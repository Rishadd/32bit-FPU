* NGSPICE file created from ALU.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_2 abstract view
.subckt sky130_fd_sc_hd__o221a_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_4 abstract view
.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_4 abstract view
.subckt sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_4 abstract view
.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_4 abstract view
.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_1 abstract view
.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_2 abstract view
.subckt sky130_fd_sc_hd__o311ai_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_1 abstract view
.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_4 abstract view
.subckt sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_4 abstract view
.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_16 abstract view
.subckt sky130_fd_sc_hd__clkinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_4 abstract view
.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_2 abstract view
.subckt sky130_fd_sc_hd__nand4b_2 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_1 abstract view
.subckt sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_4 abstract view
.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_4 abstract view
.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_4 abstract view
.subckt sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_4 abstract view
.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

.subckt ALU VGND VPWR clk i_a[0] i_a[10] i_a[11] i_a[12] i_a[13] i_a[14] i_a[15] i_a[16]
+ i_a[17] i_a[18] i_a[19] i_a[1] i_a[20] i_a[21] i_a[22] i_a[23] i_a[24] i_a[25] i_a[26]
+ i_a[27] i_a[28] i_a[29] i_a[2] i_a[30] i_a[31] i_a[3] i_a[4] i_a[5] i_a[6] i_a[7]
+ i_a[8] i_a[9] i_b[0] i_b[10] i_b[11] i_b[12] i_b[13] i_b[14] i_b[15] i_b[16] i_b[17]
+ i_b[18] i_b[19] i_b[1] i_b[20] i_b[21] i_b[22] i_b[23] i_b[24] i_b[25] i_b[26] i_b[27]
+ i_b[28] i_b[29] i_b[2] i_b[30] i_b[31] i_b[3] i_b[4] i_b[5] i_b[6] i_b[7] i_b[8]
+ i_b[9] i_vld o_res[0] o_res[10] o_res[11] o_res[12] o_res[13] o_res[14] o_res[15]
+ o_res[16] o_res[17] o_res[18] o_res[19] o_res[1] o_res[20] o_res[21] o_res[22] o_res[23]
+ o_res[24] o_res[25] o_res[26] o_res[27] o_res[28] o_res[29] o_res[2] o_res[30] o_res[31]
+ o_res[3] o_res[4] o_res[5] o_res[6] o_res[7] o_res[8] o_res[9] o_res_vld opcode
+ overflow rst
XFILLER_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09671_ _02753_ _02278_ VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__nand2_1
X_08622_ _01706_ _01707_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__nand2_1
XFILLER_54_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08553_ _01634_ _01635_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__nand2_1
XFILLER_82_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07504_ _00586_ _00582_ _00579_ _00588_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__o211ai_1
XFILLER_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08484_ _01566_ _01568_ _01562_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__a21o_1
X_07435_ _00471_ _00484_ _00482_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__a21boi_2
XFILLER_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07366_ net1043 net1038 net1419 net2193 _00451_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__o2111ai_2
X_07297_ net2080 net1509 _07026_ _07027_ VGND VGND VPWR VPWR _07068_ sky130_fd_sc_hd__a22o_1
X_09105_ _02138_ net677 _02147_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__a21oi_2
XFILLER_108_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09036_ net3024 net3131 _02104_ _02118_ _02120_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__a32oi_4
XFILLER_124_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2508 net2511 VGND VGND VPWR VPWR net2508 sky130_fd_sc_hd__clkbuf_2
XFILLER_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1807 net1808 VGND VGND VPWR VPWR net1807 sky130_fd_sc_hd__buf_1
XFILLER_89_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2519 net2520 VGND VGND VPWR VPWR net2519 sky130_fd_sc_hd__buf_4
XFILLER_132_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout842 net844 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__buf_1
Xfanout820 _01978_ VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__clkbuf_1
Xfanout831 _06784_ VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__buf_1
XFILLER_77_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09938_ _02791_ _02792_ _03020_ _03021_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__nand4_4
Xfanout1829 net1830 VGND VGND VPWR VPWR net1829 sky130_fd_sc_hd__clkbuf_4
Xfanout1818 net1823 VGND VGND VPWR VPWR net1818 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_129_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout853 net857 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__buf_1
Xfanout875 _03771_ VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__buf_2
Xfanout864 _05027_ VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__clkbuf_1
XFILLER_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout897 _02821_ VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_51_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout886 _03381_ VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__clkbuf_2
X_09869_ net1430 net2608 VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_142_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12880_ _05931_ _05932_ net239 VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__o21a_1
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11900_ _04766_ _04892_ _04891_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_142_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11831_ _04832_ _04915_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__nand2_1
X_14550_ clknet_leaf_4_clk _00080_ _00372_ VGND VGND VPWR VPWR mul_res\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13501_ net175 net525 _06524_ VGND VGND VPWR VPWR _06530_ sky130_fd_sc_hd__o21ai_4
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11762_ _04843_ _04844_ _04845_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__nand3_2
X_14481_ clknet_leaf_8_clk adder_inst.exp_larger\[7\] _00303_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[7\] sky130_fd_sc_hd__dfrtp_2
X_11693_ _04609_ _04634_ _04635_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_24_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10713_ _03742_ _03794_ _03796_ _03582_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__o22a_1
X_13432_ net2522 net515 _06460_ VGND VGND VPWR VPWR _06461_ sky130_fd_sc_hd__o21a_1
XFILLER_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10644_ _03706_ _03722_ _03726_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__o21ai_1
XFILLER_139_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13363_ _06380_ _06386_ _06383_ _06382_ VGND VGND VPWR VPWR _06392_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_42_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10575_ _03659_ _03660_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__nor2_2
XFILLER_127_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12314_ _05396_ _05397_ _05393_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__a21oi_1
Xrebuffer7 _02541_ VGND VGND VPWR VPWR net2925 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_142_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13294_ net771 net538 net1535 VGND VGND VPWR VPWR _06323_ sky130_fd_sc_hd__a21oi_1
X_12245_ _05329_ _05330_ VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__nand2_1
XFILLER_108_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12176_ net1116 net1099 VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__nor2_1
XFILLER_96_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11127_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__inv_2
XFILLER_110_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11058_ _04100_ _04104_ net870 VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_69_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10009_ _02859_ _02860_ net459 net458 VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__o211ai_1
XFILLER_36_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07220_ _06979_ _06987_ _06989_ VGND VGND VPWR VPWR _06991_ sky130_fd_sc_hd__o21ai_1
X_07151_ net2015 VGND VGND VPWR VPWR _06923_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_113_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout127 net128 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_6
Xfanout105 _05612_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_6
XFILLER_113_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout138 _06622_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_8
X_07984_ _01066_ _01067_ _01064_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__o21ai_1
Xfanout149 net150 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_8
X_09723_ net1251 net1128 net1012 net929 net814 VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__o221ai_4
XFILLER_28_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09654_ _02739_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_2_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08605_ net1253 net1188 net1040 net954 _01689_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__o221a_2
XTAP_TAPCELL_ROW_124_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09585_ _02664_ _02666_ _02667_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__nand3_1
XFILLER_43_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08536_ _01613_ _01617_ _01621_ net402 VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__o211ai_4
X_08467_ net405 net403 _01491_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_41_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07418_ _00433_ _00464_ _00485_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__nand3_2
X_08398_ net713 _01482_ net689 VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_21_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07349_ _07075_ _07068_ _07028_ VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__nand3b_1
XFILLER_136_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10360_ _03147_ net324 _03214_ _03217_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__nand4_2
XFILLER_136_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09019_ _02098_ _02102_ _02090_ _02091_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__o211a_2
X_10291_ _03369_ _03374_ _03375_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__nand3_4
XFILLER_88_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2305 net2309 VGND VGND VPWR VPWR net2305 sky130_fd_sc_hd__clkbuf_2
Xfanout2316 net2317 VGND VGND VPWR VPWR net2316 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_53_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12030_ _05095_ net3126 _05112_ VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__o21a_4
Xfanout2338 net2339 VGND VGND VPWR VPWR net2338 sky130_fd_sc_hd__buf_2
Xfanout2327 net2328 VGND VGND VPWR VPWR net2327 sky130_fd_sc_hd__clkbuf_2
XFILLER_2_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1615 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net1615 sky130_fd_sc_hd__buf_6
Xfanout1604 net1605 VGND VGND VPWR VPWR net1604 sky130_fd_sc_hd__buf_2
Xfanout2349 net2360 VGND VGND VPWR VPWR net2349 sky130_fd_sc_hd__buf_1
Xfanout1626 net1627 VGND VGND VPWR VPWR net1626 sky130_fd_sc_hd__buf_2
XFILLER_77_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout650 _03705_ VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__clkbuf_4
Xfanout1648 net1649 VGND VGND VPWR VPWR net1648 sky130_fd_sc_hd__clkbuf_2
Xfanout1637 net1638 VGND VGND VPWR VPWR net1637 sky130_fd_sc_hd__buf_4
Xfanout683 _01802_ VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__clkbuf_1
Xfanout1659 net1662 VGND VGND VPWR VPWR net1659 sky130_fd_sc_hd__buf_2
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout694 _01330_ VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__clkbuf_1
Xfanout672 _02646_ VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__buf_4
XFILLER_46_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13981_ net2804 VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__inv_2
Xfanout661 _02967_ VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__clkbuf_2
X_12932_ net2758 net1065 net747 _05977_ _05976_ VGND VGND VPWR VPWR _05978_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_109_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12863_ _05916_ _05917_ net840 VGND VGND VPWR VPWR _05918_ sky130_fd_sc_hd__and3_1
XFILLER_46_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12794_ net3328 _05851_ net2724 net1306 VGND VGND VPWR VPWR _05856_ sky130_fd_sc_hd__a2bb2o_1
X_11814_ net1147 net1136 net937 net920 _04819_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__o221ai_2
X_14533_ clknet_leaf_20_clk _00072_ _00355_ VGND VGND VPWR VPWR mul_res\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11745_ net1858 net2575 VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__nand2_1
X_14464_ clknet_leaf_6_clk _00050_ _00286_ VGND VGND VPWR VPWR add_res\[22\] sky130_fd_sc_hd__dfrtp_1
X_13415_ net373 _06233_ net252 _06220_ VGND VGND VPWR VPWR _06444_ sky130_fd_sc_hd__nand4_2
X_11676_ _04731_ _04756_ _04760_ _04761_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__o211ai_4
XFILLER_139_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14395_ clknet_leaf_15_clk net3384 _00217_ VGND VGND VPWR VPWR adder_inst.man_a_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_10_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10627_ net2322 net1867 net1898 net2296 VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__a22oi_2
X_13346_ net1091 net1274 net604 net734 net1221 VGND VGND VPWR VPWR _06375_ sky130_fd_sc_hd__a221o_1
X_10558_ _03643_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__inv_2
X_13277_ net264 _06180_ VGND VGND VPWR VPWR _06306_ sky130_fd_sc_hd__nand2_2
X_12228_ _04806_ _05308_ _05313_ VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__nand3_4
X_10489_ _03383_ net2557 net1572 net886 VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__nand4_1
Xfanout2872 net2873 VGND VGND VPWR VPWR net2872 sky130_fd_sc_hd__buf_1
Xfanout2850 net2852 VGND VGND VPWR VPWR net2850 sky130_fd_sc_hd__clkbuf_2
Xfanout2861 net2876 VGND VGND VPWR VPWR net2861 sky130_fd_sc_hd__clkbuf_1
X_12159_ _05241_ _05242_ _05239_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__nand3_4
Xfanout2883 net2886 VGND VGND VPWR VPWR net2883 sky130_fd_sc_hd__clkbuf_2
Xfanout2894 net2895 VGND VGND VPWR VPWR net2894 sky130_fd_sc_hd__buf_1
XFILLER_84_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09370_ net435 _02430_ _02451_ net815 _02374_ VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__a32o_1
X_08321_ net1556 net2401 net2432 net1527 VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__a22oi_1
X_08252_ _01334_ _01335_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__nand2_1
XFILLER_33_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07203_ net2083 net1422 net1041 _06970_ VGND VGND VPWR VPWR _06974_ sky130_fd_sc_hd__a22o_1
XFILLER_118_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08183_ _01231_ net475 _01266_ _01261_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__o2bb2a_4
XTAP_TAPCELL_ROW_95_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07134_ net2631 VGND VGND VPWR VPWR _06906_ sky130_fd_sc_hd__inv_2
XFILLER_134_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07967_ _01051_ _01052_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__nand2_1
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09706_ _02786_ _02789_ _02790_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__nand3_4
X_07898_ net2215 net1592 VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__nand2_1
XFILLER_74_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09637_ _02251_ _02253_ _02254_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__a21oi_2
XFILLER_82_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09568_ net461 net588 _02653_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__a21oi_1
XFILLER_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08519_ _01524_ _01521_ _01523_ _01600_ _01601_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__o2111ai_2
X_09499_ _02105_ _02123_ net3108 _02581_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__o211a_1
X_11530_ net416 _04615_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__nor2_4
XFILLER_135_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11461_ _04543_ _04504_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__nand2_2
XFILLER_136_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14180_ net2858 VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__inv_2
X_13200_ net790 net301 _06228_ VGND VGND VPWR VPWR _06230_ sky130_fd_sc_hd__o21ai_2
X_10412_ net806 net891 net1226 net1126 VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__o2bb2ai_4
X_11392_ net868 _04139_ _04140_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__nand3b_1
XFILLER_137_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13131_ net1893 net499 _06160_ VGND VGND VPWR VPWR _06161_ sky130_fd_sc_hd__o21ai_1
X_10343_ net3039 _03355_ net3150 _03350_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__a31o_1
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2135 net2137 VGND VGND VPWR VPWR net2135 sky130_fd_sc_hd__clkbuf_2
Xfanout2113 net2114 VGND VGND VPWR VPWR net2113 sky130_fd_sc_hd__buf_1
Xfanout2124 net2127 VGND VGND VPWR VPWR net2124 sky130_fd_sc_hd__buf_1
Xfanout2102 net2103 VGND VGND VPWR VPWR net2102 sky130_fd_sc_hd__dlymetal6s2s_1
X_13062_ _06052_ _06053_ net861 net783 VGND VGND VPWR VPWR _06092_ sky130_fd_sc_hd__a211o_1
XFILLER_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10274_ _03359_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__inv_2
XFILLER_120_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1423 net1424 VGND VGND VPWR VPWR net1423 sky130_fd_sc_hd__clkbuf_1
Xfanout1401 net1402 VGND VGND VPWR VPWR net1401 sky130_fd_sc_hd__buf_1
Xfanout2157 net2159 VGND VGND VPWR VPWR net2157 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2146 net2147 VGND VGND VPWR VPWR net2146 sky130_fd_sc_hd__clkbuf_1
Xfanout1412 net1413 VGND VGND VPWR VPWR net1412 sky130_fd_sc_hd__buf_1
X_12013_ net1157 net1100 _05096_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__o21a_1
Xfanout1456 net1457 VGND VGND VPWR VPWR net1456 sky130_fd_sc_hd__buf_1
Xfanout1445 net1458 VGND VGND VPWR VPWR net1445 sky130_fd_sc_hd__clkbuf_2
Xfanout2179 net2180 VGND VGND VPWR VPWR net2179 sky130_fd_sc_hd__clkbuf_2
Xfanout1434 net1439 VGND VGND VPWR VPWR net1434 sky130_fd_sc_hd__clkbuf_2
Xfanout1478 net1480 VGND VGND VPWR VPWR net1478 sky130_fd_sc_hd__buf_1
Xfanout1489 net1490 VGND VGND VPWR VPWR net1489 sky130_fd_sc_hd__clkbuf_2
Xfanout491 net496 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout480 net482 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__clkbuf_2
Xfanout1467 net1469 VGND VGND VPWR VPWR net1467 sky130_fd_sc_hd__clkbuf_1
X_13964_ net3430 mul_res\[28\] net2790 VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__mux2_1
X_13895_ _06847_ _06846_ VGND VGND VPWR VPWR multiplier_inst.man_final\[10\] sky130_fd_sc_hd__nor2_1
X_12915_ net2772 _05836_ _05960_ _05962_ VGND VGND VPWR VPWR _05963_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_100_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12846_ net2785 net2726 _05804_ net2788 net2716 VGND VGND VPWR VPWR _05903_ sky130_fd_sc_hd__a221o_1
XFILLER_64_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_751 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14516_ clknet_leaf_1_clk multiplier_inst.man_final\[16\] _00338_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[16\] sky130_fd_sc_hd__dfrtp_1
X_12777_ net1081 net1067 net1310 _05838_ VGND VGND VPWR VPWR _05839_ sky130_fd_sc_hd__a211o_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11728_ _04809_ _04243_ _04813_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__o21ai_4
X_14447_ clknet_leaf_4_clk _00063_ _00269_ VGND VGND VPWR VPWR add_res\[5\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11659_ _04744_ _04741_ _04743_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__nand3_1
XFILLER_128_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14378_ clknet_leaf_12_clk net3342 _00200_ VGND VGND VPWR VPWR adder_inst.man_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_12_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13329_ _06350_ net488 _06353_ _06352_ VGND VGND VPWR VPWR _06358_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_77_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08870_ _01758_ _01762_ _01760_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_90_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07821_ net598 _00752_ net599 _00730_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__o211ai_1
XFILLER_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2680 net2681 VGND VGND VPWR VPWR net2680 sky130_fd_sc_hd__clkbuf_1
Xfanout2691 net2694 VGND VGND VPWR VPWR net2691 sky130_fd_sc_hd__buf_1
X_07752_ net1562 net2216 VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__nand2_1
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1990 net1991 VGND VGND VPWR VPWR net1990 sky130_fd_sc_hd__clkbuf_1
X_07683_ _00766_ _00768_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__nor2_1
XFILLER_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_121_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09422_ _02504_ _02507_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__nor2_2
X_09353_ _02332_ _02437_ _02438_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__nand3_1
XFILLER_40_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08304_ _01388_ net592 _01389_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__a21oi_2
X_09284_ _02366_ net353 _02336_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__a21oi_2
XFILLER_33_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08235_ net2200 net1800 net1831 net2174 VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__a22o_1
XFILLER_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08166_ _01244_ _01250_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__nand2_1
X_07117_ net2329 VGND VGND VPWR VPWR _06889_ sky130_fd_sc_hd__inv_2
XFILLER_133_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08097_ _01179_ net941 net2066 net1853 VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__o211a_1
XFILLER_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08999_ _01753_ _02080_ net192 VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__and3_1
XFILLER_29_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10961_ _04039_ _04041_ _04042_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__nand3_2
X_13680_ _06425_ _06428_ _06694_ VGND VGND VPWR VPWR _06697_ sky130_fd_sc_hd__a21o_1
X_12700_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _05770_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_48_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12631_ _05531_ _05532_ _05664_ _05710_ VGND VGND VPWR VPWR _05711_ sky130_fd_sc_hd__nand4_1
X_10892_ _03715_ _03717_ net650 _03707_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__o211ai_4
XFILLER_71_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12562_ net2009 net1281 VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__nand2b_4
XFILLER_129_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12493_ _05323_ _05425_ _05426_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__o21ai_2
X_14301_ clknet_leaf_17_clk net7 _00123_ VGND VGND VPWR VPWR adder_inst.i_a\[15\]
+ sky130_fd_sc_hd__dfrtp_1
X_11513_ _04540_ _04567_ _04594_ _04595_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__o211ai_4
X_14232_ net2906 VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__inv_2
Xwire166 _06616_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_1
X_11444_ _04523_ _04037_ _04522_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__a21oi_1
XFILLER_137_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14163_ net2862 VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__inv_2
X_11375_ _04427_ _04429_ _04430_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_59_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13114_ _06142_ net3294 _06143_ VGND VGND VPWR VPWR _06144_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_59_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14094_ net2839 VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__inv_2
X_10326_ _03408_ _03407_ _03406_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__nand3_4
XFILLER_124_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13045_ net1997 net1085 net606 net731 VGND VGND VPWR VPWR _06075_ sky130_fd_sc_hd__o22ai_4
X_10257_ _03103_ _03104_ _03105_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__a21bo_1
Xfanout1231 net1232 VGND VGND VPWR VPWR net1231 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1220 net1221 VGND VGND VPWR VPWR net1220 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_72_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1242 net1244 VGND VGND VPWR VPWR net1242 sky130_fd_sc_hd__clkbuf_2
Xfanout1253 net1254 VGND VGND VPWR VPWR net1253 sky130_fd_sc_hd__buf_1
X_10188_ _03265_ _03271_ _03272_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__nand3_2
Xfanout1264 net1265 VGND VGND VPWR VPWR net1264 sky130_fd_sc_hd__buf_2
Xfanout1297 net1298 VGND VGND VPWR VPWR net1297 sky130_fd_sc_hd__clkbuf_1
XFILLER_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1275 net1276 VGND VGND VPWR VPWR net1275 sky130_fd_sc_hd__buf_1
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13947_ add_res\[11\] net3488 net2794 VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__mux2_1
XFILLER_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13878_ net130 _05569_ _06834_ _06831_ VGND VGND VPWR VPWR _06836_ sky130_fd_sc_hd__o211a_1
XFILLER_62_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12829_ net239 _05784_ VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__and2_4
XFILLER_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08020_ _01087_ _01089_ _01091_ _01103_ _01105_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__a32oi_2
XFILLER_116_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09971_ _03052_ net1842 net2261 net895 VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__and4_1
XFILLER_103_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08922_ net2046 net2021 net1807 net1838 VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__nand4_2
XFILLER_69_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08853_ _01768_ _01780_ net3076 _01935_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__o211ai_4
XFILLER_29_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07804_ net1047 net981 _00888_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__o21ai_1
X_08784_ _01865_ _01866_ _01867_ _01658_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__o2bb2ai_4
X_07735_ _00809_ _00807_ _00812_ _00811_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__a211o_1
XFILLER_44_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07666_ _00742_ _00743_ net829 _00749_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__a22oi_2
X_09405_ _02390_ _02392_ _02415_ _02418_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_36_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07597_ _00682_ _00601_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__nand2_1
XFILLER_111_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09336_ _02393_ _02394_ _02415_ _02417_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__o22ai_1
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09267_ net969 _00985_ _02351_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_134_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08218_ net1250 net1154 net1012 net959 _01302_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__o221a_1
X_09198_ net332 net331 _01550_ _01552_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__nand4_2
X_08149_ net1590 net2316 VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__nand2_1
XFILLER_134_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11160_ net2479 net1855 VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__nand2_1
XFILLER_136_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10111_ net1433 net1463 net2610 net2637 VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__nand4_2
X_11091_ _04146_ _03840_ _03839_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_112_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10042_ _03124_ _02888_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__nand2_1
XFILLER_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13801_ net3389 net727 VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__and2_1
XFILLER_75_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13732_ net850 _06738_ _06739_ _06742_ VGND VGND VPWR VPWR _06743_ sky130_fd_sc_hd__o31a_1
X_11993_ net1962 net2572 net1990 net2542 VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__a22oi_1
XFILLER_17_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10944_ _04027_ _04028_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__nand2_1
XFILLER_16_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13663_ _06681_ net3276 VGND VGND VPWR VPWR adder_inst.sum_raw\[10\] sky130_fd_sc_hd__xnor2_2
X_10875_ net1220 net1130 _03957_ VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_14_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13594_ net3503 net3502 _06622_ VGND VGND VPWR VPWR adder_inst.sign_sum sky130_fd_sc_hd__mux2_4
X_12614_ _05695_ VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_14_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12545_ net147 _05630_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__nand2_1
XFILLER_101_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12476_ net2919 _05427_ VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__xor2_2
X_14215_ net2857 VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__inv_2
XANTENNA_5 _06821_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11427_ _04060_ _04061_ net1771 net2509 VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__nand4_1
X_14146_ net2910 VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__inv_2
XFILLER_98_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11358_ _04438_ _04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__or2_1
XFILLER_140_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10309_ net1520 net2620 VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__nand2_1
XFILLER_140_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14077_ net2822 VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__inv_2
X_11289_ net961 net919 net1856 net2513 _04371_ VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__o2111ai_4
XFILLER_140_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13028_ _06045_ net3171 _06052_ net3177 VGND VGND VPWR VPWR _06058_ sky130_fd_sc_hd__a22oi_4
Xfanout1061 _06921_ VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1072 _06918_ VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__buf_4
Xfanout1083 _06911_ VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1050 _06959_ VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__clkbuf_1
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer17 _06297_ VGND VGND VPWR VPWR net2935 sky130_fd_sc_hd__dlygate4sd1_1
Xfanout1094 net1095 VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__clkbuf_1
Xrebuffer39 _01865_ VGND VGND VPWR VPWR net2957 sky130_fd_sc_hd__buf_1
X_07520_ net2101 net1632 net1666 net2065 VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__a22oi_1
Xrebuffer28 _03069_ VGND VGND VPWR VPWR net2946 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_85_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07451_ net2160 net1534 net1563 net2132 VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_85_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07382_ net2082 net1597 VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__nand2_1
X_09121_ _02161_ _02163_ net400 _02206_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__a2bb2oi_2
Xrebuffer129 net2958 VGND VGND VPWR VPWR net3047 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer107 _04169_ VGND VGND VPWR VPWR net3025 sky130_fd_sc_hd__clkbuf_1
Xrebuffer118 _04235_ VGND VGND VPWR VPWR net3036 sky130_fd_sc_hd__buf_2
XFILLER_135_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09052_ net992 net949 _02137_ _02135_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_116_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold500 add_res\[29\] VGND VGND VPWR VPWR net3418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold511 _00015_ VGND VGND VPWR VPWR net3429 sky130_fd_sc_hd__dlygate4sd3_1
X_08003_ net2040 net2017 net1928 net1947 VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__nand4_4
Xhold533 add_res\[15\] VGND VGND VPWR VPWR net3451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold522 add_res\[21\] VGND VGND VPWR VPWR net3440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold544 adder_inst.i_a\[14\] VGND VGND VPWR VPWR net3462 sky130_fd_sc_hd__dlygate4sd3_1
Xhold555 mul_res\[9\] VGND VGND VPWR VPWR net3473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold566 _00011_ VGND VGND VPWR VPWR net3484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold577 multiplier_inst.man_final_r\[18\] VGND VGND VPWR VPWR net3495 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09954_ net1035 net927 net2179 net1925 _02802_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__o2111ai_4
X_08905_ _01985_ _01987_ _01972_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__a21oi_2
X_09885_ net896 _02953_ net662 _02967_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__o211ai_2
X_08836_ _01913_ _01918_ _01921_ _01755_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__o211ai_4
X_08767_ net2121 net2152 net1713 net1750 VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__nand4_2
X_07718_ _00802_ _00803_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__nand2_1
XFILLER_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08698_ _01584_ _01601_ _01599_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__a21oi_2
XFILLER_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07649_ net1483 net2244 net2278 net1448 VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_0_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10660_ net2387 net1791 net2418 net1820 VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__nand4_4
X_09319_ _02402_ _00994_ _02398_ _02401_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__o211ai_2
X_10591_ net3085 net580 _03460_ _03461_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_40_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12330_ _05401_ _05415_ VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__nand2_1
XFILLER_5_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12261_ _05332_ _05336_ _05337_ _05343_ VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__a31o_1
XFILLER_5_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14000_ net2837 VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__inv_2
X_11212_ _04295_ _04297_ _04292_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_56_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12192_ _05275_ _05277_ _05241_ _05242_ VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__nand4_1
Xoutput75 net75 VGND VGND VPWR VPWR o_res[16] sky130_fd_sc_hd__buf_2
X_11143_ _04221_ _04224_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__nand2_2
Xoutput97 net97 VGND VGND VPWR VPWR o_res[7] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR o_res[26] sky130_fd_sc_hd__buf_2
X_11074_ _04156_ _04157_ net639 VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__and3_1
XFILLER_1_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10025_ net1206 net1173 net972 _01397_ net809 VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__o221ai_2
XFILLER_102_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11976_ net552 _04972_ _04965_ _04967_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__o211ai_1
X_13715_ _06359_ _06360_ _06725_ VGND VGND VPWR VPWR _06728_ sky130_fd_sc_hd__a21boi_1
X_10927_ net2297 net2325 net1953 net1979 VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__nand4_4
X_13646_ _06665_ _06666_ VGND VGND VPWR VPWR _06667_ sky130_fd_sc_hd__and2_1
XFILLER_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10858_ _03937_ _03938_ _03939_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__nand3_2
X_13577_ net188 _06273_ _06274_ VGND VGND VPWR VPWR _06606_ sky130_fd_sc_hd__a21oi_1
XFILLER_9_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10789_ net205 _03872_ net204 VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__a21boi_2
X_12528_ _05441_ _05486_ _05485_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__a21oi_1
XFILLER_117_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12459_ _05318_ _05544_ VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__xnor2_4
XFILLER_132_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14129_ net2906 VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__inv_2
XFILLER_113_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09670_ _02271_ _02276_ net3148 _02214_ net329 VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_87_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08621_ _01679_ _01680_ _01704_ _01705_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__o211ai_4
XFILLER_55_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08552_ net2236 net1657 net2274 net1622 VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__a22oi_1
X_07503_ _00577_ net412 _00517_ _00508_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__nand4_2
X_08483_ net1266 net1162 net1045 net922 _01568_ VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__o221ai_2
X_07434_ _00477_ _00480_ _00484_ _00471_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_46_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07365_ _00448_ _00449_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__nand2_1
X_07296_ _07066_ VGND VGND VPWR VPWR _07067_ sky130_fd_sc_hd__inv_2
XFILLER_109_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09104_ net2938 _02143_ net2960 net678 _02139_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_98_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09035_ _02118_ _02120_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__nand2_1
XFILLER_123_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2509 net2510 VGND VGND VPWR VPWR net2509 sky130_fd_sc_hd__clkbuf_1
Xfanout843 net844 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__buf_1
Xfanout832 _06784_ VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__buf_1
Xfanout1808 net1809 VGND VGND VPWR VPWR net1808 sky130_fd_sc_hd__clkbuf_1
Xfanout821 _01746_ VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__clkbuf_2
X_09937_ _02791_ _02792_ _03020_ _03021_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__and4_1
Xfanout810 _02842_ VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__clkbuf_2
Xfanout1819 net1823 VGND VGND VPWR VPWR net1819 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_129_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout854 net855 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__buf_1
Xfanout865 _04285_ VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__buf_6
Xfanout876 _03747_ VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__buf_1
XFILLER_133_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout887 _03381_ VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__buf_1
Xfanout898 _02699_ VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_4
X_09868_ net896 _02953_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_142_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08819_ _01871_ _01902_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__nand2_1
X_09799_ _02873_ _02874_ _02882_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_142_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11830_ net1915 net2539 net2575 net1890 VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__a22oi_1
XFILLER_54_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11761_ _04679_ _04680_ _04688_ _04690_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__nand4_1
XFILLER_14_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13500_ net252 net193 _06528_ _06527_ VGND VGND VPWR VPWR _06529_ sky130_fd_sc_hd__o211ai_4
X_10712_ _03583_ _03797_ _03795_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__nand3_2
XFILLER_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14480_ clknet_leaf_9_clk adder_inst.exp_larger\[6\] _00302_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11692_ _04771_ _04773_ _04769_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__nand3_4
XFILLER_14_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13431_ net780 net546 net1840 VGND VGND VPWR VPWR _06460_ sky130_fd_sc_hd__a21o_1
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10643_ _03728_ _03723_ _03727_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__nand3_4
X_13362_ _06380_ _06384_ _06386_ VGND VGND VPWR VPWR _06391_ sky130_fd_sc_hd__or3_1
X_10574_ net2923 _03603_ _03656_ _03658_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__o211ai_4
X_12313_ _05396_ _05397_ _05393_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__and3_1
Xrebuffer8 net148 VGND VGND VPWR VPWR net2926 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_6_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13293_ net379 net310 net225 _06207_ VGND VGND VPWR VPWR _06322_ sky130_fd_sc_hd__or4_2
XFILLER_142_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12244_ _05325_ _05326_ _02504_ _02507_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__o2bb2ai_1
X_12175_ net1116 net1105 net1099 net1124 VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__o22a_1
XFILLER_95_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11126_ _04177_ net419 net421 VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__a21bo_1
XFILLER_110_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11057_ net867 _04142_ net1552 net2671 VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__nand4b_4
XFILLER_91_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_69_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10008_ _02862_ net458 net459 VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_69_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11959_ _05042_ _05023_ net446 VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__o21ai_2
XFILLER_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13629_ _06645_ _06493_ _06507_ _06638_ _06494_ VGND VGND VPWR VPWR _06652_ sky130_fd_sc_hd__o221a_4
XFILLER_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07150_ adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR _06922_ sky130_fd_sc_hd__inv_2
XFILLER_9_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout117 _05560_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_6
Xfanout128 _05527_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_8
XFILLER_114_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07983_ _00935_ _01065_ _01068_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__o21ai_1
X_09722_ net1251 net1128 net1012 net927 net814 VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__o221a_1
XFILLER_95_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09653_ _02243_ _02707_ _02704_ _02737_ _02709_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__a32o_1
X_08604_ _01686_ _01687_ net1040 net954 VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__o2bb2ai_1
X_09584_ _02161_ _02163_ net3053 _02205_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__o211ai_2
XFILLER_43_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08535_ _01540_ _01620_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__nor2_1
XFILLER_43_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08466_ net437 _01489_ net406 _01548_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__nand4_1
X_07417_ _00501_ net616 VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__nand2_1
X_08397_ net713 net689 _01482_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__a21oi_2
X_07348_ _00429_ _00432_ _00422_ VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_21_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07279_ net601 _07049_ VGND VGND VPWR VPWR _07050_ sky130_fd_sc_hd__nand2_1
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09018_ _02097_ _02101_ _02098_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__a21oi_4
X_10290_ _03369_ _03374_ _03375_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__and3_4
Xfanout2306 net2308 VGND VGND VPWR VPWR net2306 sky130_fd_sc_hd__clkbuf_2
XFILLER_88_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2317 net2319 VGND VGND VPWR VPWR net2317 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2339 adder_inst.man_a_r\[12\] VGND VGND VPWR VPWR net2339 sky130_fd_sc_hd__buf_6
Xfanout2328 net2329 VGND VGND VPWR VPWR net2328 sky130_fd_sc_hd__clkbuf_2
Xfanout1605 net1606 VGND VGND VPWR VPWR net1605 sky130_fd_sc_hd__clkbuf_2
XFILLER_132_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1627 net1628 VGND VGND VPWR VPWR net1627 sky130_fd_sc_hd__clkbuf_2
Xfanout1616 net1618 VGND VGND VPWR VPWR net1616 sky130_fd_sc_hd__clkbuf_2
Xfanout1638 net1642 VGND VGND VPWR VPWR net1638 sky130_fd_sc_hd__buf_2
Xfanout640 _04099_ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__clkbuf_2
Xfanout1649 net1650 VGND VGND VPWR VPWR net1649 sky130_fd_sc_hd__clkbuf_2
Xfanout651 _03540_ VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__buf_2
Xfanout673 _02645_ VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__buf_4
X_13980_ net2804 VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__inv_2
Xfanout662 _02965_ VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__clkbuf_2
X_12931_ net2755 net1059 net2756 net739 net841 VGND VGND VPWR VPWR _05977_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_109_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout695 _01256_ VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__buf_6
XFILLER_74_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_749 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12862_ net1055 net2774 net2777 net736 VGND VGND VPWR VPWR _05917_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_109_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11813_ _04896_ _04820_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__nand2_1
X_12793_ _05853_ net846 net2746 _05804_ _05852_ VGND VGND VPWR VPWR _05855_ sky130_fd_sc_hd__a32o_1
XFILLER_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14532_ clknet_leaf_7_clk net722 _00354_ VGND VGND VPWR VPWR mul_ovf sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11744_ _04824_ _04825_ _04822_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__nand3_2
X_14463_ clknet_leaf_5_clk _00049_ _00285_ VGND VGND VPWR VPWR add_res\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11675_ _04466_ _04467_ net625 _04416_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__a22o_1
XFILLER_128_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13414_ net1091 net1274 net603 net734 net2457 VGND VGND VPWR VPWR _06443_ sky130_fd_sc_hd__a221o_1
X_10626_ net2295 net2322 net1867 net1898 VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__nand4_1
XFILLER_139_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14394_ clknet_leaf_10_clk net3378 _00216_ VGND VGND VPWR VPWR adder_inst.man_a_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_127_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13345_ net2000 net1088 net730 net605 net1220 VGND VGND VPWR VPWR _06374_ sky130_fd_sc_hd__o221a_1
XFILLER_10_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10557_ _03639_ _03640_ _03638_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__nand3_2
X_13276_ net340 net359 _06183_ net363 VGND VGND VPWR VPWR _06305_ sky130_fd_sc_hd__and4_1
Xrebuffer290 adder_inst.exp_a_r\[7\] VGND VGND VPWR VPWR net3208 sky130_fd_sc_hd__dlygate4sd1_1
X_10488_ _03383_ net2557 net1572 net886 VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__and4_1
XFILLER_142_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12227_ _04778_ _04779_ _05311_ _05312_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__o211a_4
XFILLER_68_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2851 net2852 VGND VGND VPWR VPWR net2851 sky130_fd_sc_hd__buf_1
Xfanout2873 net2874 VGND VGND VPWR VPWR net2873 sky130_fd_sc_hd__clkbuf_1
Xfanout2862 net2863 VGND VGND VPWR VPWR net2862 sky130_fd_sc_hd__clkbuf_2
XFILLER_68_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2840 net2844 VGND VGND VPWR VPWR net2840 sky130_fd_sc_hd__buf_2
X_12158_ _05241_ _05242_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__nand2_2
Xfanout2884 net2885 VGND VGND VPWR VPWR net2884 sky130_fd_sc_hd__clkbuf_2
Xfanout2895 net2896 VGND VGND VPWR VPWR net2895 sky130_fd_sc_hd__buf_1
X_11109_ _04186_ _04188_ net3047 _04170_ net2995 VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__o221ai_4
X_12089_ _05093_ _05173_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__nand2_1
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08320_ net1556 net2402 VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__nand2_1
XFILLER_33_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08251_ net694 _01332_ _01323_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__a21oi_1
XFILLER_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07202_ net1041 _06970_ net1271 net1267 VGND VGND VPWR VPWR _06973_ sky130_fd_sc_hd__o2bb2a_1
X_08182_ _01232_ net473 VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_95_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07133_ net2603 VGND VGND VPWR VPWR _06905_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07966_ _01046_ _01049_ _01050_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__nand3_1
XFILLER_87_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09705_ _02786_ _02788_ _02787_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__nand3b_4
XFILLER_56_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07897_ net2158 net2186 net1626 net1659 VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__nand4_1
X_09636_ _02721_ _02718_ _02720_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09567_ net673 _02651_ net672 VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_104_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08518_ _01600_ _01601_ _01585_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__a21o_1
X_09498_ net3110 net3093 _02117_ _02119_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__o2bb2ai_4
X_08449_ _01534_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__inv_2
XFILLER_128_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11460_ _04500_ _04501_ _04541_ net344 VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__a22o_1
XFILLER_109_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10411_ net806 net890 _03262_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__a21o_1
X_11391_ net867 _04138_ _04141_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13130_ net776 net543 net2577 VGND VGND VPWR VPWR _06160_ sky130_fd_sc_hd__a21o_1
X_10342_ _03208_ _03209_ _03193_ _03194_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__o211ai_4
XFILLER_136_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13061_ _06079_ _06080_ _06087_ _06088_ VGND VGND VPWR VPWR _06091_ sky130_fd_sc_hd__nand4_4
Xfanout2103 net2104 VGND VGND VPWR VPWR net2103 sky130_fd_sc_hd__buf_1
Xfanout2125 net2126 VGND VGND VPWR VPWR net2125 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2114 adder_inst.man_a_r\[20\] VGND VGND VPWR VPWR net2114 sky130_fd_sc_hd__buf_2
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10273_ net579 net576 _03350_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__a21o_1
X_12012_ _05097_ _05096_ _05092_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__a21oi_4
Xfanout2136 net2137 VGND VGND VPWR VPWR net2136 sky130_fd_sc_hd__buf_1
XFILLER_105_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2158 net2159 VGND VGND VPWR VPWR net2158 sky130_fd_sc_hd__buf_2
Xfanout1402 net1403 VGND VGND VPWR VPWR net1402 sky130_fd_sc_hd__clkbuf_2
Xfanout2147 net2151 VGND VGND VPWR VPWR net2147 sky130_fd_sc_hd__buf_1
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1413 net1429 VGND VGND VPWR VPWR net1413 sky130_fd_sc_hd__buf_2
XFILLER_120_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1424 net1425 VGND VGND VPWR VPWR net1424 sky130_fd_sc_hd__buf_2
Xfanout1446 net1451 VGND VGND VPWR VPWR net1446 sky130_fd_sc_hd__buf_1
Xfanout1457 net1458 VGND VGND VPWR VPWR net1457 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1435 net1438 VGND VGND VPWR VPWR net1435 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1479 net1480 VGND VGND VPWR VPWR net1479 sky130_fd_sc_hd__clkbuf_1
Xfanout492 net496 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__clkbuf_1
Xfanout470 _01608_ VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__clkbuf_2
Xfanout481 net482 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__buf_1
XFILLER_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1468 net1469 VGND VGND VPWR VPWR net1468 sky130_fd_sc_hd__dlymetal6s2s_1
X_13963_ net3424 mul_res\[27\] net2799 VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__mux2_1
XFILLER_93_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13894_ _05576_ _05585_ _06845_ VGND VGND VPWR VPWR _06847_ sky130_fd_sc_hd__and3_1
X_12914_ net2765 net1078 net1064 _05961_ VGND VGND VPWR VPWR _05962_ sky130_fd_sc_hd__o211a_1
XFILLER_62_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12845_ net1083 net2775 net2776 net751 VGND VGND VPWR VPWR _05902_ sky130_fd_sc_hd__o22a_1
X_12776_ net2724 net2738 net2718 net1069 VGND VGND VPWR VPWR _05838_ sky130_fd_sc_hd__o31a_1
XFILLER_15_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14515_ clknet_leaf_4_clk multiplier_inst.man_final\[15\] _00337_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11727_ net3014 _04812_ _03690_ net1146 _04810_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__a41oi_4
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14446_ clknet_leaf_4_clk _00062_ _00268_ VGND VGND VPWR VPWR add_res\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_128_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11658_ net1646 net2669 _04463_ _04464_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__a22o_1
X_10609_ net2266 net1946 net1972 net2251 VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__a22oi_4
X_14377_ clknet_leaf_12_clk net3345 _00199_ VGND VGND VPWR VPWR adder_inst.man_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_11589_ net1123 net1116 net916 _04354_ _04355_ VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_12_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap615 _00874_ VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__clkbuf_1
X_13328_ _06344_ _06356_ _06345_ VGND VGND VPWR VPWR _06357_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_77_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13259_ _06243_ net3192 net2137 net522 VGND VGND VPWR VPWR _06288_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07820_ _00755_ _00730_ net600 VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__nand3_1
Xfanout2681 net2682 VGND VGND VPWR VPWR net2681 sky130_fd_sc_hd__clkbuf_2
Xfanout2670 net2671 VGND VGND VPWR VPWR net2670 sky130_fd_sc_hd__clkbuf_1
Xfanout2692 net2694 VGND VGND VPWR VPWR net2692 sky130_fd_sc_hd__dlymetal6s2s_1
X_07751_ net1529 net2240 VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__nand2_1
Xfanout1980 net1981 VGND VGND VPWR VPWR net1980 sky130_fd_sc_hd__clkbuf_2
Xfanout1991 net1992 VGND VGND VPWR VPWR net1991 sky130_fd_sc_hd__buf_1
X_07682_ net986 net1689 net2074 VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__nand3_1
XFILLER_92_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09421_ _02506_ _02496_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__nand2_1
XFILLER_80_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09352_ _02435_ _02436_ _02333_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__nand3_4
XFILLER_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08303_ _01361_ _01373_ net593 _01383_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__a2bb2oi_1
X_09283_ _02019_ _02062_ _02368_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__a21oi_4
X_08234_ net2200 net1800 net1832 net2174 VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_119_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08165_ net1229 net1214 net996 net977 _01249_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__o221ai_2
XTAP_TAPCELL_ROW_31_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07116_ net1676 VGND VGND VPWR VPWR _06888_ sky130_fd_sc_hd__inv_4
XFILLER_118_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08096_ net2066 net1853 _01179_ net941 VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__a211oi_1
XFILLER_69_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08998_ _01926_ _01931_ _02082_ _02083_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__o211ai_4
XFILLER_48_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07949_ _01028_ net702 _01016_ _01017_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__a211oi_1
XFILLER_75_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10960_ _04039_ _04042_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__nand2_2
XFILLER_18_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09619_ _02230_ _02231_ _02237_ _02240_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_39_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10891_ net3030 _03707_ _03719_ _03720_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__o2bb2ai_4
X_12630_ _05695_ net444 VGND VGND VPWR VPWR _05710_ sky130_fd_sc_hd__nor2_1
XFILLER_71_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12561_ net2009 net1282 VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_61_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12492_ net141 net314 _05562_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__nand3_1
X_14300_ clknet_leaf_17_clk net6 _00122_ VGND VGND VPWR VPWR adder_inst.i_a\[14\]
+ sky130_fd_sc_hd__dfrtp_2
X_11512_ _04540_ _04567_ _04596_ _04597_ VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__a2bb2oi_2
X_14231_ net2893 VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__inv_2
X_11443_ _04528_ _04522_ _04527_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__nand3_1
XFILLER_7_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14162_ net2862 VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__inv_2
XFILLER_50_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire167 _05307_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_6
XFILLER_109_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13113_ net3294 _06141_ VGND VGND VPWR VPWR _06143_ sky130_fd_sc_hd__nand2_4
X_11374_ _04427_ _04429_ _04430_ VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__a21o_1
XFILLER_113_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14093_ net2826 VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__inv_2
X_10325_ _03406_ _03407_ _03408_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__and3_1
XFILLER_124_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13044_ net1090 net1272 net603 net733 VGND VGND VPWR VPWR _06074_ sky130_fd_sc_hd__a22oi_4
X_10256_ net1697 net1729 net2376 net2405 _03105_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__a41o_1
XFILLER_121_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1221 _06887_ VGND VGND VPWR VPWR net1221 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_72_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1232 _06884_ VGND VGND VPWR VPWR net1232 sky130_fd_sc_hd__buf_2
Xfanout1210 net1211 VGND VGND VPWR VPWR net1210 sky130_fd_sc_hd__clkbuf_1
Xfanout1243 net1244 VGND VGND VPWR VPWR net1243 sky130_fd_sc_hd__buf_1
Xfanout1254 net1258 VGND VGND VPWR VPWR net1254 sky130_fd_sc_hd__clkbuf_2
X_10187_ net806 _03263_ _03266_ _03033_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__a22oi_1
Xfanout1265 net1268 VGND VGND VPWR VPWR net1265 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1287 adder_inst.exp_larger_r\[6\] VGND VGND VPWR VPWR net1287 sky130_fd_sc_hd__buf_1
Xfanout1298 net1302 VGND VGND VPWR VPWR net1298 sky130_fd_sc_hd__buf_1
Xfanout1276 adder_inst.exp_b_r\[6\] VGND VGND VPWR VPWR net1276 sky130_fd_sc_hd__buf_1
X_13946_ net3446 mul_res\[10\] net2794 VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__mux2_1
XFILLER_93_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13877_ _06833_ _06834_ _06831_ VGND VGND VPWR VPWR _06835_ sky130_fd_sc_hd__a21oi_1
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12828_ net1324 _05889_ net1320 VGND VGND VPWR VPWR _05890_ sky130_fd_sc_hd__nor3b_4
XTAP_TAPCELL_ROW_17_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12759_ net2775 net2767 net2769 net2763 VGND VGND VPWR VPWR _05821_ sky130_fd_sc_hd__or4_1
XFILLER_30_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14429_ clknet_leaf_14_clk net3339 _00251_ VGND VGND VPWR VPWR adder_inst.man_b_r\[19\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_30_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09970_ net895 net893 net1223 net1151 VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_131_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08921_ net2021 net1837 VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__nand2_1
XFILLER_124_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08852_ net356 _01936_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__nand2_2
XFILLER_69_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07803_ net1260 net1215 net1047 net981 VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__o22a_1
X_08783_ _01659_ _01643_ _01865_ _01866_ net688 VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__o2111ai_4
XFILLER_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07734_ _00810_ _00811_ _00812_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__o21ai_1
XFILLER_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07665_ _00741_ _00750_ _00744_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__nor3_2
X_09404_ _02485_ _02486_ _02460_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__nand3_2
XFILLER_52_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07596_ _00678_ _00679_ _00662_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__nand3_2
XFILLER_111_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09335_ _02390_ _02392_ _02418_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_101_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09266_ _00982_ net969 net2214 net1592 VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__and4_1
XFILLER_21_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08217_ _01299_ _01300_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__nand2_1
XFILLER_119_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09197_ _02281_ _01556_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__nand2_2
XFILLER_134_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08148_ net714 net698 net700 VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__a21boi_1
X_08079_ net2116 net1803 net1834 net2095 VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__a22o_1
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10110_ net1464 net2611 net2636 net1434 VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__a22o_1
X_11090_ _04167_ _04168_ _04169_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__nand3_4
XFILLER_121_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10041_ _02886_ _02887_ _02884_ net664 VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13800_ net3491 net727 VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__and2_1
XFILLER_91_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11992_ net1964 net2571 VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__nand2_1
X_13731_ net850 _06741_ VGND VGND VPWR VPWR _06742_ sky130_fd_sc_hd__nand2_1
XFILLER_90_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10943_ net2390 net1870 net1898 net2355 VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__a22oi_4
X_13662_ net762 _06679_ _06680_ VGND VGND VPWR VPWR _06681_ sky130_fd_sc_hd__o21ai_2
X_10874_ _03957_ _03697_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__nand2_1
XFILLER_43_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13593_ net149 net158 VGND VGND VPWR VPWR _06622_ sky130_fd_sc_hd__nand2_8
X_12613_ _05693_ _05694_ VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_14_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12544_ _05520_ _05521_ _05519_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__o21ai_1
XFILLER_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12475_ _05543_ _05546_ _05549_ net117 VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__or4b_4
XFILLER_8_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14214_ net2857 VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__inv_2
XANTENNA_6 _06895_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11426_ _04321_ _04322_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__nand2_1
X_14145_ net2912 VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__inv_2
XFILLER_113_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11357_ _04427_ _04431_ _04435_ _04437_ VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_140_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14076_ net2823 VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__inv_2
XFILLER_4_784 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10308_ _03387_ _03392_ _03391_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__nand3_2
XFILLER_140_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13027_ _06056_ _05646_ _05644_ _05656_ VGND VGND VPWR VPWR _06057_ sky130_fd_sc_hd__nand4_4
X_11288_ _04371_ net2512 net1856 _04369_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__and4_1
Xfanout1040 _00425_ VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__buf_1
X_10239_ _03068_ net456 _03087_ _03088_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout1073 _06918_ VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1062 _06920_ VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__buf_4
Xfanout1051 net1053 VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__buf_2
XFILLER_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1084 _06911_ VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__buf_1
XFILLER_82_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer18 _06117_ VGND VGND VPWR VPWR net2936 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_66_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1095 net1098 VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer29 _06287_ VGND VGND VPWR VPWR net2947 sky130_fd_sc_hd__dlygate4sd1_1
X_13929_ net321 _05630_ net147 VGND VGND VPWR VPWR _06871_ sky130_fd_sc_hd__o21ai_1
XFILLER_74_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07450_ net1512 net2194 VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_33_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07381_ net2050 net2031 net1630 net1664 VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__and4_1
X_09120_ _02197_ _02201_ _02203_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__a21oi_2
X_09051_ net2264 net1776 VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__nand2_1
Xrebuffer108 _04169_ VGND VGND VPWR VPWR net3026 sky130_fd_sc_hd__buf_6
Xrebuffer119 _03322_ VGND VGND VPWR VPWR net3037 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_116_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08002_ net2040 net2018 net1931 net1950 VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold501 _00021_ VGND VGND VPWR VPWR net3419 sky130_fd_sc_hd__dlygate4sd3_1
Xhold534 _00006_ VGND VGND VPWR VPWR net3452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold523 _00013_ VGND VGND VPWR VPWR net3441 sky130_fd_sc_hd__dlygate4sd3_1
Xhold512 add_res\[28\] VGND VGND VPWR VPWR net3430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold545 mul_ovf VGND VGND VPWR VPWR net3463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold556 _00031_ VGND VGND VPWR VPWR net3474 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold578 multiplier_inst.sign_res_r VGND VGND VPWR VPWR net3496 sky130_fd_sc_hd__dlygate4sd3_1
Xhold567 adder_inst.is_nan_a_r VGND VGND VPWR VPWR net3485 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09953_ net1230 net1128 _03038_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__o21ai_4
XFILLER_100_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08904_ _01796_ _01971_ _01985_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__o21ai_1
X_09884_ net662 net661 _02954_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__a21bo_1
XFILLER_111_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08835_ _01721_ net2920 net392 _01916_ _01917_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__o2111ai_4
X_08766_ _01849_ _01850_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__nand2_1
XFILLER_57_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07717_ _00637_ net718 _00800_ _00801_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__nand4_1
XFILLER_38_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08697_ _01587_ _01595_ _01596_ _01585_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__a31oi_2
XFILLER_65_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07648_ net1482 net2242 net2281 net1448 VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__a22oi_2
XFILLER_81_761 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07579_ net2102 net1595 _00523_ _00525_ VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__a211oi_2
XFILLER_80_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09318_ _02402_ _00994_ _02398_ _02401_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__o211a_1
XFILLER_9_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10590_ _03457_ _03459_ _03448_ net2996 net3085 VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__o221ai_4
XFILLER_127_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09249_ _01894_ _02017_ _02062_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__o21a_1
XFILLER_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12260_ _05336_ _05337_ _05332_ _05343_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__a31oi_1
XFILLER_110_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11211_ _04012_ _04293_ VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__nand2_4
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12191_ _05239_ _05276_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__and2b_1
XFILLER_135_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11142_ _04220_ _04223_ _04222_ VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__nand3_2
Xoutput76 net76 VGND VGND VPWR VPWR o_res[17] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR o_res[8] sky130_fd_sc_hd__buf_2
XFILLER_122_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput87 net87 VGND VGND VPWR VPWR o_res[27] sky130_fd_sc_hd__buf_2
XFILLER_103_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11073_ _04143_ _04146_ _04147_ _04158_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__o31a_1
XFILLER_48_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10024_ net809 _02879_ _02881_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__a21o_1
XFILLER_64_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11975_ _05049_ _05047_ _05059_ _05056_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__a22oi_2
X_13714_ _06696_ _06709_ _06726_ VGND VGND VPWR VPWR _06727_ sky130_fd_sc_hd__a21oi_4
X_10926_ net2324 net1979 VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__nand2_2
XFILLER_44_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13645_ net1811 net529 _06464_ _06471_ VGND VGND VPWR VPWR _06666_ sky130_fd_sc_hd__o211ai_1
XFILLER_71_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10857_ _03940_ _03941_ _03936_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__nand3_2
XFILLER_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13576_ _06241_ _06247_ _06249_ _06256_ VGND VGND VPWR VPWR _06605_ sky130_fd_sc_hd__o22ai_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10788_ _03872_ _03869_ _03865_ _03870_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__o2bb2ai_2
X_12527_ net144 net318 _05598_ _05599_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__nand4_4
X_12458_ _05320_ net165 _03475_ VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__o21ai_2
XFILLER_125_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11409_ _04494_ _04474_ _04493_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__nand3_4
X_12389_ _05462_ _05473_ _05474_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__or3_1
XFILLER_140_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14128_ net2882 VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__inv_2
XFILLER_141_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14059_ net2850 VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08620_ _01703_ _01681_ _01702_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__nand3_4
XFILLER_55_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08551_ net1622 net2236 net1657 net2272 VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_59_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07502_ _00583_ _00585_ _00580_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__a21o_1
X_08482_ _01564_ _01565_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__nand2_1
X_07433_ _00471_ _00478_ net720 _00484_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_46_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07364_ net1447 net1479 net2133 net2161 VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__nand4_1
X_09103_ _02182_ _02184_ _02186_ _02179_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__a31oi_4
XFILLER_22_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07295_ _07064_ _07065_ VGND VGND VPWR VPWR _07066_ sky130_fd_sc_hd__or2_1
X_09034_ _02113_ net904 net2170 net1849 VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_68_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout800 _03714_ VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__clkbuf_2
Xfanout833 _05846_ VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1809 net1810 VGND VGND VPWR VPWR net1809 sky130_fd_sc_hd__buf_1
Xfanout822 _01439_ VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__clkbuf_2
X_09936_ _03020_ _03021_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__nand2_2
Xfanout811 _02715_ VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_129_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout844 net845 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__clkbuf_1
Xfanout855 net856 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout866 _04259_ VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_112_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout888 _03278_ VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__buf_4
Xfanout877 net878 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_5_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09867_ net1383 net2639 net2662 net1354 VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__a22oi_2
Xfanout899 _02699_ VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_142_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08818_ _01869_ _01870_ net468 _01901_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__a22oi_4
XPHY_EDGE_ROW_77_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09798_ _02883_ _02876_ _02875_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_142_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08749_ net2213 net1657 VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__nand2_2
XFILLER_38_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11760_ _04679_ net607 _04687_ _04689_ VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_26_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10711_ _03572_ _03574_ _03580_ _03570_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__o22ai_2
X_11691_ _04554_ _04770_ _04769_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__o21ai_1
X_13430_ _06458_ VGND VGND VPWR VPWR _06459_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_24_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10642_ net652 _03503_ _03510_ _03512_ VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_127_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13361_ net520 net1205 _06386_ net180 VGND VGND VPWR VPWR _06390_ sky130_fd_sc_hd__a211oi_2
X_10573_ net3086 _03379_ _03442_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__a21oi_4
X_12312_ _05396_ _05397_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__nand2_1
X_13292_ _06319_ _06320_ VGND VGND VPWR VPWR _06321_ sky130_fd_sc_hd__nor2_1
Xrebuffer9 net2926 VGND VGND VPWR VPWR net2927 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_6_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12243_ _02508_ _05325_ _05326_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__nand3_1
XFILLER_108_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12174_ _05258_ _05259_ VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__nor2_1
XFILLER_122_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11125_ _04173_ _04194_ _04209_ _04208_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__o211ai_4
XFILLER_1_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11056_ net1610 net1645 net2622 net2646 _04140_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__a41o_1
XFILLER_49_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10007_ _02856_ _02857_ net459 net458 VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_69_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11958_ _05036_ _05038_ net446 VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_43_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11889_ net552 _04972_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__nor2_1
X_10909_ _03753_ _03754_ net569 _03732_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__o211a_1
X_13628_ _06497_ net178 _06495_ _06644_ VGND VGND VPWR VPWR _06651_ sky130_fd_sc_hd__o211ai_4
X_13559_ _06361_ _06389_ _06357_ VGND VGND VPWR VPWR _06588_ sky130_fd_sc_hd__a21oi_1
XFILLER_9_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07982_ _00935_ _01065_ _01064_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_93_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout107 net108 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_6
X_09721_ net1013 net930 net814 VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__o21ai_1
XFILLER_103_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09652_ _02732_ _02730_ _02708_ _02709_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_2_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08603_ _01686_ _01687_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__nand2_1
XFILLER_83_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09583_ _02206_ _02665_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__nand2_1
XFILLER_55_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_124_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08534_ _01513_ _01514_ _01542_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__and3_1
X_08465_ _01490_ net406 net403 VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__and3_1
XFILLER_50_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07416_ _00494_ _00495_ _00500_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__nand3_1
X_08396_ _01480_ _01481_ VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__nand2_1
XFILLER_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07347_ _00419_ _00431_ _00430_ _00422_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_21_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07278_ net2034 net1508 _06949_ _06977_ _06978_ VGND VGND VPWR VPWR _07049_ sky130_fd_sc_hd__a32o_1
X_09017_ _02097_ _02101_ _02098_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__a21o_1
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2307 net2308 VGND VGND VPWR VPWR net2307 sky130_fd_sc_hd__clkbuf_1
XFILLER_104_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2318 net2319 VGND VGND VPWR VPWR net2318 sky130_fd_sc_hd__clkbuf_2
Xfanout2329 net2330 VGND VGND VPWR VPWR net2329 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_53_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1606 net1607 VGND VGND VPWR VPWR net1606 sky130_fd_sc_hd__buf_1
XFILLER_120_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1628 net1629 VGND VGND VPWR VPWR net1628 sky130_fd_sc_hd__clkbuf_2
Xfanout1617 net1618 VGND VGND VPWR VPWR net1617 sky130_fd_sc_hd__buf_1
Xfanout641 _04023_ VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__buf_6
Xfanout630 _04707_ VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__clkbuf_1
Xfanout1639 net1640 VGND VGND VPWR VPWR net1639 sky130_fd_sc_hd__clkbuf_2
Xfanout685 _01767_ VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__buf_2
Xfanout674 _02564_ VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__buf_8
X_09919_ _02795_ _02994_ _03002_ _02993_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__a2bb2oi_1
Xfanout652 net3114 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__buf_8
Xfanout663 _02931_ VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__buf_6
X_12930_ net2762 net2733 net834 _05975_ VGND VGND VPWR VPWR _05976_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_109_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout696 _01218_ VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__clkbuf_4
X_12861_ net2780 net2717 _05914_ _05915_ net746 VGND VGND VPWR VPWR _05916_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_109_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11812_ net936 net920 _04820_ _04819_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__o211ai_2
X_12792_ net1072 net2746 VGND VGND VPWR VPWR _05854_ sky130_fd_sc_hd__nand2_1
XFILLER_73_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14531_ clknet_leaf_8_clk net766 _00353_ VGND VGND VPWR VPWR multiplier_inst.sign_res_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11743_ _04827_ _04666_ _04823_ _04826_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__o211ai_4
X_14462_ clknet_leaf_6_clk _00048_ _00284_ VGND VGND VPWR VPWR add_res\[20\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11674_ _04416_ _04466_ _04467_ net384 VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_40_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13413_ _06438_ _06440_ VGND VGND VPWR VPWR _06442_ sky130_fd_sc_hd__and2_4
X_10625_ net2321 net1867 VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__nand2_1
XFILLER_128_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14393_ clknet_leaf_15_clk net3381 _00215_ VGND VGND VPWR VPWR adder_inst.man_a_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_13344_ net370 net227 _06269_ _06372_ VGND VGND VPWR VPWR _06373_ sky130_fd_sc_hd__o31a_1
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10556_ _03390_ _03394_ _03397_ _03402_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_142_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer280 net3263 VGND VGND VPWR VPWR net3198 sky130_fd_sc_hd__buf_4
X_13275_ net265 _06177_ _06282_ net281 VGND VGND VPWR VPWR _06304_ sky130_fd_sc_hd__o211ai_4
Xrebuffer291 _03413_ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__buf_6
X_10487_ net1573 net2557 net887 _03383_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__a22o_1
XFILLER_142_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12226_ _04640_ _04780_ _04777_ _04772_ VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2830 net2832 VGND VGND VPWR VPWR net2830 sky130_fd_sc_hd__clkbuf_2
X_12157_ _05241_ _05242_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__and2_1
XFILLER_110_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2852 net2877 VGND VGND VPWR VPWR net2852 sky130_fd_sc_hd__clkbuf_1
XFILLER_96_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2863 net2864 VGND VGND VPWR VPWR net2863 sky130_fd_sc_hd__clkbuf_2
Xfanout2841 net2843 VGND VGND VPWR VPWR net2841 sky130_fd_sc_hd__clkbuf_2
X_11108_ _04167_ net3104 net3026 _04187_ _04189_ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__a32oi_4
Xfanout2885 net2886 VGND VGND VPWR VPWR net2885 sky130_fd_sc_hd__clkbuf_2
Xfanout2896 net2897 VGND VGND VPWR VPWR net2896 sky130_fd_sc_hd__buf_1
Xfanout2874 net2875 VGND VGND VPWR VPWR net2874 sky130_fd_sc_hd__clkbuf_1
XFILLER_84_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12088_ net1887 net1916 net2627 net2656 VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__nand4_1
X_11039_ net562 net560 _04117_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08250_ _01323_ net694 _01332_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__and3_1
XFILLER_20_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07201_ _06970_ net1422 net2083 net1041 VGND VGND VPWR VPWR _06972_ sky130_fd_sc_hd__nand4_2
X_08181_ _01234_ _01262_ _01263_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__nand3_2
X_07132_ net1979 VGND VGND VPWR VPWR _06904_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_95_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07965_ _01049_ _01050_ _01046_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__a21o_1
XFILLER_59_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09704_ net183 _02306_ _02308_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__a21o_1
X_07896_ net2186 net1626 net1660 net2158 VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__a22o_1
XFILLER_83_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09635_ net1406 net2609 VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09566_ net673 _02651_ net672 VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_104_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08517_ _01600_ _01601_ _01584_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__a21o_1
XFILLER_70_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09497_ _02116_ _02115_ net3095 net3110 VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__o211ai_4
XFILLER_51_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08448_ _01529_ _01530_ _01531_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__nand3_4
XFILLER_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10410_ net1226 net1126 _03259_ net891 VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__o211ai_4
X_08379_ net1436 net1465 net2463 net2497 VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__nand4_2
XFILLER_136_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11390_ net868 _04138_ _04140_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__o21ai_1
XFILLER_23_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10341_ _03194_ _03193_ _03206_ _03207_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__o2bb2ai_4
X_13060_ net3300 _06087_ VGND VGND VPWR VPWR _06090_ sky130_fd_sc_hd__nand2_4
XFILLER_3_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10272_ _03112_ _03119_ _03354_ _03353_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__o211ai_2
Xfanout2126 net2127 VGND VGND VPWR VPWR net2126 sky130_fd_sc_hd__clkbuf_1
Xfanout2104 adder_inst.man_a_r\[20\] VGND VGND VPWR VPWR net2104 sky130_fd_sc_hd__buf_6
XFILLER_3_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12011_ _05004_ net2629 net1887 VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__nand3_2
XFILLER_120_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1414 net1415 VGND VGND VPWR VPWR net1414 sky130_fd_sc_hd__buf_1
Xfanout2137 net2138 VGND VGND VPWR VPWR net2137 sky130_fd_sc_hd__buf_1
Xfanout2159 net2951 VGND VGND VPWR VPWR net2159 sky130_fd_sc_hd__clkbuf_2
Xfanout1403 net1404 VGND VGND VPWR VPWR net1403 sky130_fd_sc_hd__clkbuf_2
Xfanout2148 net2149 VGND VGND VPWR VPWR net2148 sky130_fd_sc_hd__buf_4
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1447 net1451 VGND VGND VPWR VPWR net1447 sky130_fd_sc_hd__buf_1
Xfanout1425 net1426 VGND VGND VPWR VPWR net1425 sky130_fd_sc_hd__buf_1
XFILLER_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1436 net1437 VGND VGND VPWR VPWR net1436 sky130_fd_sc_hd__clkbuf_2
XFILLER_120_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13962_ net3401 mul_res\[26\] net2789 VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__mux2_1
Xfanout493 net495 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__buf_2
Xfanout471 _01606_ VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__buf_2
Xfanout1458 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net1458 sky130_fd_sc_hd__buf_4
Xfanout482 net483 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__clkbuf_1
Xfanout460 _02835_ VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__clkbuf_1
Xfanout1469 net1470 VGND VGND VPWR VPWR net1469 sky130_fd_sc_hd__clkbuf_1
X_12913_ net2768 net2730 net1074 VGND VGND VPWR VPWR _05961_ sky130_fd_sc_hd__or3_1
XFILLER_47_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13893_ _05576_ _05585_ _06845_ VGND VGND VPWR VPWR _06846_ sky130_fd_sc_hd__a21oi_1
X_12844_ net237 _05900_ _05901_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__and3_1
XFILLER_73_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12775_ net1062 _05836_ _05792_ net2708 net847 VGND VGND VPWR VPWR _05837_ sky130_fd_sc_hd__a2111o_1
XPHY_EDGE_ROW_14_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14514_ clknet_leaf_0_clk multiplier_inst.man_final\[14\] _00336_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[14\] sky130_fd_sc_hd__dfrtp_1
X_11726_ net352 _04230_ _04811_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__a21oi_2
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14445_ clknet_leaf_4_clk _00061_ _00267_ VGND VGND VPWR VPWR add_res\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11657_ _04463_ _04464_ net1646 net2669 VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__nand4_1
X_10608_ net2270 net1950 VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__nand2_1
X_14376_ clknet_leaf_12_clk net3354 _00198_ VGND VGND VPWR VPWR adder_inst.man_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_11588_ net1170 net1134 net1123 _04351_ _04354_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_12_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13327_ net186 net536 net769 _06354_ _06351_ VGND VGND VPWR VPWR _06356_ sky130_fd_sc_hd__a311o_1
X_10539_ net1522 net1549 net2618 net2644 VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__and4_1
XFILLER_142_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13258_ _06244_ net281 net230 _06286_ VGND VGND VPWR VPWR _06287_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_23_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13189_ net297 net360 _06218_ VGND VGND VPWR VPWR _06219_ sky130_fd_sc_hd__o21ai_1
X_12209_ _05293_ _05282_ _05280_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__a21oi_4
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2660 net2661 VGND VGND VPWR VPWR net2660 sky130_fd_sc_hd__clkbuf_2
Xfanout2671 net2672 VGND VGND VPWR VPWR net2671 sky130_fd_sc_hd__clkbuf_2
Xfanout2693 net2694 VGND VGND VPWR VPWR net2693 sky130_fd_sc_hd__clkbuf_1
X_07750_ _00831_ _00832_ _00830_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__a21o_1
Xfanout2682 net2683 VGND VGND VPWR VPWR net2682 sky130_fd_sc_hd__buf_1
Xfanout1970 net1972 VGND VGND VPWR VPWR net1970 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1992 net1993 VGND VGND VPWR VPWR net1992 sky130_fd_sc_hd__buf_4
Xfanout1981 net1982 VGND VGND VPWR VPWR net1981 sky130_fd_sc_hd__clkbuf_2
X_07681_ _00664_ _00765_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__nand2_1
XFILLER_64_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_121_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09420_ _02501_ _02502_ _02503_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__nand3_1
XFILLER_92_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09351_ _02334_ _02433_ _02434_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__nand3_2
XFILLER_80_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09282_ _02366_ net353 VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__nand2_2
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08302_ _01377_ _01378_ _01379_ net594 VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__a31oi_1
X_08233_ net2175 net1831 VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__nand2_1
XFILLER_138_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08164_ net996 net977 _01249_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_31_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08095_ net2042 net1877 net1907 net2019 VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__a22oi_2
X_07115_ net2300 VGND VGND VPWR VPWR _06887_ sky130_fd_sc_hd__inv_2
XFILLER_134_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_132_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08997_ _02080_ net192 _01752_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__nand3_2
XFILLER_75_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_812 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07948_ _01016_ _01017_ net703 _01029_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__o211a_1
XFILLER_28_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07879_ _00963_ _00884_ _00959_ _00962_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__o211ai_4
XPHY_EDGE_ROW_50_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10890_ net643 _03974_ _03966_ _03958_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_48_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09618_ _02702_ _02693_ _02696_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_39_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09549_ _02169_ _02171_ _02172_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__a21o_1
XFILLER_140_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12560_ net1281 net2009 VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__nand2b_2
XTAP_TAPCELL_ROW_61_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12491_ net117 net118 _05575_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__nand3_4
X_11511_ _04578_ _04579_ _04593_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__o21ai_4
XFILLER_137_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14230_ net2888 VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__inv_2
X_11442_ net641 _04025_ _04037_ VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__a21o_1
X_14161_ net2862 VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__inv_2
X_11373_ net1209 net1100 _04427_ _04429_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__o211ai_2
XFILLER_137_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13112_ net1135 net1105 net499 VGND VGND VPWR VPWR _06142_ sky130_fd_sc_hd__mux2_1
X_10324_ _03176_ net659 _03179_ _03184_ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_98_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14092_ net2835 VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__inv_2
XFILLER_121_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13043_ _06062_ _06068_ net732 VGND VGND VPWR VPWR _06073_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10255_ _03338_ _03339_ _03340_ VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__nand3_2
XFILLER_105_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1222 net1223 VGND VGND VPWR VPWR net1222 sky130_fd_sc_hd__clkbuf_4
X_10186_ net808 _03032_ _03034_ VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__a21o_1
Xfanout1211 _06888_ VGND VGND VPWR VPWR net1211 sky130_fd_sc_hd__buf_6
Xfanout1200 net1202 VGND VGND VPWR VPWR net1200 sky130_fd_sc_hd__buf_2
XFILLER_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1255 net1257 VGND VGND VPWR VPWR net1255 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1244 net1248 VGND VGND VPWR VPWR net1244 sky130_fd_sc_hd__clkbuf_2
Xfanout1233 net1234 VGND VGND VPWR VPWR net1233 sky130_fd_sc_hd__buf_4
Xfanout1288 adder_inst.exp_larger_r\[6\] VGND VGND VPWR VPWR net1288 sky130_fd_sc_hd__buf_1
Xfanout1299 net1301 VGND VGND VPWR VPWR net1299 sky130_fd_sc_hd__buf_1
Xfanout1266 net1268 VGND VGND VPWR VPWR net1266 sky130_fd_sc_hd__clkbuf_4
Xfanout1277 adder_inst.exp_b_r\[4\] VGND VGND VPWR VPWR net1277 sky130_fd_sc_hd__buf_1
Xfanout290 net292 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__clkbuf_4
X_13945_ add_res\[9\] net3473 net2793 VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__mux2_1
X_13876_ net130 _05572_ VGND VGND VPWR VPWR _06834_ sky130_fd_sc_hd__nand2_2
XFILLER_74_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12827_ net2016 net1995 _05888_ VGND VGND VPWR VPWR _05889_ sky130_fd_sc_hd__or3b_4
XFILLER_15_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12758_ net2766 adder_inst.sum_raw_r\[13\] net2761 net2754 VGND VGND VPWR VPWR _05820_
+ sky130_fd_sc_hd__or4_1
X_12689_ adder_inst.i_a\[13\] adder_inst.i_a\[12\] adder_inst.i_a\[15\] adder_inst.i_a\[14\]
+ VGND VGND VPWR VPWR _05763_ sky130_fd_sc_hd__or4_1
X_11709_ _04793_ _04787_ _04786_ VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__and3_1
X_14428_ clknet_leaf_14_clk net3343 _00250_ VGND VGND VPWR VPWR adder_inst.man_b_r\[18\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_30_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14359_ clknet_leaf_1_clk adder_inst.sum_raw\[8\] _00181_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_124_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08920_ _02001_ _02004_ net355 VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__o21ai_1
X_08851_ net356 _01936_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__and2_1
X_07802_ net2099 net1689 VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__nand2_1
XFILLER_85_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2490 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net2490 sky130_fd_sc_hd__buf_6
XFILLER_85_759 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08782_ _01644_ _01655_ _01656_ net688 _01643_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__a32o_1
X_07733_ _00817_ _00704_ net185 VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__nand3_1
X_07664_ net829 _00749_ VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__nand2_2
XFILLER_52_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09403_ _02356_ _02459_ _02487_ _02488_ VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__o211ai_4
XFILLER_111_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07595_ _00678_ _00679_ _00662_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_101_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09334_ _02390_ _02392_ _02415_ _02417_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_101_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09265_ net2214 net1592 _00982_ net969 VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_134_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08216_ net2117 net1879 net1909 net2095 VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__a22o_2
X_09196_ net332 net331 _01553_ _01555_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__nand4_2
XFILLER_134_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08147_ net700 _01153_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__nand2_1
X_08078_ net2116 net1805 net1836 net2092 VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__a22oi_4
XFILLER_134_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10040_ net664 _02888_ _02884_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_112_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11991_ net2543 net1987 VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__nand2_1
X_13730_ _06321_ _06734_ _06727_ _06740_ VGND VGND VPWR VPWR _06741_ sky130_fd_sc_hd__o31a_1
XFILLER_91_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10942_ net2390 net1870 VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nand2_1
XFILLER_71_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13661_ _06581_ net134 net762 _06677_ VGND VGND VPWR VPWR _06680_ sky130_fd_sc_hd__o211ai_2
X_10873_ net1220 net1130 net987 net931 _03696_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__o221ai_2
X_13592_ _06605_ _06607_ net3317 _06609_ net159 VGND VGND VPWR VPWR _06621_ sky130_fd_sc_hd__o41a_1
X_12612_ _05681_ _05682_ _05692_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_14_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12543_ _05611_ net115 net114 VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__or3b_4
XFILLER_129_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12474_ _05556_ net122 _05559_ VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__a21oi_4
X_14213_ net2867 VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__inv_2
XANTENNA_7 _06895_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11425_ _04317_ _04320_ _04319_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__o21ai_1
XFILLER_137_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14144_ net2905 VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11356_ _04439_ _04440_ _04432_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__nand3_2
XFILLER_125_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14075_ net2821 VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__inv_2
XFILLER_4_796 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10307_ _03388_ _03389_ _03386_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__a21oi_2
X_13026_ _06928_ net3207 _06876_ _06925_ VGND VGND VPWR VPWR _06056_ sky130_fd_sc_hd__a31oi_4
X_11287_ net1856 net2512 _04369_ _04371_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__a22o_1
XFILLER_140_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1030 net1031 VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__buf_4
X_10238_ _03065_ _03067_ net2946 _03089_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__o211ai_4
Xfanout1074 _06918_ VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__clkbuf_1
Xfanout1063 net1065 VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1041 _06969_ VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__clkbuf_2
Xfanout1052 net1053 VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__buf_1
X_10169_ _03248_ _03251_ _03252_ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__nand3_4
XFILLER_82_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1085 net1086 VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__buf_6
Xfanout1096 net1098 VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__buf_2
X_13928_ _05628_ _06869_ _06870_ VGND VGND VPWR VPWR multiplier_inst.man_final\[20\]
+ sky130_fd_sc_hd__o21a_1
XFILLER_82_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer19 _06486_ VGND VGND VPWR VPWR net2937 sky130_fd_sc_hd__buf_6
XFILLER_62_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13859_ _05541_ _06786_ _06820_ _06821_ VGND VGND VPWR VPWR _06822_ sky130_fd_sc_hd__o211ai_4
XFILLER_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07380_ net2055 net1631 net1665 net2031 VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__a22oi_4
XFILLER_90_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09050_ net2232 net1801 net1831 net2199 VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__a22o_1
Xrebuffer109 _03947_ VGND VGND VPWR VPWR net3027 sky130_fd_sc_hd__buf_2
X_08001_ _01081_ _01085_ _01082_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__a21oi_1
Xhold502 multiplier_inst.man_final_r\[13\] VGND VGND VPWR VPWR net3420 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_129_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold524 add_res\[0\] VGND VGND VPWR VPWR net3442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold535 multiplier_inst.man_final_r\[3\] VGND VGND VPWR VPWR net3453 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_128_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold513 _00020_ VGND VGND VPWR VPWR net3431 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 mul_res\[4\] VGND VGND VPWR VPWR net3475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold568 mul_res\[2\] VGND VGND VPWR VPWR net3486 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold546 _00032_ VGND VGND VPWR VPWR net3464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold579 adder_inst.is_zero_a_r VGND VGND VPWR VPWR net3497 sky130_fd_sc_hd__dlygate4sd3_1
X_09952_ net1035 net927 _02802_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__o21ai_4
XFILLER_131_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08903_ _01796_ _01971_ _01984_ _01986_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__o22ai_2
X_09883_ net661 _02954_ net662 VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__and3_1
XFILLER_85_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08834_ _01721_ _01627_ net392 _01916_ _01917_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__o2111a_4
XFILLER_66_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08765_ net2152 net1713 net1750 net2121 VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__a22oi_1
XFILLER_85_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07716_ _00637_ net718 _00800_ _00801_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__a22o_1
X_08696_ net685 _01780_ _01778_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__a21oi_4
XFILLER_72_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07647_ net1421 net2309 VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__nand2_1
XFILLER_81_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07578_ net2049 net1720 VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09317_ _02399_ _02400_ _02397_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__nand3_2
XFILLER_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09248_ net355 _02005_ net401 _02063_ VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__a31o_1
XFILLER_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09179_ _02229_ _02242_ _02215_ _02216_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__o211ai_4
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11210_ net2353 net1957 net1980 net2324 VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a22oi_4
X_12190_ _05234_ _05236_ _05237_ _05238_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__nand4_1
XFILLER_135_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11141_ _04222_ _04223_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__nand2_1
XFILLER_122_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput99 net99 VGND VGND VPWR VPWR o_res[9] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR o_res[18] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR o_res[28] sky130_fd_sc_hd__buf_2
X_11072_ _04156_ _04157_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__nand2_1
XFILLER_48_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10023_ net1671 net2407 net809 _02879_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__a22o_4
XFILLER_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11974_ _05058_ _05045_ _05057_ _05055_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__a31oi_1
X_13713_ _06710_ _06725_ VGND VGND VPWR VPWR _06726_ sky130_fd_sc_hd__nand2_1
XFILLER_72_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10925_ _04008_ _04009_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__nand2_4
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13644_ _06458_ _06461_ _06477_ _06656_ VGND VGND VPWR VPWR _06665_ sky130_fd_sc_hd__o211ai_2
X_10856_ _03941_ _03940_ _03936_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__and3_1
XFILLER_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13575_ _06292_ _06303_ _06603_ net1493 VGND VGND VPWR VPWR _06604_ sky130_fd_sc_hd__a22o_1
X_10787_ _03826_ net566 _03852_ _03827_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__a31o_1
X_12526_ _05611_ net115 VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__nor2_8
XFILLER_8_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12457_ _05542_ _05534_ VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__nand2_4
XFILLER_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11408_ net631 _04489_ _04480_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__a21o_1
XFILLER_125_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12388_ _05454_ _05472_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__and2_1
X_14127_ net2844 VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__inv_2
XFILLER_140_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11339_ net1736 net2592 VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__nand2_1
XFILLER_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14058_ net2850 VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__inv_2
XFILLER_79_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13009_ net1326 net1996 _06042_ net1322 VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__o31a_1
XFILLER_94_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08550_ net1624 net2236 net1658 net2273 VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__and4_2
XPHY_EDGE_ROW_6_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07501_ _00580_ _00583_ _00585_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__nand3_1
X_08481_ net1477 net2412 net2442 net1445 VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__a22oi_1
XFILLER_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07432_ _00478_ net720 _00484_ _00471_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_46_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07363_ net1447 net2161 VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__nand2_1
X_09102_ _02183_ _02185_ _02180_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__o21a_1
X_07294_ _07010_ _07062_ _07061_ VGND VGND VPWR VPWR _07065_ sky130_fd_sc_hd__a21boi_1
XFILLER_117_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09033_ net903 net818 _02108_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__and3_4
XFILLER_117_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout834 _05846_ VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__clkbuf_1
Xfanout823 _01240_ VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__buf_1
X_09935_ _03015_ _03018_ _03019_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__nand3_2
Xfanout812 _02715_ VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__clkbuf_1
Xfanout801 _03509_ VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_129_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout845 _05813_ VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__clkbuf_1
XFILLER_86_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout856 net857 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__clkbuf_2
Xfanout867 _04137_ VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlymetal6s2s_1
X_09866_ net1354 net1383 net2639 net2663 VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__and4_1
XFILLER_133_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08817_ _01901_ _01870_ _01869_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_51_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout878 _03712_ VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_142_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09797_ _02880_ net809 _02879_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_142_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08748_ net1591 net2274 VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__nand2_1
X_08679_ net1266 net1168 _01761_ net908 VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__o211a_1
X_10710_ _03573_ _03575_ _03581_ _03571_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__a22oi_4
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11690_ net3029 _04773_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__nand2_1
XFILLER_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10641_ _03514_ _03515_ net652 _03503_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__o211ai_4
X_13360_ _06378_ _06388_ _06379_ VGND VGND VPWR VPWR _06389_ sky130_fd_sc_hd__o21ai_1
X_10572_ net3086 _03379_ _03442_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__nand3_4
X_12311_ _05394_ _02494_ _02490_ VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__nand3b_1
X_13291_ _06316_ _06317_ VGND VGND VPWR VPWR _06320_ sky130_fd_sc_hd__and2b_2
XFILLER_6_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12242_ _02508_ _05325_ _05326_ VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__and3_1
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12173_ _05225_ _05226_ _05228_ _05229_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__nor4_1
X_11124_ _04175_ _04204_ _04206_ _04207_ VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__o211ai_2
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11055_ net1583 net2671 VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__nand2_1
X_10006_ net459 net458 _02859_ _02860_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_76_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11957_ _05036_ _05038_ net446 VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_82_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10908_ _03982_ _03992_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_43_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11888_ _04970_ _04968_ _04736_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__and3_1
X_13627_ _06495_ _06650_ VGND VGND VPWR VPWR adder_inst.sum_raw\[5\] sky130_fd_sc_hd__xor2_1
X_10839_ _03914_ _03915_ _03923_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__nand3_2
X_13558_ _06582_ _06586_ VGND VGND VPWR VPWR _06587_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12509_ _05593_ _05591_ _05587_ VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__nand3b_4
XTAP_TAPCELL_ROW_113_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13489_ net526 _06516_ _06508_ VGND VGND VPWR VPWR _06518_ sky130_fd_sc_hd__o21ai_2
XFILLER_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07981_ _00935_ _01065_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__and2_1
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_4
Xfanout119 net121 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_2
X_09720_ net1035 net930 _02804_ _02801_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__o22ai_4
XFILLER_68_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09651_ _02731_ _02733_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__nand2_1
XFILLER_103_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08602_ net2096 net1804 net1834 net2073 VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__a22oi_1
X_09582_ _02164_ net400 _02205_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_124_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08533_ _01613_ _01617_ net402 VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08464_ net437 _01489_ net403 net405 VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__a22o_1
X_07415_ _00494_ _00495_ _00500_ VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__a21o_1
X_08395_ net1328 net2614 _01478_ _01479_ VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__a22o_1
X_07346_ _00419_ _00431_ _00422_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__o21ai_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07277_ _07046_ _07032_ _07045_ _07030_ VGND VGND VPWR VPWR _07048_ sky130_fd_sc_hd__a31o_1
X_09016_ _02094_ _02095_ _02101_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__o21a_1
XFILLER_117_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2308 net2309 VGND VGND VPWR VPWR net2308 sky130_fd_sc_hd__clkbuf_1
XFILLER_3_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2319 net2320 VGND VGND VPWR VPWR net2319 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_53_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1629 net1633 VGND VGND VPWR VPWR net1629 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1618 net1621 VGND VGND VPWR VPWR net1618 sky130_fd_sc_hd__clkbuf_1
X_09918_ _03002_ _02993_ _02795_ _02994_ VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout642 _04023_ VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__clkbuf_2
Xfanout1607 net1615 VGND VGND VPWR VPWR net1607 sky130_fd_sc_hd__clkbuf_2
Xfanout631 _04486_ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__clkbuf_2
Xfanout620 _05035_ VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__clkbuf_1
XFILLER_104_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout675 _02338_ VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__clkbuf_2
Xfanout653 _03500_ VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__buf_6
Xfanout664 _02885_ VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__buf_4
Xfanout686 _01698_ VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout697 _01218_ VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__buf_1
X_09849_ net1516 net2553 VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__nand2_1
XFILLER_19_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12860_ net2785 net2726 net744 net2788 _05836_ VGND VGND VPWR VPWR _05915_ sky130_fd_sc_hd__o32a_1
XTAP_TAPCELL_ROW_109_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11811_ _04817_ _04819_ net1147 net1136 VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__o2bb2ai_2
X_12791_ _05786_ net848 VGND VGND VPWR VPWR _05853_ sky130_fd_sc_hd__nand2b_1
X_14530_ clknet_leaf_8_clk multiplier_inst.exp_final\[7\] _00352_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11742_ _04827_ _04666_ _04823_ _04826_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__o211a_2
X_14461_ clknet_leaf_6_clk _00046_ _00283_ VGND VGND VPWR VPWR add_res\[19\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11673_ _04416_ net384 _04468_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_40_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13412_ _06438_ _06440_ VGND VGND VPWR VPWR _06441_ sky130_fd_sc_hd__nor2_1
X_14392_ clknet_leaf_10_clk net3380 _00214_ VGND VGND VPWR VPWR adder_inst.man_a_r\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_10624_ net2295 net1898 VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__nand2_1
XFILLER_128_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13343_ _06370_ net254 net221 net3261 VGND VGND VPWR VPWR _06372_ sky130_fd_sc_hd__nand4_2
XFILLER_10_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10555_ _03390_ _03394_ _03403_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__nand3_1
X_13274_ _06291_ _06302_ VGND VGND VPWR VPWR _06303_ sky130_fd_sc_hd__or2_1
Xrebuffer292 _01631_ VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__buf_6
Xrebuffer281 net3263 VGND VGND VPWR VPWR net3199 sky130_fd_sc_hd__clkbuf_1
Xrebuffer270 net3300 VGND VGND VPWR VPWR net3188 sky130_fd_sc_hd__dlygate4sd1_1
X_10486_ net1572 net2557 net887 _03383_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__a22oi_2
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12225_ _05310_ _04778_ _04895_ _04893_ VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_135_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2820 net2849 VGND VGND VPWR VPWR net2820 sky130_fd_sc_hd__buf_1
X_12156_ _05197_ net3130 _05189_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__nand3_2
Xfanout2864 net2875 VGND VGND VPWR VPWR net2864 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2853 net2856 VGND VGND VPWR VPWR net2853 sky130_fd_sc_hd__buf_2
Xfanout2842 net2844 VGND VGND VPWR VPWR net2842 sky130_fd_sc_hd__clkbuf_2
Xfanout2831 net2832 VGND VGND VPWR VPWR net2831 sky130_fd_sc_hd__buf_1
X_11107_ _04174_ _04176_ _04192_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__a21o_1
Xfanout2886 net2887 VGND VGND VPWR VPWR net2886 sky130_fd_sc_hd__buf_1
Xfanout2897 net2916 VGND VGND VPWR VPWR net2897 sky130_fd_sc_hd__buf_1
Xfanout2875 net2876 VGND VGND VPWR VPWR net2875 sky130_fd_sc_hd__buf_1
X_12087_ net1888 net2656 VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__nand2_1
XFILLER_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11038_ _04120_ _04118_ _04119_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__nand3_1
XFILLER_92_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12989_ net1324 net1996 _06026_ net1320 VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_96_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07200_ _06970_ net1422 net2083 net1041 VGND VGND VPWR VPWR _06971_ sky130_fd_sc_hd__and4_1
X_08180_ _01234_ _01263_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__nand2_1
XFILLER_118_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07131_ net2577 VGND VGND VPWR VPWR _06903_ sky130_fd_sc_hd__inv_2
XFILLER_134_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07964_ net409 _01048_ _01047_ VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__nand3_1
XFILLER_114_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07895_ net2189 net1626 net1660 net2158 VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__a22oi_4
X_09703_ net183 net3119 _02308_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__nand3_2
XFILLER_67_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09634_ net1431 net1460 net2554 net2581 VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__nand4_4
X_09565_ _02649_ _02650_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_26_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08516_ _01600_ _01601_ _01584_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__nand3_1
X_09496_ _02122_ _02106_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08447_ _01527_ _01528_ _01532_ VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_137_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire328 _02512_ VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__buf_1
X_08378_ net1437 net1465 net2463 net2498 VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__and4_1
XFILLER_136_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07329_ _07097_ _07098_ _07080_ VGND VGND VPWR VPWR _07100_ sky130_fd_sc_hd__a21oi_1
XFILLER_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10340_ _03206_ _03207_ _03193_ _03194_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__o211ai_2
XFILLER_136_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10271_ _03352_ _03355_ _03356_ VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__nand3_4
XFILLER_105_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2116 net2117 VGND VGND VPWR VPWR net2116 sky130_fd_sc_hd__buf_4
Xfanout2105 net2106 VGND VGND VPWR VPWR net2105 sky130_fd_sc_hd__buf_4
X_12010_ _05094_ net2597 net1916 VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__nand3_2
Xfanout2138 net2139 VGND VGND VPWR VPWR net2138 sky130_fd_sc_hd__clkbuf_2
Xfanout2127 net2128 VGND VGND VPWR VPWR net2127 sky130_fd_sc_hd__buf_1
XFILLER_78_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1404 adder_inst.man_b_r\[21\] VGND VGND VPWR VPWR net1404 sky130_fd_sc_hd__clkbuf_2
Xfanout2149 net2150 VGND VGND VPWR VPWR net2149 sky130_fd_sc_hd__buf_6
XFILLER_120_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1415 net1416 VGND VGND VPWR VPWR net1415 sky130_fd_sc_hd__clkbuf_1
Xfanout1448 net1450 VGND VGND VPWR VPWR net1448 sky130_fd_sc_hd__clkbuf_2
Xfanout1426 net1427 VGND VGND VPWR VPWR net1426 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1437 net1438 VGND VGND VPWR VPWR net1437 sky130_fd_sc_hd__clkbuf_1
Xfanout450 _04701_ VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__buf_2
XFILLER_120_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13961_ net3465 mul_res\[25\] net2789 VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__mux2_1
Xfanout472 _01316_ VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__buf_4
Xfanout461 _02631_ VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__buf_4
Xfanout483 net487 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__buf_1
X_12912_ net2770 net2729 net2741 net1082 VGND VGND VPWR VPWR _05960_ sky130_fd_sc_hd__or4_1
Xfanout494 net495 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__buf_1
XFILLER_86_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13892_ net125 _05593_ _05587_ VGND VGND VPWR VPWR _06845_ sky130_fd_sc_hd__a21boi_1
XFILLER_104_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12843_ net1083 net2778 net2779 net751 VGND VGND VPWR VPWR _05901_ sky130_fd_sc_hd__o22a_1
XFILLER_74_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12774_ net2730 net2745 net2746 VGND VGND VPWR VPWR _05836_ sky130_fd_sc_hd__or3_4
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14513_ clknet_leaf_1_clk multiplier_inst.man_final\[13\] _00335_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[13\] sky130_fd_sc_hd__dfrtp_1
X_11725_ _04221_ _04227_ _04235_ net174 VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__o211ai_1
X_14444_ clknet_leaf_4_clk _00058_ _00266_ VGND VGND VPWR VPWR add_res\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11656_ _04704_ _04705_ _04706_ _04707_ _04714_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__a32oi_2
XFILLER_127_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14375_ clknet_leaf_2_clk adder_inst.sum_raw\[24\] _00197_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[24\]
+ sky130_fd_sc_hd__dfrtp_1
X_11587_ _04672_ _04355_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__nand2_1
X_10607_ _03684_ _03689_ net2978 VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_12_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13326_ net769 net536 net186 _06351_ _06354_ VGND VGND VPWR VPWR _06355_ sky130_fd_sc_hd__a311oi_1
X_10538_ _03399_ _03623_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__nand2_1
XFILLER_142_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13257_ _06284_ net1864 net336 _06285_ VGND VGND VPWR VPWR _06286_ sky130_fd_sc_hd__nand4_2
Xmax_cap639 _04148_ VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__clkbuf_2
X_12208_ net2980 net326 VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__nand2_1
X_10469_ _03295_ _03296_ _03314_ _03315_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_142_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13188_ net262 _06216_ _06217_ VGND VGND VPWR VPWR _06218_ sky130_fd_sc_hd__o21ai_1
XFILLER_123_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2672 net2683 VGND VGND VPWR VPWR net2672 sky130_fd_sc_hd__buf_1
Xfanout2661 adder_inst.man_a_r\[1\] VGND VGND VPWR VPWR net2661 sky130_fd_sc_hd__clkbuf_2
X_12139_ _05222_ _05223_ _05224_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__nor3_1
Xfanout2650 net2651 VGND VGND VPWR VPWR net2650 sky130_fd_sc_hd__buf_1
Xfanout2694 net2695 VGND VGND VPWR VPWR net2694 sky130_fd_sc_hd__buf_1
Xfanout2683 net2684 VGND VGND VPWR VPWR net2683 sky130_fd_sc_hd__clkbuf_2
XFILLER_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1960 net1966 VGND VGND VPWR VPWR net1960 sky130_fd_sc_hd__clkbuf_2
Xfanout1971 net1972 VGND VGND VPWR VPWR net1971 sky130_fd_sc_hd__clkbuf_1
Xfanout1982 net1994 VGND VGND VPWR VPWR net1982 sky130_fd_sc_hd__clkbuf_2
Xfanout1993 net1994 VGND VGND VPWR VPWR net1993 sky130_fd_sc_hd__clkbuf_2
X_07680_ net2049 net1719 net1755 net2023 VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_121_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09350_ _02369_ _02370_ _02432_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__o21ai_2
XFILLER_80_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09281_ _02340_ _02364_ _02365_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__nand3b_1
X_08301_ net592 _01383_ _01375_ VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__a21o_1
XFILLER_33_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08232_ net2200 net1800 VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__nand2_1
XFILLER_21_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_119_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08163_ _01201_ _01246_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_31_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08094_ net2042 net2019 net1876 net1906 VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__nand4_2
X_07114_ net2270 VGND VGND VPWR VPWR _06886_ sky130_fd_sc_hd__inv_2
XFILLER_133_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08996_ _02080_ net192 _01752_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__a21o_1
XFILLER_125_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07947_ net702 _01018_ net703 VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__nand3_1
XFILLER_87_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07878_ _00961_ _00958_ _00960_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__nand3_4
XFILLER_141_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09617_ _02691_ _02692_ _02690_ _02701_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_39_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09548_ _01347_ _02170_ net1674 net2340 _02169_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__o2111ai_1
XFILLER_43_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09479_ net2199 net1849 VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11510_ _04580_ _04582_ _04591_ net417 VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__o211ai_4
XFILLER_133_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12490_ net117 net118 _05575_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__and3_4
XFILLER_11_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11441_ _04034_ _04035_ _04020_ _04024_ net642 VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__o221ai_1
XFILLER_109_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14160_ net2862 VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__inv_2
X_11372_ _04456_ _04453_ _04455_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__o21ai_1
XFILLER_137_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13111_ net1923 net776 net543 _06139_ VGND VGND VPWR VPWR _06141_ sky130_fd_sc_hd__a31o_1
X_10323_ _03181_ _03185_ _03176_ net659 VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__o211ai_2
XFILLER_125_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14091_ net2835 VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__inv_2
XFILLER_112_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13042_ net1090 net1272 _05713_ VGND VGND VPWR VPWR _06072_ sky130_fd_sc_hd__o21ai_2
XFILLER_59_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10254_ net1206 net1167 net970 net914 _03103_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__o221ai_2
Xfanout1212 net1214 VGND VGND VPWR VPWR net1212 sky130_fd_sc_hd__buf_4
Xfanout1223 net1224 VGND VGND VPWR VPWR net1223 sky130_fd_sc_hd__clkbuf_2
Xfanout1201 net1202 VGND VGND VPWR VPWR net1201 sky130_fd_sc_hd__dlymetal6s2s_1
X_10185_ net1005 net925 net808 _03034_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__o211ai_4
Xfanout1256 net1257 VGND VGND VPWR VPWR net1256 sky130_fd_sc_hd__buf_1
Xfanout1245 net1247 VGND VGND VPWR VPWR net1245 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_72_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1234 net1236 VGND VGND VPWR VPWR net1234 sky130_fd_sc_hd__buf_4
Xfanout1267 net1268 VGND VGND VPWR VPWR net1267 sky130_fd_sc_hd__buf_2
Xfanout1289 adder_inst.exp_larger_r\[5\] VGND VGND VPWR VPWR net1289 sky130_fd_sc_hd__buf_1
XFILLER_93_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout280 net3194 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_6
Xfanout1278 adder_inst.exp_b_r\[4\] VGND VGND VPWR VPWR net1278 sky130_fd_sc_hd__clkbuf_1
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_2
X_13944_ net3492 mul_res\[8\] net2794 VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__mux2_1
XFILLER_47_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13875_ net140 net315 _05569_ VGND VGND VPWR VPWR _06833_ sky130_fd_sc_hd__a21o_1
XFILLER_47_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12826_ _05871_ _05886_ _05887_ _05789_ VGND VGND VPWR VPWR _05888_ sky130_fd_sc_hd__o31a_1
XFILLER_74_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12757_ net2784 net2746 _05818_ VGND VGND VPWR VPWR _05819_ sky130_fd_sc_hd__or3_1
X_12688_ adder_inst.i_a\[1\] adder_inst.i_a\[0\] adder_inst.i_a\[3\] adder_inst.i_a\[2\]
+ VGND VGND VPWR VPWR _05762_ sky130_fd_sc_hd__or4_1
XFILLER_42_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11708_ net3099 _04651_ _04612_ net202 VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__o31a_1
X_14427_ clknet_leaf_14_clk net3346 _00249_ VGND VGND VPWR VPWR adder_inst.man_b_r\[17\]
+ sky130_fd_sc_hd__dfrtp_2
X_11639_ _04379_ _04384_ net559 _04413_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__o211ai_1
XFILLER_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14358_ clknet_leaf_3_clk adder_inst.sum_raw\[7\] _00180_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_13309_ _06245_ net334 net253 VGND VGND VPWR VPWR _06338_ sky130_fd_sc_hd__and3_1
XFILLER_7_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14289_ clknet_leaf_12_clk net26 _00111_ VGND VGND VPWR VPWR adder_inst.i_a\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_131_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08850_ _01816_ _01821_ net685 _01781_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__o211a_1
XFILLER_111_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07801_ net2047 net2073 net1719 net1752 VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__nand4_2
Xfanout2480 net2481 VGND VGND VPWR VPWR net2480 sky130_fd_sc_hd__buf_1
XFILLER_111_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08781_ _01643_ _01659_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__nor2_1
XFILLER_84_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2491 net2493 VGND VGND VPWR VPWR net2491 sky130_fd_sc_hd__clkbuf_2
X_07732_ _00817_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__inv_2
XFILLER_93_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1790 net1791 VGND VGND VPWR VPWR net1790 sky130_fd_sc_hd__buf_1
X_07663_ net1337 net2369 _00746_ _00747_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__a22o_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09402_ _02477_ _02478_ _02481_ _02483_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__o22ai_2
XFILLER_111_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07594_ _00678_ _00679_ _00662_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__a21oi_1
X_09333_ _02393_ _02394_ _02416_ _02418_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_36_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09264_ _02346_ _02349_ VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_134_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08215_ net2117 net1879 net1909 net2092 VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__a22oi_1
X_09195_ net332 net331 VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__nand2_1
X_08146_ _01205_ _01206_ _01216_ _01229_ net697 VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__a32o_1
XFILLER_134_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08077_ net2144 net1773 VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__nand2_1
XFILLER_134_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08979_ _02061_ net467 _02060_ _01903_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__nand4_2
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11990_ net626 net623 _05009_ _05010_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__o2bb2ai_2
X_10941_ net2355 net1901 VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__nand2_1
X_13660_ net169 _06672_ _06678_ VGND VGND VPWR VPWR _06679_ sky130_fd_sc_hd__o21ba_1
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12611_ _05681_ _05682_ _05692_ VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__and3_1
X_10872_ net1220 net1130 net987 net935 _03696_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__o221a_1
XFILLER_16_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13591_ _06590_ net166 _06618_ VGND VGND VPWR VPWR _06620_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_14_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12542_ _05576_ net114 net3241 VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__and3_1
XFILLER_12_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12473_ _05553_ _05558_ VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__nand2_4
X_14212_ net2864 VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__inv_2
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11424_ _04058_ _04254_ _04253_ net866 VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__o22a_1
XFILLER_137_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_8 _06896_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14143_ net2910 VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11355_ _04439_ _04440_ _04432_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__and3_1
XFILLER_113_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14074_ net2821 VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__inv_2
X_10306_ net1234 net1102 _03179_ _03181_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__o22ai_2
X_11286_ _04369_ _04371_ net1159 net1147 VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13025_ _06046_ _06050_ _06053_ VGND VGND VPWR VPWR _06055_ sky130_fd_sc_hd__o21ai_4
X_10237_ _03068_ net456 VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__nand2_1
Xfanout1031 net1032 VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__buf_4
Xfanout1020 net1022 VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__buf_4
Xfanout1064 _06920_ VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__buf_1
XFILLER_121_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1053 _06944_ VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__buf_2
Xfanout1042 net1043 VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__buf_6
XFILLER_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10168_ _03013_ _03250_ _03249_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_89_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1086 net1087 VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__buf_4
Xfanout1097 net1098 VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__buf_1
X_10099_ _03180_ net2610 net1495 VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__and3_1
X_13927_ net109 _06869_ _05628_ VGND VGND VPWR VPWR _06870_ sky130_fd_sc_hd__o21ai_1
XFILLER_75_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13858_ _05539_ _06818_ _06817_ VGND VGND VPWR VPWR _06821_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_33_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13789_ net3453 net723 VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__and2_1
X_12809_ _05832_ _05870_ _05864_ _05850_ VGND VGND VPWR VPWR _05871_ sky130_fd_sc_hd__or4_4
XFILLER_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08000_ _01081_ _01085_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_116_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold503 multiplier_inst.man_final_r\[12\] VGND VGND VPWR VPWR net3421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold525 _00000_ VGND VGND VPWR VPWR net3443 sky130_fd_sc_hd__dlygate4sd3_1
Xhold514 add_res\[13\] VGND VGND VPWR VPWR net3432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold536 add_res\[16\] VGND VGND VPWR VPWR net3454 sky130_fd_sc_hd__dlygate4sd3_1
Xhold558 _00026_ VGND VGND VPWR VPWR net3476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold569 _00022_ VGND VGND VPWR VPWR net3487 sky130_fd_sc_hd__dlygate4sd3_1
Xhold547 add_res\[25\] VGND VGND VPWR VPWR net3465 sky130_fd_sc_hd__dlygate4sd3_1
X_09951_ net1006 net928 _03034_ _03030_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__o22a_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08902_ _01972_ _01985_ _01987_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__nand3b_4
X_09882_ net662 net661 _02954_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__a21oi_1
X_08833_ _01726_ _01914_ _01915_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__nand3_4
X_08764_ net2121 net1749 VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__nand2_1
XFILLER_122_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07715_ _00655_ _00657_ _00787_ _00799_ VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__o211ai_2
XFILLER_38_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08695_ _01780_ net685 VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__nand2_1
XFILLER_25_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07646_ net1449 net2277 VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__nand2_1
XFILLER_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07577_ net2049 net2024 net1687 net1719 VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__and4_4
XTAP_TAPCELL_ROW_0_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09316_ net1529 net1561 net2239 net2275 _00997_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__a41o_1
XFILLER_40_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09247_ net355 _02005_ net401 _02063_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__a31oi_4
XFILLER_21_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09178_ _02262_ _02263_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nand2_1
XFILLER_135_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08129_ net989 net975 _01213_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__o21ai_1
XFILLER_134_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11140_ _03828_ _03855_ _03869_ net204 VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__nand4_2
XFILLER_122_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput78 net78 VGND VGND VPWR VPWR o_res[19] sky130_fd_sc_hd__buf_2
XFILLER_122_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput89 net89 VGND VGND VPWR VPWR o_res[29] sky130_fd_sc_hd__buf_2
X_11071_ _04151_ _04152_ _04155_ net562 VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__o211ai_2
XFILLER_102_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10022_ net972 _01397_ net1671 net2407 net809 VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__o2111ai_4
XFILLER_102_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11973_ _05058_ _05057_ _05045_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13712_ _06339_ _06340_ _06342_ _06360_ _06717_ VGND VGND VPWR VPWR _06725_ sky130_fd_sc_hd__a32oi_2
XFILLER_71_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10924_ net2325 net1953 net1980 net2297 VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__a22oi_2
XFILLER_17_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13643_ net162 _06663_ net135 VGND VGND VPWR VPWR _06664_ sky130_fd_sc_hd__mux2_4
X_10855_ _03788_ _03789_ _03784_ net648 VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__o211ai_1
X_13574_ _06602_ VGND VGND VPWR VPWR _06603_ sky130_fd_sc_hd__inv_2
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12525_ _05585_ _05594_ _05608_ VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__nand3_4
X_10786_ _03827_ _03853_ net385 VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__o21ai_2
XFILLER_12_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12456_ net142 net316 _05541_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__nand3_4
X_12387_ _05454_ _05472_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__nor2_1
X_11407_ _04477_ _04478_ net631 _04489_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__nand4_1
XFILLER_141_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14126_ net2854 VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__inv_2
X_11338_ net1705 net2626 VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__nand2_1
XFILLER_99_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14057_ net2850 VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__inv_2
XFILLER_98_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11269_ net1170 net1134 VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__nor2_1
XFILLER_140_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13008_ _05811_ _06039_ _06041_ VGND VGND VPWR VPWR _06042_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_87_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07500_ _00584_ _00572_ _00570_ _00497_ _00499_ VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__a32o_1
XFILLER_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08480_ net1445 net1477 net2412 net2442 VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__nand4_1
X_07431_ _00506_ _00507_ _00505_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__a21o_1
XFILLER_90_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07362_ net1479 net2133 VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__nand2_1
X_09101_ _02183_ _02185_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__nor2_1
X_07293_ _07058_ _07060_ _07063_ VGND VGND VPWR VPWR _07064_ sky130_fd_sc_hd__a21boi_1
X_09032_ net818 net904 _02108_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__a21o_1
XFILLER_117_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_724 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout824 _01239_ VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__buf_1
Xfanout813 _02569_ VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__buf_4
X_09934_ _03014_ _03016_ _03017_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__nand3_4
Xfanout802 _03300_ VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_129_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout846 _05801_ VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout835 net837 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout857 _05752_ VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__clkbuf_2
X_09865_ net1383 net2662 VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__nand2_1
XFILLER_97_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08816_ net468 _01901_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_51_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout868 _04137_ VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__clkbuf_1
Xfanout879 _03615_ VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__clkbuf_2
XFILLER_133_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09796_ _02880_ _02878_ _01397_ net972 VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_142_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_116_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08747_ _01697_ _01701_ net686 VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__a21boi_4
XFILLER_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08678_ _01761_ net908 _01758_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__a21o_1
X_07629_ _00713_ _00710_ _00712_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__o21ai_1
XFILLER_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10640_ net652 _03503_ _03514_ _03515_ VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_24_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10571_ _03603_ net2923 _03656_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__o21ai_4
XPHY_EDGE_ROW_125_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12310_ _02489_ _05394_ _05395_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__nand3_2
X_13290_ _06318_ VGND VGND VPWR VPWR _06319_ sky130_fd_sc_hd__inv_2
XFILLER_6_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12241_ _05325_ _05326_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__nand2_1
XFILLER_107_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12172_ _05225_ _05226_ _05228_ _05229_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__o22a_1
X_11123_ _03860_ _04205_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__nand2_2
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11054_ net1582 net2671 VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__and2_1
XFILLER_103_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10005_ _03089_ net456 _03065_ _03067_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__o2bb2ai_4
XPHY_EDGE_ROW_134_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11956_ _05037_ _05039_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__nand2_1
XFILLER_83_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10907_ net565 _03991_ _03981_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_43_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11887_ _04736_ _04968_ _04970_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__a21oi_1
X_13626_ _06648_ net765 _06649_ VGND VGND VPWR VPWR _06650_ sky130_fd_sc_hd__a21o_1
X_10838_ net873 _03921_ _03919_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__a21oi_2
X_13557_ _06344_ _06345_ _06359_ _06395_ VGND VGND VPWR VPWR _06586_ sky130_fd_sc_hd__nor4_4
X_10769_ _03805_ _03824_ _03825_ _03854_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__a31o_1
X_12508_ _05593_ _05590_ _05587_ VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__nor3b_4
XFILLER_118_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13488_ net525 _06516_ _06508_ VGND VGND VPWR VPWR _06517_ sky130_fd_sc_hd__o21a_1
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12439_ _05524_ net2033 net1343 VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_97_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07980_ _00935_ _01065_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__nor2_1
Xfanout109 _05637_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_4
XFILLER_99_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14109_ net2815 VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__inv_2
XFILLER_86_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09650_ net670 net668 _02716_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__and3_1
XFILLER_94_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08601_ net2069 net1836 VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__nand2_1
XFILLER_103_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09581_ _02665_ _02205_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08532_ _01270_ _01612_ _01614_ VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__nand3_1
X_08463_ net405 net403 _01490_ VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__a21oi_1
X_07414_ _00498_ _00499_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__and2_1
X_08394_ net1051 net912 net1328 net2614 _01479_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__o2111ai_4
X_07345_ _07072_ _07074_ _07103_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__o21bai_2
XTAP_TAPCELL_ROW_21_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07276_ _07046_ _07032_ _07045_ VGND VGND VPWR VPWR _07047_ sky130_fd_sc_hd__and3_1
X_09015_ net2119 net1929 VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__nand2_2
XFILLER_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2309 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net2309 sky130_fd_sc_hd__clkbuf_2
XFILLER_104_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout610 _01257_ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__clkbuf_2
Xfanout1619 net1620 VGND VGND VPWR VPWR net1619 sky130_fd_sc_hd__clkbuf_2
X_09917_ _03002_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__inv_2
Xfanout1608 net1609 VGND VGND VPWR VPWR net1608 sky130_fd_sc_hd__clkbuf_2
Xfanout621 _05034_ VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__clkbuf_2
Xfanout632 _04396_ VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__buf_4
Xfanout676 _02182_ VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__clkbuf_2
Xfanout665 _02854_ VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__clkbuf_2
Xfanout643 _03965_ VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__buf_4
Xfanout654 _03344_ VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__clkbuf_2
Xfanout687 _01657_ VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__buf_6
Xfanout698 _01150_ VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__buf_1
XFILLER_74_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09848_ net1519 net1545 net2524 net2553 VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__and4_1
XFILLER_85_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09779_ net3107 net462 _02609_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__and3_1
XFILLER_46_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12790_ net1312 net848 _05805_ VGND VGND VPWR VPWR _05852_ sky130_fd_sc_hd__o21bai_1
X_11810_ net936 net919 _04819_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__o21ai_1
XFILLER_27_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11741_ _04668_ net1935 net2482 VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__nand3_2
XFILLER_42_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14460_ clknet_leaf_5_clk _00045_ _00282_ VGND VGND VPWR VPWR add_res\[18\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11672_ _04416_ _04468_ net384 VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_40_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13411_ net492 _06436_ _06439_ VGND VGND VPWR VPWR _06440_ sky130_fd_sc_hd__a21oi_2
X_14391_ clknet_leaf_19_clk net3459 _00213_ VGND VGND VPWR VPWR adder_inst.man_a_r\[15\]
+ sky130_fd_sc_hd__dfrtp_2
X_10623_ net2350 net1845 VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__nand2_1
X_13342_ _06369_ net231 _06368_ VGND VGND VPWR VPWR _06371_ sky130_fd_sc_hd__nand3_2
X_10554_ _03397_ _03402_ _03390_ _03394_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__o211ai_2
XFILLER_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13273_ _06299_ _06301_ VGND VGND VPWR VPWR _06302_ sky130_fd_sc_hd__nor2_1
Xrebuffer271 net1725 VGND VGND VPWR VPWR net3189 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer282 _06129_ VGND VGND VPWR VPWR net3200 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer260 net548 VGND VGND VPWR VPWR net3178 sky130_fd_sc_hd__dlygate4sd1_1
X_10485_ _03567_ _03568_ _03564_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_79_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12224_ _04769_ _04774_ _04775_ VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__nand3b_1
Xrebuffer293 _03114_ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_9_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2810 net2811 VGND VGND VPWR VPWR net2810 sky130_fd_sc_hd__clkbuf_2
X_12155_ _05197_ _05199_ _05026_ _05187_ VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2821 net2823 VGND VGND VPWR VPWR net2821 sky130_fd_sc_hd__buf_2
XFILLER_111_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2854 net2856 VGND VGND VPWR VPWR net2854 sky130_fd_sc_hd__buf_2
Xfanout2843 net2844 VGND VGND VPWR VPWR net2843 sky130_fd_sc_hd__buf_1
Xfanout2832 net2833 VGND VGND VPWR VPWR net2832 sky130_fd_sc_hd__clkbuf_2
X_11106_ _04187_ _04189_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__nand2_1
XFILLER_1_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2887 net2896 VGND VGND VPWR VPWR net2887 sky130_fd_sc_hd__buf_1
XFILLER_104_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2865 net2875 VGND VGND VPWR VPWR net2865 sky130_fd_sc_hd__buf_1
Xfanout2876 net2877 VGND VGND VPWR VPWR net2876 sky130_fd_sc_hd__buf_1
X_12086_ _05165_ _05170_ _05171_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__nand3b_1
Xfanout2898 net2900 VGND VGND VPWR VPWR net2898 sky130_fd_sc_hd__buf_2
X_11037_ _04055_ _04070_ _04121_ _04122_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__o211ai_1
XFILLER_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12988_ net707 _05849_ _05848_ _06923_ VGND VGND VPWR VPWR _06026_ sky130_fd_sc_hd__and4b_1
XFILLER_45_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11939_ _05017_ _05022_ _05021_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_99_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13609_ _06533_ _06557_ _06560_ VGND VGND VPWR VPWR _06635_ sky130_fd_sc_hd__o21a_1
XFILLER_20_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14589_ clknet_leaf_6_clk net3438 _00411_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
X_07130_ net1961 VGND VGND VPWR VPWR _06902_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_12_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_142_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07963_ _00979_ _01048_ _01047_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__a21o_1
XFILLER_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07894_ _00973_ _00975_ _00976_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__nand3_2
XFILLER_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09702_ net183 _02306_ _02307_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__a21o_1
XFILLER_28_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09633_ _02252_ _02717_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__nand2_1
X_09564_ _02219_ _02222_ _02220_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__a21oi_1
XFILLER_130_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08515_ _01587_ _01595_ _01596_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__nand3_2
X_09495_ net3091 _02107_ _02115_ _02116_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_24_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08446_ _01220_ _01224_ _01221_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__a21oi_1
X_08377_ net1435 net2459 VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_137_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07328_ _07076_ _07077_ _07098_ _07097_ _07079_ VGND VGND VPWR VPWR _07099_ sky130_fd_sc_hd__o2111a_1
XFILLER_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07259_ _07029_ _06950_ net2029 net1507 VGND VGND VPWR VPWR _07030_ sky130_fd_sc_hd__and4_1
XFILLER_99_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10270_ _03116_ _03115_ _03113_ _03114_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__o211ai_4
XFILLER_133_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2106 net2114 VGND VGND VPWR VPWR net2106 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2117 net2118 VGND VGND VPWR VPWR net2117 sky130_fd_sc_hd__buf_1
Xfanout2128 adder_inst.man_a_r\[19\] VGND VGND VPWR VPWR net2128 sky130_fd_sc_hd__buf_1
Xfanout2139 adder_inst.man_a_r\[19\] VGND VGND VPWR VPWR net2139 sky130_fd_sc_hd__buf_4
Xfanout1405 net1407 VGND VGND VPWR VPWR net1405 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout440 net441 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__clkbuf_2
Xfanout1416 net1417 VGND VGND VPWR VPWR net1416 sky130_fd_sc_hd__buf_1
Xfanout1427 net1428 VGND VGND VPWR VPWR net1427 sky130_fd_sc_hd__buf_1
Xfanout1438 net1439 VGND VGND VPWR VPWR net1438 sky130_fd_sc_hd__buf_1
X_13960_ net3437 mul_res\[24\] net2799 VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__mux2_1
Xfanout1449 net1450 VGND VGND VPWR VPWR net1449 sky130_fd_sc_hd__clkbuf_1
XFILLER_101_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout473 _01267_ VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_2
Xfanout462 _02587_ VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__buf_6
Xfanout484 net486 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout451 _04344_ VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_2
X_12911_ _05958_ _05959_ net240 VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__o21a_1
Xfanout495 net496 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__buf_1
X_13891_ _05576_ _05578_ _05582_ _05584_ _06844_ VGND VGND VPWR VPWR multiplier_inst.man_final\[9\]
+ sky130_fd_sc_hd__a41oi_2
X_12842_ net2786 net2714 _05843_ _05899_ VGND VGND VPWR VPWR _05900_ sky130_fd_sc_hd__a31o_1
XFILLER_73_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12773_ net1081 net1072 VGND VGND VPWR VPWR _05835_ sky130_fd_sc_hd__nand2_1
X_14512_ clknet_leaf_0_clk multiplier_inst.man_final\[12\] _00334_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11724_ _03689_ _03684_ _03691_ _03889_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__o22ai_2
X_14443_ clknet_leaf_4_clk _00047_ _00265_ VGND VGND VPWR VPWR add_res\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11655_ _04708_ _04717_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__nand2_1
X_14374_ clknet_leaf_3_clk adder_inst.sum_raw\[23\] _00196_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11586_ net1123 _04351_ _04354_ VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__o21ai_2
XFILLER_10_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10606_ _03679_ _03682_ _03687_ _03688_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_12_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13325_ net186 net488 _06353_ VGND VGND VPWR VPWR _06354_ sky130_fd_sc_hd__a21oi_1
X_10537_ net1522 net2641 VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__nand2_1
XFILLER_127_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13256_ _06197_ net267 net360 net299 _06265_ VGND VGND VPWR VPWR _06285_ sky130_fd_sc_hd__o221ai_4
X_10468_ _03316_ _03318_ net454 net452 VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__o211ai_4
XFILLER_142_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12207_ _05283_ _05278_ _05292_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__a21oi_2
XFILLER_96_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13187_ net262 _06213_ VGND VGND VPWR VPWR _06217_ sky130_fd_sc_hd__nand2_1
X_10399_ net2208 net1971 VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__nand2_1
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2640 net2645 VGND VGND VPWR VPWR net2640 sky130_fd_sc_hd__clkbuf_2
X_12138_ _05162_ _05163_ _05164_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__and3_1
Xfanout2651 net2660 VGND VGND VPWR VPWR net2651 sky130_fd_sc_hd__buf_1
Xfanout2662 net2667 VGND VGND VPWR VPWR net2662 sky130_fd_sc_hd__buf_2
Xclkbuf_leaf_1_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
Xfanout2695 adder_inst.sum_raw_r\[24\] VGND VGND VPWR VPWR net2695 sky130_fd_sc_hd__buf_1
Xfanout1950 net1951 VGND VGND VPWR VPWR net1950 sky130_fd_sc_hd__clkbuf_2
Xfanout2684 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR net2684 sky130_fd_sc_hd__buf_2
Xfanout1961 net1966 VGND VGND VPWR VPWR net1961 sky130_fd_sc_hd__buf_8
X_12069_ _05073_ net200 VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__nand2_1
Xfanout2673 net2678 VGND VGND VPWR VPWR net2673 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_64_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1972 net1978 VGND VGND VPWR VPWR net1972 sky130_fd_sc_hd__clkbuf_2
Xfanout1983 net1985 VGND VGND VPWR VPWR net1983 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1994 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net1994 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_121_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09280_ net675 _02339_ _02362_ _02363_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__o211ai_2
X_08300_ net592 _01383_ net594 VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__a21oi_1
XFILLER_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08231_ _01313_ _01311_ _01312_ _01309_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__nand4_2
XFILLER_119_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08162_ net2211 net1718 net1748 net2183 VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_31_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08093_ net2042 net2019 net1877 net1907 VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__and4_1
X_07113_ net2233 VGND VGND VPWR VPWR _06885_ sky130_fd_sc_hd__inv_2
XFILLER_134_616 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_132_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08995_ _01934_ _02075_ _02076_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__nand3_2
X_07946_ net702 _01018_ net703 VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__and3_1
XFILLER_87_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07877_ net2045 net2070 net1715 net1751 _00888_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__a41o_1
XFILLER_141_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09616_ _02698_ _02700_ net898 net1016 VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_39_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09547_ net1674 net2340 _02169_ _02171_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_39_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09478_ _02554_ _02558_ _02557_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__nand3_4
X_08429_ _01513_ _01514_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__nand2_1
XFILLER_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11440_ net641 _04025_ _04034_ _04035_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__o2bb2ai_2
Xclkload0 clknet_1_0__leaf_clk VGND VGND VPWR VPWR clkload0/X sky130_fd_sc_hd__clkbuf_8
X_11371_ net1209 net1096 _04455_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__o21a_1
XFILLER_109_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14090_ net2840 VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__inv_2
X_13110_ net1923 net528 _06139_ VGND VGND VPWR VPWR _06140_ sky130_fd_sc_hd__a21oi_1
X_10322_ _03179_ _03183_ _03182_ _03176_ net659 VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__o2111ai_4
X_13041_ net1085 net1997 net858 VGND VGND VPWR VPWR _06071_ sky130_fd_sc_hd__a21oi_4
XFILLER_133_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10253_ _03103_ _03104_ _03105_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__a21o_1
Xfanout1213 net1214 VGND VGND VPWR VPWR net1213 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1202 _06891_ VGND VGND VPWR VPWR net1202 sky130_fd_sc_hd__clkbuf_4
X_10184_ _03264_ _03268_ _03267_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__nand3_4
XFILLER_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1246 net1247 VGND VGND VPWR VPWR net1246 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1224 net1225 VGND VGND VPWR VPWR net1224 sky130_fd_sc_hd__clkbuf_4
Xfanout1235 net1236 VGND VGND VPWR VPWR net1235 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout281 net3194 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_4
Xfanout270 net3306 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__buf_6
Xfanout1279 adder_inst.exp_b_r\[3\] VGND VGND VPWR VPWR net1279 sky130_fd_sc_hd__clkbuf_4
Xfanout1257 net1258 VGND VGND VPWR VPWR net1257 sky130_fd_sc_hd__clkbuf_2
Xfanout292 _06135_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_4
Xfanout1268 _06879_ VGND VGND VPWR VPWR net1268 sky130_fd_sc_hd__clkbuf_4
X_13943_ add_res\[7\] net3460 net2792 VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__mux2_1
XFILLER_74_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13874_ _06831_ _06832_ VGND VGND VPWR VPWR multiplier_inst.man_final\[4\] sky130_fd_sc_hd__nor2_1
XFILLER_62_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12825_ _05815_ net837 _05812_ _05828_ _05830_ VGND VGND VPWR VPWR _05887_ sky130_fd_sc_hd__o311ai_2
XFILLER_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12756_ net2786 net2688 net2714 net2698 VGND VGND VPWR VPWR _05818_ sky130_fd_sc_hd__or4_1
X_12687_ adder_inst.i_a\[5\] adder_inst.i_a\[4\] adder_inst.i_a\[7\] adder_inst.i_a\[6\]
+ VGND VGND VPWR VPWR _05761_ sky130_fd_sc_hd__or4_1
X_11707_ net202 _04792_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__nand2_1
XFILLER_30_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14426_ clknet_leaf_14_clk net3359 _00248_ VGND VGND VPWR VPWR adder_inst.man_b_r\[16\]
+ sky130_fd_sc_hd__dfrtp_2
X_11638_ _04700_ _04722_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__nand2_2
XFILLER_128_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14357_ clknet_leaf_3_clk adder_inst.sum_raw\[6\] _00179_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_128_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13308_ _06335_ _06336_ VGND VGND VPWR VPWR _06337_ sky130_fd_sc_hd__nand2_1
X_11569_ net202 _04652_ _04612_ net3099 VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_115_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14288_ clknet_leaf_12_clk net23 _00110_ VGND VGND VPWR VPWR adder_inst.i_a\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_13239_ _06266_ _06267_ net230 VGND VGND VPWR VPWR _06268_ sky130_fd_sc_hd__and3_1
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2470 net2472 VGND VGND VPWR VPWR net2470 sky130_fd_sc_hd__clkbuf_2
X_08780_ _01862_ _01859_ _01833_ _01861_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__o211ai_4
Xfanout2481 net2487 VGND VGND VPWR VPWR net2481 sky130_fd_sc_hd__buf_1
X_07800_ net1697 net1729 VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07731_ _00814_ _00815_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__nor2_4
XFILLER_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2492 net2493 VGND VGND VPWR VPWR net2492 sky130_fd_sc_hd__buf_1
Xfanout1780 net1781 VGND VGND VPWR VPWR net1780 sky130_fd_sc_hd__clkbuf_1
Xfanout1791 net1792 VGND VGND VPWR VPWR net1791 sky130_fd_sc_hd__clkbuf_2
X_07662_ _00747_ net2369 net1337 _00746_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__nand4_1
XFILLER_38_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09401_ _02479_ _02482_ _02484_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__nand3_1
X_07593_ _00672_ _00676_ _00677_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__nand3_2
XFILLER_52_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09332_ _02395_ _02409_ _02410_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_101_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09263_ _02348_ _02341_ _02347_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__nand3_2
X_08214_ net2092 net2116 net1879 net1909 VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__nand4_4
X_09194_ net329 _02279_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_134_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08145_ net3049 _01206_ _01216_ _01229_ net696 VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__a32oi_4
XFILLER_21_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08076_ _01109_ _01115_ _01112_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__a21oi_2
XFILLER_106_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08978_ net467 _01903_ _02060_ _02061_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__a22o_1
X_07929_ net1359 net1386 net2367 net2386 VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__nand4_1
XFILLER_75_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10940_ net2417 net1845 VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__nand2_1
XFILLER_29_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12610_ net1280 net2008 net784 _05691_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__a31o_1
X_10871_ _03488_ _03694_ net988 net931 VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_44_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13590_ _06590_ net166 _06618_ VGND VGND VPWR VPWR _06619_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_14_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12541_ _05626_ _05616_ _05625_ _05619_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__nor4_4
XFILLER_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12472_ _02793_ _05557_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__xor2_4
XFILLER_8_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14211_ net2862 VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__inv_2
XFILLER_61_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11423_ _04260_ net2537 net1763 VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__and3_1
XFILLER_137_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_9 _06900_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14142_ net2908 VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11354_ net983 net910 net1676 net2623 _04436_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__o2111ai_2
XFILLER_98_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10305_ _03180_ _03182_ net1495 net2610 VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__nand4_1
XFILLER_4_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14073_ net2803 VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__inv_2
X_11285_ _04248_ _04368_ VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__nand2_1
X_13024_ _05648_ _05657_ _06050_ _06053_ VGND VGND VPWR VPWR _06054_ sky130_fd_sc_hd__o31a_1
X_10236_ _03320_ net454 net452 VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__a21boi_4
Xfanout1010 _00491_ VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__clkbuf_2
Xfanout1021 net1022 VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__buf_1
XFILLER_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1065 _06920_ VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__clkbuf_1
Xfanout1043 net1044 VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__buf_4
XFILLER_94_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1054 _06928_ VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__buf_4
XFILLER_66_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10167_ net182 net181 _03013_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__and3_4
Xfanout1032 _00473_ VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__buf_6
XFILLER_120_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1076 _06917_ VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_89_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1087 _06910_ VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__buf_4
X_10098_ net1117 net1109 net1015 net1102 net1233 VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__o32a_1
Xfanout1098 _06908_ VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__buf_2
X_13926_ net132 _05635_ _05632_ VGND VGND VPWR VPWR _06869_ sky130_fd_sc_hd__o21a_1
X_13857_ _04799_ _06819_ VGND VGND VPWR VPWR _06820_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_33_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13788_ net3390 net723 VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__and2_1
X_12808_ net2688 net1313 _05868_ _05869_ VGND VGND VPWR VPWR _05870_ sky130_fd_sc_hd__a211o_1
XFILLER_50_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12739_ net2731 net2739 VGND VGND VPWR VPWR _05801_ sky130_fd_sc_hd__nor2_1
XFILLER_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14409_ clknet_leaf_8_clk _00033_ _00231_ VGND VGND VPWR VPWR adder_inst.is_inf_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_129_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold504 add_res\[12\] VGND VGND VPWR VPWR net3422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold515 _00004_ VGND VGND VPWR VPWR net3433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold526 add_res\[31\] VGND VGND VPWR VPWR net3444 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 mul_res\[5\] VGND VGND VPWR VPWR net3477 sky130_fd_sc_hd__dlygate4sd3_1
Xhold537 _00007_ VGND VGND VPWR VPWR net3455 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold548 _00017_ VGND VGND VPWR VPWR net3466 sky130_fd_sc_hd__dlygate4sd3_1
X_09950_ net1006 net928 _03034_ _03030_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__o22ai_2
XFILLER_131_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08901_ _01979_ _01981_ _01973_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__o21bai_4
XFILLER_112_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09881_ _02962_ _02963_ _02961_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__o21bai_2
XTAP_TAPCELL_ROW_111_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08832_ _01726_ _01915_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_29_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08763_ net2152 net1713 VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__nand2_1
XFILLER_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07714_ _00757_ _00786_ _00798_ net411 VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__o211ai_2
XFILLER_26_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08694_ _01757_ _01764_ _01766_ _01775_ _01776_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__a32oi_4
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07645_ net2252 net2270 VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__nand2_1
X_07576_ _00634_ _00661_ _00632_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_0_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09315_ _00995_ _00996_ net1243 net1219 VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09246_ _02330_ _02331_ VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_38_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09177_ _02247_ net816 _02259_ _02260_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__nand4_1
XFILLER_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08128_ net989 net975 _01213_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__o21a_1
XFILLER_134_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08059_ net825 _01144_ _01139_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_56_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11070_ net560 _04153_ _04154_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__nand3_2
Xoutput79 net79 VGND VGND VPWR VPWR o_res[1] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR o_res[0] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_47_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10021_ net970 net914 _03105_ _03102_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__o22a_4
XFILLER_88_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13711_ net136 _06722_ _06723_ VGND VGND VPWR VPWR _06724_ sky130_fd_sc_hd__a21o_1
XFILLER_57_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11972_ _04932_ _04934_ _04955_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__o21ai_1
X_10923_ net2325 net1953 VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13642_ _06478_ _06652_ _06662_ VGND VGND VPWR VPWR _06663_ sky130_fd_sc_hd__o21bai_2
XTAP_TAPCELL_ROW_84_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10854_ _03784_ net647 _03786_ _03787_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__o2bb2ai_1
X_13573_ _06291_ _06292_ _06600_ VGND VGND VPWR VPWR _06602_ sky130_fd_sc_hd__nand3b_2
X_12524_ _05586_ _05609_ _05595_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__nor3_4
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10785_ _03656_ _03605_ _03864_ _03866_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__o211ai_4
X_12455_ _03693_ _05540_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__xor2_4
X_12386_ _05470_ _05471_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__nand2_1
X_11406_ _04489_ _04479_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__nand2_1
XFILLER_141_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14125_ net2858 VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__inv_2
X_11337_ net1611 net2648 _04418_ _04421_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14056_ net2850 VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__inv_2
XFILLER_95_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11268_ _04349_ _04350_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__nand2_2
X_13007_ net2016 _05817_ net707 _06040_ VGND VGND VPWR VPWR _06041_ sky130_fd_sc_hd__or4b_1
X_11199_ net2353 net2392 net1957 net1983 VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__nand4_2
XFILLER_39_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10219_ _03078_ _03079_ net967 net943 VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_95_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13909_ _06857_ _06855_ _05577_ _05611_ VGND VGND VPWR VPWR multiplier_inst.man_final\[14\]
+ sky130_fd_sc_hd__o2bb2a_4
XFILLER_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07430_ _00462_ _00514_ _00515_ _00513_ VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__o31ai_1
XFILLER_62_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07361_ net2129 net2148 VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__nand2_2
XFILLER_22_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09100_ net1003 _01397_ net1577 net2403 _01396_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__o2111ai_4
X_07292_ _07010_ _07062_ VGND VGND VPWR VPWR _07063_ sky130_fd_sc_hd__and2_1
X_09031_ net818 net903 _02108_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__a21oi_4
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout825 _01142_ VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__buf_1
Xfanout814 _02550_ VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__clkbuf_2
X_09933_ _02767_ _02762_ _02766_ _02782_ _02783_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__o2111ai_1
Xfanout803 _03300_ VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__clkbuf_1
XFILLER_131_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout836 net837 VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__clkbuf_1
Xfanout847 _05797_ VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__buf_6
XFILLER_100_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout858 _05712_ VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__buf_1
X_09864_ _06877_ net1093 VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__nor2_1
XFILLER_133_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08815_ _01706_ _01898_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_51_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout869 net870 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_85_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09795_ net1671 net2407 VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_142_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08746_ _01691_ _01696_ _01698_ _01700_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__a2bb2oi_2
X_08677_ _01761_ net908 _01758_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__a21oi_1
X_07628_ net2155 net1594 net1014 net1001 VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07559_ net1482 net2220 VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10570_ _03604_ _03655_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__nand2_4
X_09229_ net3058 _02309_ _02311_ _01929_ VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__a22oi_2
XFILLER_42_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12240_ net614 _00947_ _00972_ _00949_ VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__o211ai_2
XFILLER_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12171_ net2979 _05247_ _05244_ _05240_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_123_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11122_ _03827_ _03855_ net3140 _03862_ net2950 VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__o2111ai_4
XFILLER_107_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11053_ net1610 net1645 net2622 net2649 VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__nand4_1
XFILLER_76_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10004_ _03065_ _03067_ net456 _03089_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_76_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11955_ _05028_ net622 net619 VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__and3_1
XFILLER_45_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10906_ _03985_ _03987_ _03983_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__o21ai_2
X_13625_ _06497_ net177 _06643_ _06640_ net854 VGND VGND VPWR VPWR _06649_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_43_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11886_ net628 _04951_ _04969_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10837_ net873 _03921_ _03919_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__a21o_1
XFILLER_13_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13556_ _06378_ _06388_ _06395_ _06584_ _06379_ VGND VGND VPWR VPWR _06585_ sky130_fd_sc_hd__o221ai_2
X_10768_ net566 _03852_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__nand2_1
X_12507_ _05382_ _05592_ VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__xor2_2
XFILLER_118_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13487_ _06515_ net228 _06513_ VGND VGND VPWR VPWR _06516_ sky130_fd_sc_hd__o21ai_4
XFILLER_9_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12438_ net2057 net1373 _07013_ _07016_ VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_97_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10699_ _03560_ _03781_ _03777_ _03782_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__o211ai_1
XFILLER_126_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12369_ _05454_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__inv_2
XFILLER_113_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14108_ net2815 VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__inv_2
XFILLER_113_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14039_ net2864 VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08600_ net2100 net1805 VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__nand2_1
XFILLER_82_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09580_ _02196_ _02202_ _02204_ net400 _02164_ VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_124_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08531_ _01270_ _01612_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__nand2_4
XFILLER_36_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08462_ _01493_ _01546_ _01547_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__nand3_4
XFILLER_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07413_ _00496_ _00497_ net1339 net2284 VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__nand4_2
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08393_ net1379 net2561 net2587 net1351 VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__a22o_1
XFILLER_50_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07344_ _00423_ _00424_ _00428_ VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_21_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07275_ _07039_ _07040_ _07043_ _07044_ VGND VGND VPWR VPWR _07046_ sky130_fd_sc_hd__a22o_1
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09014_ net2130 net1929 VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__and2_1
XFILLER_117_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout600 _00729_ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__clkbuf_1
Xfanout611 _01187_ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlymetal6s2s_1
X_09916_ _03001_ _02998_ _03000_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__a21oi_2
Xfanout1609 net1613 VGND VGND VPWR VPWR net1609 sky130_fd_sc_hd__clkbuf_2
Xfanout622 _05034_ VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__clkbuf_1
Xfanout633 _04395_ VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__buf_6
XFILLER_59_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout666 _02852_ VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__clkbuf_2
Xfanout655 _03341_ VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__clkbuf_2
Xfanout644 _03926_ VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__buf_4
Xfanout688 _01657_ VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__clkbuf_2
Xfanout699 _01150_ VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__buf_1
Xfanout677 _02149_ VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__clkbuf_2
X_09847_ net1543 net2524 VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__nand2_1
X_09778_ net460 _02862_ _02837_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_29_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08729_ _01810_ _01806_ _01782_ _01813_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_29_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11740_ _04667_ _04668_ net1164 net1136 VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_41_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11671_ _04723_ _04728_ _04729_ _04755_ _04733_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__a32oi_1
XTAP_TAPCELL_ROW_40_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13410_ net1999 net1087 net731 net606 net1177 VGND VGND VPWR VPWR _06439_ sky130_fd_sc_hd__o221a_1
X_14390_ clknet_leaf_19_clk net3462 _00212_ VGND VGND VPWR VPWR adder_inst.man_a_r\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_10622_ net2350 net1845 VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_40_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13341_ _06307_ _06305_ net294 _06304_ VGND VGND VPWR VPWR _06370_ sky130_fd_sc_hd__o211ai_2
X_10553_ _03390_ _03394_ _03404_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__a21o_1
Xrebuffer250 _05217_ VGND VGND VPWR VPWR net3168 sky130_fd_sc_hd__dlygate4sd1_1
X_13272_ _06298_ net522 _06300_ VGND VGND VPWR VPWR _06301_ sky130_fd_sc_hd__a21bo_1
Xrebuffer272 net3318 VGND VGND VPWR VPWR net3190 sky130_fd_sc_hd__buf_6
Xrebuffer283 net3200 VGND VGND VPWR VPWR net3201 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer261 net3199 VGND VGND VPWR VPWR net3179 sky130_fd_sc_hd__dlymetal6s2s_1
X_10484_ _03566_ _03569_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_79_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12223_ _04661_ _04663_ _04783_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__o21ai_1
Xrebuffer294 _03821_ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__buf_1
XFILLER_135_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2800 net2801 VGND VGND VPWR VPWR net2800 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_9_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2811 net2812 VGND VGND VPWR VPWR net2811 sky130_fd_sc_hd__buf_1
X_12154_ _05239_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2855 net2856 VGND VGND VPWR VPWR net2855 sky130_fd_sc_hd__clkbuf_2
Xfanout2844 net2845 VGND VGND VPWR VPWR net2844 sky130_fd_sc_hd__buf_1
Xfanout2822 net2823 VGND VGND VPWR VPWR net2822 sky130_fd_sc_hd__buf_1
X_11105_ _04178_ net422 net420 VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__nand3_1
XFILLER_1_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2833 net2834 VGND VGND VPWR VPWR net2833 sky130_fd_sc_hd__clkbuf_1
Xfanout2888 net2895 VGND VGND VPWR VPWR net2888 sky130_fd_sc_hd__buf_2
XFILLER_110_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2866 net2867 VGND VGND VPWR VPWR net2866 sky130_fd_sc_hd__clkbuf_2
Xfanout2877 net2917 VGND VGND VPWR VPWR net2877 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_49_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12085_ _05080_ _05082_ _05083_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__a21o_1
Xfanout2899 net2900 VGND VGND VPWR VPWR net2899 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11036_ _03903_ _03904_ _03905_ _03906_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_76_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12987_ net1325 net1995 _06025_ net1321 VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__o31a_1
XFILLER_91_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11938_ _05018_ _05019_ _05020_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__nand3_4
XFILLER_33_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11869_ _04951_ _04953_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__nand2_2
X_14588_ clknet_leaf_7_clk net3429 _00410_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
X_13608_ net156 net161 _06630_ _06533_ _06560_ VGND VGND VPWR VPWR _06634_ sky130_fd_sc_hd__o221a_1
XFILLER_119_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13539_ _06566_ _06567_ VGND VGND VPWR VPWR _06568_ sky130_fd_sc_hd__nor2_4
XFILLER_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07962_ _00980_ _01037_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__nand2_1
X_09701_ net183 net3120 _02307_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__nand3_2
X_07893_ _00974_ _00977_ _00978_ VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__nand3_1
XFILLER_82_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09632_ net1460 net2555 net2589 net1431 VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_108_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09563_ net999 net913 _02220_ _02222_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__o211a_1
XFILLER_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08514_ _01598_ _01586_ _01597_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__nand3_2
XFILLER_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09494_ _02561_ net2963 _02578_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__o21ai_4
XFILLER_51_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08445_ _01220_ _01224_ _01221_ VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__a21o_1
XFILLER_11_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08376_ net1411 net2530 VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nand2_1
XFILLER_23_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07327_ _07095_ _07096_ _07086_ VGND VGND VPWR VPWR _07098_ sky130_fd_sc_hd__a21o_1
XFILLER_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07258_ _07026_ _07028_ _07023_ VGND VGND VPWR VPWR _07029_ sky130_fd_sc_hd__a21oi_2
X_07189_ net1457 net1491 VGND VGND VPWR VPWR _06960_ sky130_fd_sc_hd__nand2_2
Xfanout2107 net2109 VGND VGND VPWR VPWR net2107 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_132_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2118 net2119 VGND VGND VPWR VPWR net2118 sky130_fd_sc_hd__clkbuf_2
Xfanout2129 net2131 VGND VGND VPWR VPWR net2129 sky130_fd_sc_hd__buf_4
Xfanout441 _00909_ VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_1
Xfanout1417 net1418 VGND VGND VPWR VPWR net1417 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1428 net1429 VGND VGND VPWR VPWR net1428 sky130_fd_sc_hd__clkbuf_2
Xfanout1439 net3000 VGND VGND VPWR VPWR net1439 sky130_fd_sc_hd__clkbuf_2
Xfanout430 _03435_ VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__buf_4
Xfanout1406 net1407 VGND VGND VPWR VPWR net1406 sky130_fd_sc_hd__clkbuf_1
Xfanout474 _01267_ VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__clkbuf_2
Xfanout463 _02587_ VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__clkbuf_1
Xfanout452 _03296_ VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__buf_8
X_12910_ net2690 net2756 net755 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR _05959_
+ sky130_fd_sc_hd__a22o_1
X_13890_ _05564_ _05574_ _06842_ _05561_ _06843_ VGND VGND VPWR VPWR _06844_ sky130_fd_sc_hd__o41a_1
XFILLER_100_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout496 net497 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__buf_1
XFILLER_73_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout485 net486 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__buf_1
XFILLER_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12841_ net2787 net2724 _05845_ _05898_ VGND VGND VPWR VPWR _05899_ sky130_fd_sc_hd__a31o_1
XFILLER_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12772_ _05826_ _05833_ VGND VGND VPWR VPWR _05834_ sky130_fd_sc_hd__nor2_1
X_14511_ clknet_leaf_0_clk multiplier_inst.man_final\[11\] _00333_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11723_ _04784_ _04807_ _04808_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__o21a_2
X_14442_ clknet_leaf_20_clk _00036_ _00264_ VGND VGND VPWR VPWR add_res\[0\] sky130_fd_sc_hd__dfrtp_1
X_11654_ net710 VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__inv_2
X_10605_ _03679_ net129 _03685_ _03686_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_127_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14373_ clknet_leaf_2_clk adder_inst.sum_raw\[22\] _00195_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_11585_ net936 net924 _04669_ _04666_ VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__o22a_1
X_13324_ net2000 net1088 net730 net605 net1224 VGND VGND VPWR VPWR _06353_ sky130_fd_sc_hd__o221a_1
XFILLER_10_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10536_ _03619_ _03620_ _03617_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__nand3_2
XFILLER_115_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13255_ _06176_ net267 net413 net1864 _06281_ VGND VGND VPWR VPWR _06284_ sky130_fd_sc_hd__o2111ai_4
X_10467_ net454 net452 _03316_ _03318_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__o2bb2ai_4
X_12206_ _05272_ _05277_ _05291_ _05243_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__nand4b_1
X_13186_ net1585 net479 _06214_ VGND VGND VPWR VPWR _06216_ sky130_fd_sc_hd__o21ai_2
X_10398_ net2249 net1944 VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__nand2_1
Xfanout2630 net2631 VGND VGND VPWR VPWR net2630 sky130_fd_sc_hd__clkbuf_2
XFILLER_123_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2663 net2667 VGND VGND VPWR VPWR net2663 sky130_fd_sc_hd__clkbuf_2
X_12137_ _05162_ _05163_ _05164_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__a21oi_1
Xfanout2652 net2654 VGND VGND VPWR VPWR net2652 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2641 net2643 VGND VGND VPWR VPWR net2641 sky130_fd_sc_hd__clkbuf_2
Xfanout2696 net2697 VGND VGND VPWR VPWR net2696 sky130_fd_sc_hd__buf_1
Xfanout2685 net2686 VGND VGND VPWR VPWR net2685 sky130_fd_sc_hd__buf_1
Xfanout1951 net1952 VGND VGND VPWR VPWR net1951 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12068_ _05073_ net200 VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__and2_1
Xfanout2674 net2678 VGND VGND VPWR VPWR net2674 sky130_fd_sc_hd__clkbuf_1
Xfanout1940 net1941 VGND VGND VPWR VPWR net1940 sky130_fd_sc_hd__clkbuf_1
Xfanout1995 net1996 VGND VGND VPWR VPWR net1995 sky130_fd_sc_hd__buf_1
Xfanout1973 net1975 VGND VGND VPWR VPWR net1973 sky130_fd_sc_hd__buf_8
Xfanout1984 net1985 VGND VGND VPWR VPWR net1984 sky130_fd_sc_hd__buf_2
Xfanout1962 net1963 VGND VGND VPWR VPWR net1962 sky130_fd_sc_hd__dlymetal6s2s_1
X_11019_ _04101_ _04102_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__nand2_1
XFILLER_49_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_121_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_103_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08230_ _01314_ _01310_ _01298_ _01315_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__nand4_2
XFILLER_60_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08161_ net2183 net2211 net1718 net1747 VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_31_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08092_ net2065 net1852 VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__nand2_2
X_07112_ net2180 VGND VGND VPWR VPWR _06884_ sky130_fd_sc_hd__inv_2
XFILLER_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08994_ _01920_ _01755_ _01919_ _02077_ _02078_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__o2111ai_4
XPHY_EDGE_ROW_10_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07945_ _01016_ _01017_ net703 net702 VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_141_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07876_ _00885_ _00887_ net1261 net1213 VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09615_ net2493 net2525 net1033 _02700_ _02698_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_39_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09546_ _02628_ _02629_ _02622_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_48_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09477_ _02555_ _02559_ _02560_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_61_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08428_ _01505_ _01506_ _01512_ VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__a21o_1
XFILLER_12_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08359_ _01367_ _01432_ _01441_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__o21ai_2
Xclkload1 clknet_leaf_10_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__inv_16
X_11370_ net1676 net2668 VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__nand2_1
XFILLER_119_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10321_ _03176_ _03177_ _03181_ _03185_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_76_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13040_ _06061_ _06058_ _06068_ VGND VGND VPWR VPWR _06070_ sky130_fd_sc_hd__o21bai_4
XFILLER_105_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10252_ net970 net921 _03336_ _03332_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__o22a_1
Xfanout1214 net1215 VGND VGND VPWR VPWR net1214 sky130_fd_sc_hd__buf_4
XFILLER_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10183_ _03268_ _03267_ _03264_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__and3_4
Xfanout1203 _06890_ VGND VGND VPWR VPWR net1203 sky130_fd_sc_hd__buf_4
Xfanout1247 net1248 VGND VGND VPWR VPWR net1247 sky130_fd_sc_hd__clkbuf_1
Xfanout1225 _06886_ VGND VGND VPWR VPWR net1225 sky130_fd_sc_hd__buf_2
Xfanout1236 net1237 VGND VGND VPWR VPWR net1236 sky130_fd_sc_hd__clkbuf_2
X_13942_ add_res\[6\] net3457 net2794 VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__mux2_1
Xfanout1258 _06881_ VGND VGND VPWR VPWR net1258 sky130_fd_sc_hd__clkbuf_1
Xfanout260 net261 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__buf_6
Xfanout1269 net1271 VGND VGND VPWR VPWR net1269 sky130_fd_sc_hd__clkbuf_2
Xfanout282 net284 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__buf_6
XFILLER_115_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13873_ net118 _05560_ _06830_ VGND VGND VPWR VPWR _06832_ sky130_fd_sc_hd__a21oi_1
XFILLER_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12824_ _05884_ net839 net709 _05885_ VGND VGND VPWR VPWR _05886_ sky130_fd_sc_hd__a211o_1
XFILLER_131_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12755_ net2685 net1291 net1289 net750 VGND VGND VPWR VPWR _05817_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_17_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11706_ _04652_ net416 VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__nand2_1
XFILLER_15_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12686_ adder_inst.man_b\[23\] _05760_ VGND VGND VPWR VPWR adder_inst.is_zero_b sky130_fd_sc_hd__nor2_1
X_14425_ clknet_leaf_14_clk net3353 _00247_ VGND VGND VPWR VPWR adder_inst.man_b_r\[15\]
+ sky130_fd_sc_hd__dfrtp_1
X_11637_ _04694_ _04698_ _04699_ _04701_ _04721_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__a32oi_4
X_14356_ clknet_leaf_3_clk adder_inst.sum_raw\[5\] _00178_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_11568_ net202 _04652_ net416 VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__nand3_2
XFILLER_128_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13307_ net338 net299 _06285_ _06284_ VGND VGND VPWR VPWR _06336_ sky130_fd_sc_hd__o211ai_1
XFILLER_7_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10519_ _03602_ _03597_ _03601_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__and3_1
X_14287_ clknet_leaf_12_clk net12 _00109_ VGND VGND VPWR VPWR adder_inst.i_a\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_11499_ _04524_ _04530_ _04529_ _04521_ VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__a22oi_1
X_13238_ _06193_ net269 net281 VGND VGND VPWR VPWR _06267_ sky130_fd_sc_hd__o21ai_2
XFILLER_111_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13169_ net266 _06197_ VGND VGND VPWR VPWR _06199_ sky130_fd_sc_hd__nand2_1
XFILLER_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2471 net2472 VGND VGND VPWR VPWR net2471 sky130_fd_sc_hd__clkbuf_1
Xfanout2460 net2461 VGND VGND VPWR VPWR net2460 sky130_fd_sc_hd__buf_1
X_07730_ _00815_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__inv_2
XFILLER_85_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2482 net2484 VGND VGND VPWR VPWR net2482 sky130_fd_sc_hd__buf_6
Xfanout2493 net2496 VGND VGND VPWR VPWR net2493 sky130_fd_sc_hd__buf_1
Xfanout1781 net1782 VGND VGND VPWR VPWR net1781 sky130_fd_sc_hd__buf_1
Xfanout1770 net1771 VGND VGND VPWR VPWR net1770 sky130_fd_sc_hd__buf_1
Xfanout1792 net1793 VGND VGND VPWR VPWR net1792 sky130_fd_sc_hd__buf_4
X_07661_ net1391 net2306 net2338 net1364 VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__a22o_1
XFILLER_26_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09400_ _02476_ _02467_ _02475_ _02482_ _02484_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__o2111ai_1
X_07592_ _00675_ _00671_ _00674_ VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__nand3_2
X_09331_ _02413_ _02414_ _02396_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_36_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09262_ _02343_ _00956_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nand2_1
XFILLER_119_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08213_ net2144 net1850 VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__nand2_1
X_09193_ _02271_ net3139 net3055 _02214_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__o211ai_4
XFILLER_21_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08144_ _01225_ _01226_ _01217_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__o21a_1
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08075_ _01109_ _01115_ _01112_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__a21o_1
XFILLER_134_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08977_ net467 _01903_ _02060_ _02061_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_71_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07928_ net1359 net1386 net2367 net2385 VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__and4_1
X_07859_ _00898_ _00899_ _00901_ _00895_ VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__a22oi_2
XFILLER_71_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10870_ _03951_ _03954_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__nand2_1
X_09529_ net465 _02132_ _02150_ _02151_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_12_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12540_ _05622_ _05623_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__nand2_4
XFILLER_24_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12471_ _05547_ _03020_ _03021_ VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__a21bo_1
X_14210_ net2867 VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__inv_2
X_11422_ net3149 _04346_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__nand2_2
X_14141_ net2906 VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__inv_2
XFILLER_125_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11353_ _04434_ _04436_ net1208 net1107 VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__o2bb2ai_1
X_14072_ net2804 VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__inv_2
X_10304_ _03388_ _03389_ _03386_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__nand3_4
X_11284_ net2479 net1883 net1913 net2449 VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__a22oi_1
XFILLER_121_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13023_ _05643_ _05655_ _05654_ VGND VGND VPWR VPWR _06053_ sky130_fd_sc_hd__a21boi_4
X_10235_ _03296_ _03317_ _03319_ _03294_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__a31oi_4
Xfanout1022 net1023 VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__clkbuf_1
Xfanout1000 net1004 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__buf_1
Xfanout1055 net1057 VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__buf_1
XFILLER_120_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1044 net1045 VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__clkbuf_2
X_10166_ _02999_ _03001_ net182 net181 VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__o211ai_2
Xfanout1033 _00472_ VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__buf_4
Xfanout1077 _06917_ VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_89_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1088 _06910_ VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__dlymetal6s2s_1
X_10097_ net1494 net2610 VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__nand2_2
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13925_ _06867_ _06868_ _05628_ VGND VGND VPWR VPWR multiplier_inst.man_final\[19\]
+ sky130_fd_sc_hd__a21oi_2
XFILLER_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1099 net1100 VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__clkbuf_2
X_13856_ _04805_ _06790_ _04804_ VGND VGND VPWR VPWR _06819_ sky130_fd_sc_hd__o21ai_2
XFILLER_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12807_ net839 _05866_ _05867_ net709 VGND VGND VPWR VPWR _05869_ sky130_fd_sc_hd__a31o_1
XFILLER_90_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13787_ net3400 net723 VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__and2_1
XFILLER_43_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10999_ _04083_ _04084_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_33_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12738_ net1305 net1300 net1062 net847 VGND VGND VPWR VPWR _05800_ sky130_fd_sc_hd__or4_4
XFILLER_30_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12669_ _05744_ _05638_ _05746_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[7\]
+ sky130_fd_sc_hd__o21a_1
X_14408_ clknet_leaf_11_clk net3375 _00230_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_129_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold505 _00003_ VGND VGND VPWR VPWR net3423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold516 multiplier_inst.man_final_r\[8\] VGND VGND VPWR VPWR net3434 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_128_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold527 _00024_ VGND VGND VPWR VPWR net3445 sky130_fd_sc_hd__dlygate4sd3_1
X_14339_ clknet_leaf_17_clk net46 _00161_ VGND VGND VPWR VPWR adder_inst.i_b\[21\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold538 multiplier_inst.exp_final_r\[5\] VGND VGND VPWR VPWR net3456 sky130_fd_sc_hd__dlygate4sd3_1
Xhold549 adder_inst.i_a\[21\] VGND VGND VPWR VPWR net3467 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08900_ _01980_ _01982_ _01973_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__a21oi_2
X_09880_ net662 VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__inv_2
XFILLER_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08831_ _01825_ _01828_ _01912_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__o21ai_2
XFILLER_112_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08762_ net2184 net1683 VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__nand2_1
Xfanout2290 net2294 VGND VGND VPWR VPWR net2290 sky130_fd_sc_hd__buf_4
X_07713_ net411 _00757_ VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__nand2_1
X_08693_ _01767_ _01769_ _01777_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__a21o_1
XFILLER_38_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07644_ _00725_ _00726_ _00727_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__nand3_2
XFILLER_25_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07575_ _00657_ _00659_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__nor2_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09314_ net1243 net1219 _00995_ _00996_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__o211ai_2
X_09245_ _02327_ _02329_ _02324_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__nand3b_1
X_09176_ _02247_ net816 _02259_ _02260_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__a22o_1
XFILLER_107_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08127_ net2292 net1681 VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__nand2_2
XFILLER_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08058_ net2120 net2146 net1803 net1834 VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__nand4_2
XFILLER_134_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net69 VGND VGND VPWR VPWR o_res[10] sky130_fd_sc_hd__buf_2
X_10020_ _03105_ _03102_ _03104_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__o21ai_2
XFILLER_102_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11971_ _04933_ _04935_ _04954_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__nand3_1
X_13710_ net149 _06592_ net158 net850 VGND VGND VPWR VPWR _06723_ sky130_fd_sc_hd__a31o_1
X_10922_ net2297 net1979 VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__nand2_1
XFILLER_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13641_ _06572_ _06573_ _06476_ _06475_ VGND VGND VPWR VPWR _06662_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_84_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_810 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10853_ _03786_ _03787_ _03784_ net648 VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__o211ai_2
XFILLER_32_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13572_ _06291_ _06292_ VGND VGND VPWR VPWR _06601_ sky130_fd_sc_hd__nand2b_1
XFILLER_12_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10784_ _03864_ _03866_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__nand2_1
X_12523_ _05601_ _05602_ _05606_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__nand3b_1
XFILLER_24_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12454_ _03889_ _05539_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__and2_1
X_12385_ _05463_ _05469_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__or2_1
X_11405_ net867 _04142_ _04476_ _04489_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__o211a_1
X_14124_ net2871 VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__inv_2
X_11336_ net1611 net2648 _04418_ _04421_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__a31oi_2
XFILLER_141_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14055_ net2851 VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__inv_2
XFILLER_99_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13006_ net2685 net1291 _05816_ net838 net1289 VGND VGND VPWR VPWR _06040_ sky130_fd_sc_hd__a311o_1
X_11267_ net2422 net1957 net1983 net2392 VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__a22oi_1
XFILLER_121_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11198_ net2392 net1957 VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__nand2_1
X_10218_ net804 _03303_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nand2_2
XFILLER_79_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10149_ net350 net349 net896 VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__and3_1
X_13908_ net143 net318 _05603_ _05601_ VGND VGND VPWR VPWR _06857_ sky130_fd_sc_hd__a31o_1
XFILLER_35_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13839_ net1991 net2657 net2680 net1965 _05286_ VGND VGND VPWR VPWR _06802_ sky130_fd_sc_hd__a221o_1
X_07360_ net1424 net2162 _07089_ _07090_ VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__a22o_1
XFILLER_62_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07291_ _06948_ _06991_ _07008_ _07009_ _06990_ VGND VGND VPWR VPWR _07062_ sky130_fd_sc_hd__a221o_1
X_09030_ net903 net818 _02109_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__and3_4
XFILLER_129_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09932_ _02782_ _02783_ _02784_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__a21bo_1
XFILLER_131_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout815 _02377_ VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_98_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout804 _03279_ VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_129_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout837 _05814_ VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout848 _05790_ VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_86_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout826 _01099_ VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__buf_1
X_09863_ _02944_ _02947_ _02948_ VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__nand3_1
XFILLER_140_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08814_ net467 VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__inv_2
XFILLER_86_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout859 _05712_ VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09794_ net1672 net2408 VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__and2_1
X_08745_ _01672_ _01673_ net469 _01711_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__a31oi_4
XFILLER_39_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_142_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08676_ net1443 net1475 net2381 net2410 VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__nand4_1
XFILLER_38_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07627_ net2156 net1594 VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__nand2_1
XFILLER_26_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07558_ net1448 net2243 VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__nand2_1
XFILLER_10_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07489_ _00570_ _00571_ _00572_ VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__nand3_1
XFILLER_10_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer410 _05836_ VGND VGND VPWR VPWR net3328 sky130_fd_sc_hd__dlymetal6s2s_1
X_09228_ _01930_ _01927_ _01928_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__a21o_1
X_09159_ net1352 net1380 net2588 net2614 VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__nand4_2
XFILLER_135_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_2_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12170_ _05213_ _05217_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__nand2_4
XFILLER_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11121_ net3046 _03862_ _03860_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__a21o_1
XFILLER_1_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11052_ net1610 net1645 net2622 net2646 VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__and4_1
XFILLER_103_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10003_ _03085_ _03086_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__nand2_4
XFILLER_76_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11954_ net622 net619 _05028_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__a21oi_1
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11885_ net628 _04951_ _04969_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__a21oi_1
X_10905_ _03986_ _03988_ VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__nand2_1
X_13624_ _06647_ _06646_ net138 VGND VGND VPWR VPWR _06648_ sky130_fd_sc_hd__mux2_4
X_10836_ net2387 net1846 _03916_ _03917_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_32_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13555_ net162 _06583_ _06582_ VGND VGND VPWR VPWR _06584_ sky130_fd_sc_hd__a21oi_2
XFILLER_9_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10767_ net566 _03852_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__and2_1
XFILLER_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12506_ _05580_ _05410_ _05411_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__a21boi_1
X_13486_ _06512_ _06404_ _06511_ _06514_ VGND VGND VPWR VPWR _06515_ sky130_fd_sc_hd__o22a_4
XFILLER_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10698_ _03778_ _03779_ _03780_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__nand3_4
X_12437_ _05518_ _05514_ _07018_ _05522_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_113_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12368_ _05447_ _05453_ VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__nand2_1
X_14107_ net2812 VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__inv_2
XFILLER_141_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12299_ _02493_ _02495_ _02515_ net328 VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__a31oi_1
XFILLER_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11319_ _04397_ _04398_ net1195 net1112 VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__a211o_1
X_14038_ net2863 VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__inv_2
XFILLER_95_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_124_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08530_ _01269_ _01609_ _01611_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__nand3_4
X_08461_ _01541_ _01542_ _01515_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__a21o_1
XFILLER_23_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07412_ net1339 net2284 _00496_ _00497_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_106_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08392_ net1351 net1379 net2561 net2587 VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__nand4_1
X_07343_ _00423_ _00424_ _00428_ VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__o21a_1
XFILLER_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07274_ _07039_ _07040_ _07043_ _07044_ VGND VGND VPWR VPWR _07045_ sky130_fd_sc_hd__nand4_4
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09013_ _02094_ _02095_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__nand2_4
XFILLER_129_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout601 _06979_ VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__buf_2
Xfanout612 _01123_ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__clkbuf_2
X_09915_ _02710_ net812 _02997_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__o21a_1
Xfanout623 net624 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__buf_8
XFILLER_98_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout667 _02828_ VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__buf_6
X_09846_ net1543 net2553 VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__nand2_2
Xfanout645 _03926_ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__buf_1
Xfanout656 _03310_ VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__buf_6
XFILLER_112_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout678 _02148_ VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__buf_2
Xfanout689 _01475_ VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__buf_1
XFILLER_86_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09777_ _02862_ net460 _02831_ _02836_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_27_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08728_ _01806_ _01810_ _01782_ _01813_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__o211a_4
XTAP_TAPCELL_ROW_68_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08659_ _01724_ _01730_ net2989 net210 VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__a22oi_4
XFILLER_14_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11670_ _04752_ _04754_ _04724_ _04730_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_40_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10621_ _03695_ _03699_ _03701_ _03703_ VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_40_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13340_ net262 _06209_ _06365_ net2140 VGND VGND VPWR VPWR _06369_ sky130_fd_sc_hd__o211ai_1
X_10552_ _03617_ _03619_ _03620_ _03636_ _03630_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__a32oi_4
X_13271_ net772 net539 net1488 VGND VGND VPWR VPWR _06300_ sky130_fd_sc_hd__a21o_1
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer240 net3159 VGND VGND VPWR VPWR net3158 sky130_fd_sc_hd__buf_6
Xrebuffer262 _06398_ VGND VGND VPWR VPWR net3180 sky130_fd_sc_hd__buf_6
Xrebuffer273 adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR net3191 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer251 net3226 VGND VGND VPWR VPWR net3169 sky130_fd_sc_hd__buf_4
XFILLER_6_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12222_ _04661_ _04663_ _04783_ VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__o21a_1
X_10483_ _03568_ _03564_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nand2_4
XFILLER_142_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer295 _01720_ VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__buf_6
Xrebuffer284 net1459 VGND VGND VPWR VPWR net3202 sky130_fd_sc_hd__dlygate4sd1_1
Xfanout2801 opcode_stage1 VGND VGND VPWR VPWR net2801 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_9_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2812 net2813 VGND VGND VPWR VPWR net2812 sky130_fd_sc_hd__clkbuf_2
X_12153_ _05234_ _05236_ _05238_ _05237_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__a22oi_4
XFILLER_111_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2845 net2846 VGND VGND VPWR VPWR net2845 sky130_fd_sc_hd__clkbuf_1
X_11104_ net422 net420 _04178_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__a21o_1
Xfanout2834 net2847 VGND VGND VPWR VPWR net2834 sky130_fd_sc_hd__buf_1
Xfanout2823 net2824 VGND VGND VPWR VPWR net2823 sky130_fd_sc_hd__buf_1
X_12084_ net1137 net1112 _04990_ _05081_ _05080_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__o221ai_1
Xfanout2878 net2880 VGND VGND VPWR VPWR net2878 sky130_fd_sc_hd__clkbuf_2
XFILLER_110_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2867 net2870 VGND VGND VPWR VPWR net2867 sky130_fd_sc_hd__clkbuf_2
Xfanout2856 net2861 VGND VGND VPWR VPWR net2856 sky130_fd_sc_hd__buf_1
X_11035_ _03907_ _03908_ net646 _03904_ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__o211ai_1
Xfanout2889 net2895 VGND VGND VPWR VPWR net2889 sky130_fd_sc_hd__buf_1
XFILLER_103_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12986_ net2015 _05870_ VGND VGND VPWR VPWR _06025_ sky130_fd_sc_hd__nor2_1
XFILLER_92_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11937_ _05021_ _05022_ _05017_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__a21oi_1
X_11868_ _04950_ _04952_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__nor2_1
X_14587_ clknet_leaf_7_clk net3471 _00409_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
X_13607_ _06524_ net176 _06531_ _06615_ _06627_ VGND VGND VPWR VPWR _06633_ sky130_fd_sc_hd__a32oi_4
X_11799_ _04732_ _04733_ _04749_ _04750_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__o2bb2ai_1
X_10819_ net1580 net2625 _03830_ _03831_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__a22oi_2
X_13538_ net177 net2578 net532 VGND VGND VPWR VPWR _06567_ sky130_fd_sc_hd__mux2_4
XPHY_EDGE_ROW_65_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13469_ net229 _06190_ net226 _06381_ VGND VGND VPWR VPWR _06498_ sky130_fd_sc_hd__o211a_1
XFILLER_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07961_ _00867_ _00873_ _00866_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__o21a_1
XFILLER_114_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09700_ _02782_ _02785_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__nand2_2
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07892_ net596 _00857_ _00874_ _00875_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_114_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_74_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09631_ net1430 net2581 VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_108_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09562_ _02222_ net2433 net1576 _02219_ VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__and4_1
X_08513_ _01598_ _01586_ _01597_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__and3_1
XFILLER_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09493_ _02577_ net674 _02562_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__a21oi_4
XFILLER_51_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08444_ net1240 net1174 _01523_ _01525_ VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_63_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08375_ _01455_ net2555 net1409 _01457_ VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__a31o_1
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07326_ _07086_ _07095_ _07096_ VGND VGND VPWR VPWR _07097_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_83_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07257_ _07027_ net1509 net2080 _07026_ VGND VGND VPWR VPWR _07028_ sky130_fd_sc_hd__nand4_2
X_07188_ net2039 net2064 VGND VGND VPWR VPWR _06959_ sky130_fd_sc_hd__nand2_2
Xfanout2108 net2109 VGND VGND VPWR VPWR net2108 sky130_fd_sc_hd__buf_1
Xfanout2119 net2120 VGND VGND VPWR VPWR net2119 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1418 net1428 VGND VGND VPWR VPWR net1418 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_92_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1429 adder_inst.man_b_r\[20\] VGND VGND VPWR VPWR net1429 sky130_fd_sc_hd__clkbuf_4
Xfanout420 _04185_ VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__clkbuf_1
Xfanout1407 net1408 VGND VGND VPWR VPWR net1407 sky130_fd_sc_hd__clkbuf_1
Xfanout431 _03155_ VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_8
Xfanout464 _02360_ VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_2
Xfanout475 _01265_ VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__buf_6
Xfanout497 net498 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__buf_1
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_2
X_09829_ _02910_ _02909_ _02911_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__nand3_2
X_12840_ net2781 net2699 net741 net2784 net835 VGND VGND VPWR VPWR _05898_ sky130_fd_sc_hd__a221o_1
XFILLER_86_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12771_ net1291 net1289 net750 net1287 VGND VGND VPWR VPWR _05833_ sky130_fd_sc_hd__a31oi_1
XFILLER_27_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14510_ clknet_leaf_0_clk multiplier_inst.man_final\[10\] _00332_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_70_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11722_ net2990 _04802_ _04219_ _04785_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__o211ai_1
XFILLER_30_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14441_ clknet_leaf_11_clk adder_inst.is_nan_b _00263_ VGND VGND VPWR VPWR adder_inst.is_nan_b_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11653_ _04737_ _04738_ _04735_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__o21a_1
XFILLER_30_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14372_ clknet_leaf_2_clk adder_inst.sum_raw\[21\] _00194_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_10604_ net2972 _03683_ _03685_ _03686_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__nand4_4
XFILLER_128_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13323_ net519 net186 _06351_ VGND VGND VPWR VPWR _06352_ sky130_fd_sc_hd__a21oi_1
X_11584_ _04669_ _04666_ _04668_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__o21ai_2
XFILLER_127_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10535_ _03619_ _03620_ _03617_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__and3_1
XFILLER_129_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13254_ net266 _06176_ _06281_ VGND VGND VPWR VPWR _06283_ sky130_fd_sc_hd__o21ai_1
XFILLER_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10466_ net454 net452 _03317_ _03319_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__nand4_2
XFILLER_124_832 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13185_ net1585 net479 _06214_ VGND VGND VPWR VPWR _06215_ sky130_fd_sc_hd__o21a_1
X_12205_ _05273_ _05290_ _05284_ _05271_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__and4b_1
XFILLER_97_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10397_ _02546_ _03479_ _03482_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__o21ai_2
X_12136_ _05221_ _05218_ _05220_ VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__o21ai_1
Xfanout2620 net2621 VGND VGND VPWR VPWR net2620 sky130_fd_sc_hd__buf_1
XFILLER_123_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2631 net2632 VGND VGND VPWR VPWR net2631 sky130_fd_sc_hd__buf_2
Xfanout2642 net2643 VGND VGND VPWR VPWR net2642 sky130_fd_sc_hd__buf_1
Xfanout2653 net2654 VGND VGND VPWR VPWR net2653 sky130_fd_sc_hd__buf_1
Xfanout2686 net2687 VGND VGND VPWR VPWR net2686 sky130_fd_sc_hd__buf_1
Xfanout2697 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR net2697 sky130_fd_sc_hd__buf_1
Xfanout1930 net1932 VGND VGND VPWR VPWR net1930 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1952 net1956 VGND VGND VPWR VPWR net1952 sky130_fd_sc_hd__buf_4
Xfanout1941 net1942 VGND VGND VPWR VPWR net1941 sky130_fd_sc_hd__buf_4
X_12067_ _04985_ net189 VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__nand2_1
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2664 net2665 VGND VGND VPWR VPWR net2664 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2675 net2676 VGND VGND VPWR VPWR net2675 sky130_fd_sc_hd__buf_1
Xfanout1974 net1975 VGND VGND VPWR VPWR net1974 sky130_fd_sc_hd__clkbuf_2
Xfanout1985 net1993 VGND VGND VPWR VPWR net1985 sky130_fd_sc_hd__clkbuf_1
X_11018_ net1643 net2593 net2625 net1608 VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__a22oi_1
Xfanout1963 net1965 VGND VGND VPWR VPWR net1963 sky130_fd_sc_hd__buf_1
Xfanout1996 adder_inst.is_inf_r VGND VGND VPWR VPWR net1996 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_77_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12969_ net2734 net2742 net2720 _06009_ VGND VGND VPWR VPWR _06010_ sky130_fd_sc_hd__or4b_1
XFILLER_21_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08160_ net2175 net1747 VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__nand2_1
X_07111_ net1499 VGND VGND VPWR VPWR _06883_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08091_ _01175_ _01176_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__nand2_1
XFILLER_115_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08993_ _01920_ _01755_ _01919_ _02077_ _02078_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__o2111a_1
X_07944_ net703 net702 _01018_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__a21oi_2
X_07875_ _00885_ _00887_ _00888_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__a21o_1
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09614_ net1235 net1117 VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__nor2_2
XFILLER_83_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09545_ _02625_ _02179_ _02623_ _02627_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_39_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09476_ _02557_ _02558_ net2992 VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_19_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08427_ _01505_ _01506_ _01512_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__nand3_2
X_08358_ _01440_ _01434_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__nand2_1
Xclkload2 clknet_leaf_11_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
XFILLER_109_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07309_ _07076_ _07077_ _07079_ VGND VGND VPWR VPWR _07080_ sky130_fd_sc_hd__o21a_1
X_08289_ net692 _01374_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__nand2_1
X_10320_ _03390_ _03403_ _03393_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__a21oi_2
XFILLER_124_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10251_ _03336_ _03332_ _03335_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1204 _06889_ VGND VGND VPWR VPWR net1204 sky130_fd_sc_hd__clkbuf_4
X_10182_ net1005 net925 net2204 net1926 net808 VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__o2111ai_4
Xfanout1215 net1216 VGND VGND VPWR VPWR net1215 sky130_fd_sc_hd__buf_4
XFILLER_78_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout250 _02671_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_1
Xfanout1226 net1227 VGND VGND VPWR VPWR net1226 sky130_fd_sc_hd__buf_4
Xfanout1237 net1238 VGND VGND VPWR VPWR net1237 sky130_fd_sc_hd__buf_4
X_13941_ add_res\[5\] net3477 net2794 VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__mux2_1
XFILLER_93_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1248 _06883_ VGND VGND VPWR VPWR net1248 sky130_fd_sc_hd__clkbuf_2
Xfanout1259 net1260 VGND VGND VPWR VPWR net1259 sky130_fd_sc_hd__buf_2
XFILLER_87_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout261 net263 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_6
Xfanout272 net274 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_8
Xfanout283 net284 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_2
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_4
XFILLER_47_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13872_ net118 net117 _06830_ VGND VGND VPWR VPWR _06831_ sky130_fd_sc_hd__and3_1
XFILLER_46_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12823_ net1297 net753 net2686 _05876_ VGND VGND VPWR VPWR _05885_ sky130_fd_sc_hd__a2bb2o_1
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12754_ net1316 net1299 _05786_ VGND VGND VPWR VPWR _05816_ sky130_fd_sc_hd__and3_1
XFILLER_91_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11705_ _04647_ _04645_ _04646_ net416 VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__a31oi_1
X_12685_ _05755_ _05758_ _05759_ VGND VGND VPWR VPWR _05760_ sky130_fd_sc_hd__or3_2
X_14424_ clknet_leaf_14_clk net3355 _00246_ VGND VGND VPWR VPWR adder_inst.man_b_r\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_11636_ net450 _04721_ VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__nand2_1
X_14355_ clknet_leaf_3_clk adder_inst.sum_raw\[4\] _00177_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_11567_ net202 net3115 VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__nand2_1
X_13306_ net336 _06333_ _06334_ net305 VGND VGND VPWR VPWR _06335_ sky130_fd_sc_hd__nand4_1
X_14286_ clknet_leaf_12_clk net1 _00108_ VGND VGND VPWR VPWR adder_inst.i_a\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10518_ _03598_ _03599_ _03600_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__nand3_4
X_13237_ net267 _06197_ _06265_ net286 VGND VGND VPWR VPWR _06266_ sky130_fd_sc_hd__o211ai_4
XFILLER_7_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11498_ _04581_ _04583_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__nand2_1
X_10449_ _03504_ _03508_ net882 VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__o21ai_1
XFILLER_130_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13168_ net1403 net2087 net480 VGND VGND VPWR VPWR _06198_ sky130_fd_sc_hd__mux2_1
XFILLER_111_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2472 net2473 VGND VGND VPWR VPWR net2472 sky130_fd_sc_hd__buf_1
X_13099_ net1668 net373 net366 net3204 net335 VGND VGND VPWR VPWR _06129_ sky130_fd_sc_hd__o2111ai_4
Xfanout2461 net2462 VGND VGND VPWR VPWR net2461 sky130_fd_sc_hd__clkbuf_1
X_12119_ net383 _05128_ _05113_ _05115_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2450 net2455 VGND VGND VPWR VPWR net2450 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2483 net2484 VGND VGND VPWR VPWR net2483 sky130_fd_sc_hd__buf_6
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2494 net2495 VGND VGND VPWR VPWR net2494 sky130_fd_sc_hd__buf_4
Xfanout1760 net1761 VGND VGND VPWR VPWR net1760 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1782 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR net1782 sky130_fd_sc_hd__buf_6
Xfanout1771 net1772 VGND VGND VPWR VPWR net1771 sky130_fd_sc_hd__buf_6
Xfanout1793 net1799 VGND VGND VPWR VPWR net1793 sky130_fd_sc_hd__clkbuf_2
X_07660_ net1365 net1391 net2306 net2338 VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__nand4_2
XFILLER_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07591_ _00673_ _00568_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__nand2_1
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09330_ _02396_ _02413_ _02414_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_36_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09261_ net1252 net1212 _06890_ _00952_ _00955_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__o221ai_2
XFILLER_21_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08212_ _01293_ _01294_ _01290_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__nand3_4
XFILLER_138_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09192_ _02271_ _02276_ _02277_ VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_134_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08143_ _01225_ _01226_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__nor2_1
XFILLER_107_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08074_ net612 _01159_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__nand2_1
XFILLER_106_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08976_ _02021_ _02056_ _02057_ VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_71_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07927_ net1386 net2367 net2385 net1359 VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__a22o_1
XFILLER_84_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07858_ net2048 net2021 net1779 net1806 VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__and4_1
XFILLER_84_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07789_ _00866_ _00868_ _00871_ _00872_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__a22oi_2
XFILLER_71_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09528_ _02153_ _02154_ net465 _02132_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__o211ai_1
XFILLER_43_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09459_ _02530_ _02532_ _02531_ _02543_ _02541_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__a2111oi_4
XFILLER_131_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12470_ _05555_ VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__inv_2
X_11421_ _04343_ _04506_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__nand2_2
X_14140_ net2907 VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__inv_2
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11352_ _04434_ _04436_ _04433_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__a21oi_2
X_10303_ net1233 net1102 _03180_ _03182_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__o211ai_4
X_14071_ net2802 VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__inv_2
X_11283_ net2455 net2480 net1883 net1913 VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__nand4_1
XFILLER_112_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13022_ _06051_ _05656_ _05647_ VGND VGND VPWR VPWR _06052_ sky130_fd_sc_hd__nand3_4
X_10234_ _03317_ _03319_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__nand2_1
XFILLER_133_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1001 net1002 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__buf_4
Xfanout1012 net1014 VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__buf_2
X_10165_ net182 net181 _03012_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__a21o_1
Xfanout1056 net1057 VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__buf_1
XFILLER_120_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1045 net1046 VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__buf_4
XFILLER_94_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1034 _00472_ VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__buf_1
Xfanout1023 net1026 VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__clkbuf_2
Xfanout1078 net1079 VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1067 net1068 VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__clkbuf_2
Xfanout1089 net1092 VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__dlymetal6s2s_1
X_10096_ net1517 net1544 net2552 net2584 VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__nand4_4
X_13924_ net132 _05625_ _05622_ VGND VGND VPWR VPWR _06868_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_89_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13855_ _05537_ net3045 _04236_ net2941 _04812_ VGND VGND VPWR VPWR _06818_ sky130_fd_sc_hd__a311o_1
XFILLER_35_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12806_ net1313 net753 VGND VGND VPWR VPWR _05868_ sky130_fd_sc_hd__nor2_1
XFILLER_34_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13786_ net3404 net723 VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__and2_1
XFILLER_43_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10998_ net1735 net2536 VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__nand2_1
XFILLER_34_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12737_ net1313 net1308 net1303 net1296 VGND VGND VPWR VPWR _05799_ sky130_fd_sc_hd__a211oi_1
XFILLER_31_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12668_ _05742_ _05743_ _05639_ VGND VGND VPWR VPWR _05747_ sky130_fd_sc_hd__o21ai_1
X_14407_ clknet_leaf_10_clk net3387 _00229_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_11619_ _04270_ _04401_ net1768 net2596 _04400_ VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__o2111ai_4
XFILLER_128_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12599_ net1277 net2006 net861 VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__nand3_1
XFILLER_116_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold506 add_res\[27\] VGND VGND VPWR VPWR net3424 sky130_fd_sc_hd__dlygate4sd3_1
Xhold517 add_res\[30\] VGND VGND VPWR VPWR net3435 sky130_fd_sc_hd__dlygate4sd3_1
X_14338_ clknet_leaf_17_clk net45 _00160_ VGND VGND VPWR VPWR adder_inst.i_b\[20\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold539 mul_res\[6\] VGND VGND VPWR VPWR net3457 sky130_fd_sc_hd__dlygate4sd3_1
Xhold528 add_res\[10\] VGND VGND VPWR VPWR net3446 sky130_fd_sc_hd__dlygate4sd3_1
X_14269_ net2911 VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__inv_2
XFILLER_131_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08830_ net3077 _01908_ _01909_ net356 _01826_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_111_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2280 net2285 VGND VGND VPWR VPWR net2280 sky130_fd_sc_hd__clkbuf_2
X_08761_ net1010 net980 _01647_ _01650_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__o22ai_1
Xfanout2291 net2292 VGND VGND VPWR VPWR net2291 sky130_fd_sc_hd__clkbuf_2
XFILLER_122_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07712_ _00655_ _00657_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__nor2_1
X_08692_ net685 _01769_ _01777_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__a21oi_1
Xfanout1590 net1593 VGND VGND VPWR VPWR net1590 sky130_fd_sc_hd__buf_1
X_07643_ _00611_ _00625_ _00724_ _00728_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__o211ai_2
XFILLER_81_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07574_ net717 _00640_ _00654_ _00656_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__a22o_1
X_09313_ _00995_ _00996_ _00997_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__a21o_1
XFILLER_81_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09244_ _02327_ _02328_ _02325_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__o21ai_1
X_09175_ _02260_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__inv_2
XFILLER_21_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08126_ net2227 net2263 net1710 net1745 VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__nand4_2
XFILLER_135_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08057_ net2121 net2154 net1803 net1835 VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08959_ _02041_ _02042_ _02039_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__a21oi_2
XFILLER_56_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11970_ net551 _05054_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__or2_1
XFILLER_84_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10921_ _03995_ _04000_ net424 net425 VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__o211ai_4
XFILLER_71_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13640_ _06477_ _06661_ VGND VGND VPWR VPWR adder_inst.sum_raw\[7\] sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_84_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10852_ _03784_ net647 _03788_ _03789_ VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13571_ _06298_ _06598_ VGND VGND VPWR VPWR _06600_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_84_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_822 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10783_ _03863_ _03867_ _03868_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__nand3_2
X_12522_ _05601_ _05607_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__nor2_1
XFILLER_12_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12453_ _05538_ net2940 VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__nand2_1
XFILLER_126_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12384_ _05467_ _05468_ _05463_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__or3b_4
X_11404_ _04486_ _04489_ _04479_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__a21o_1
XFILLER_125_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14123_ net2840 VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__inv_2
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11335_ net1646 net2650 net2668 net1611 VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__a22oi_2
XFILLER_137_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14054_ net2863 VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__inv_2
X_11266_ net2392 net2422 net1957 net1983 VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__nand4_2
XFILLER_134_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13005_ _05810_ net1290 _05793_ net837 VGND VGND VPWR VPWR _06039_ sky130_fd_sc_hd__a31o_1
X_10217_ _03275_ _03278_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__nand2_2
X_11197_ net2353 net1983 VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__nand2_1
XFILLER_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10148_ net1354 net2639 _02950_ net350 net349 VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__a32o_1
X_10079_ net1635 net2462 VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__nand2_1
X_13907_ _06855_ _06856_ VGND VGND VPWR VPWR multiplier_inst.man_final\[13\] sky130_fd_sc_hd__and2_4
XFILLER_90_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13838_ net3157 net2948 _06800_ VGND VGND VPWR VPWR _06801_ sky130_fd_sc_hd__o21a_1
X_13769_ net155 net161 _06767_ _06256_ VGND VGND VPWR VPWR _06775_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_46_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07290_ _07020_ _07021_ _07055_ _07056_ _07060_ VGND VGND VPWR VPWR _07061_ sky130_fd_sc_hd__o41a_1
XFILLER_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09931_ _02782_ _02783_ _02784_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__a21o_1
XFILLER_131_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout816 _02248_ VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__buf_1
Xfanout805 _03279_ VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__buf_1
Xfanout838 net839 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__buf_1
Xfanout849 _05790_ VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__clkbuf_1
Xfanout827 _01099_ VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__buf_1
X_09862_ _02694_ _02696_ _02701_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__nand3_1
XFILLER_140_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08813_ _01706_ _01894_ _01897_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__nand3b_4
XFILLER_85_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09793_ net1697 net1729 net2342 net2376 VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__nand4_2
X_08744_ _01672_ net469 _01673_ _01711_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__a31o_4
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08675_ _01563_ _01759_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__nand2_2
XFILLER_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07626_ net2096 net2125 net1627 net1660 VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__nand4_1
XFILLER_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07557_ net2209 net2252 VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_66_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07488_ _00487_ _00503_ net478 VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__nand3_1
XFILLER_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer411 _05889_ VGND VGND VPWR VPWR net3329 sky130_fd_sc_hd__dlymetal6s4s_1
X_09227_ _01738_ _01732_ _01736_ _01927_ _01930_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__o2111ai_4
Xrebuffer400 _06532_ VGND VGND VPWR VPWR net3318 sky130_fd_sc_hd__clkbuf_2
X_09158_ _02218_ _02217_ net3020 _02243_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__nand4_4
X_08109_ _01160_ _01190_ _01191_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__nand3_2
X_09089_ net1216 net1204 net984 net974 _01350_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__o221ai_4
XFILLER_123_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11120_ net3042 _03857_ _03858_ _03862_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__nand4_2
XFILLER_131_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11051_ net1645 net2622 net2646 net1610 VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__a22oi_1
X_10002_ net660 _03077_ _03083_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__and3_1
XFILLER_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11953_ net619 net863 net621 VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_103_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11884_ _04943_ _04945_ _04947_ _04950_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__a31oi_1
XFILLER_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10904_ net797 _03984_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__nor2_1
X_13623_ net171 _06562_ _06563_ _06645_ _06568_ VGND VGND VPWR VPWR _06647_ sky130_fd_sc_hd__a41oi_1
X_10835_ net2389 net1846 VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_43_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13554_ _06441_ _06442_ _06579_ _06429_ VGND VGND VPWR VPWR _06583_ sky130_fd_sc_hd__nor4b_4
X_10766_ _03845_ _03848_ _03849_ _03414_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__a31o_1
X_12505_ net125 _05589_ VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__nand2_2
X_13485_ _06467_ _06466_ net294 net223 VGND VGND VPWR VPWR _06514_ sky130_fd_sc_hd__a31o_1
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10697_ _03778_ _03779_ _03780_ VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__and3_1
XFILLER_126_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12436_ _05520_ _05521_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__nor2_1
XFILLER_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12367_ _05448_ _05452_ VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_112_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14106_ net2812 VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__inv_2
X_12298_ _05374_ _05373_ _05372_ VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__nand3b_1
X_11318_ net1143 net1120 net3145 net1114 net1193 VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__o32a_4
XFILLER_113_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14037_ net2851 VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__inv_2
XFILLER_79_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11249_ _04297_ _04300_ _04010_ _04016_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_121_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_121_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08460_ _01515_ _01541_ _01542_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__nand3_1
XFILLER_36_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07411_ net1366 net1392 net2221 net2254 VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__nand4_4
XFILLER_90_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08391_ net1351 net1379 net2561 net2587 VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_106_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07342_ _00427_ net1510 net2133 _00426_ VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__nand4_4
Xclkbuf_leaf_15_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_50_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_139_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07273_ _07042_ net2192 net1340 _07041_ VGND VGND VPWR VPWR _07044_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_130_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09012_ net2089 net1949 net1973 net2063 VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__a22oi_4
XFILLER_117_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout613 _00902_ VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__clkbuf_2
Xfanout602 net603 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlymetal6s2s_1
X_09914_ _02997_ _02998_ _02995_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__a21oi_1
Xfanout624 _05002_ VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__buf_6
XFILLER_113_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout646 _03903_ VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__buf_6
X_09845_ _02924_ _02926_ _02927_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__nand3_2
Xfanout657 _03310_ VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__clkbuf_1
Xfanout635 _04366_ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_6
XFILLER_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout679 _02038_ VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__clkbuf_2
Xfanout668 _02727_ VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__buf_4
XFILLER_73_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09776_ _02853_ _02858_ _02861_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__o21ai_2
X_08727_ _01806_ _01808_ _01784_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__o21ai_4
XFILLER_73_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08658_ _01724_ _01730_ net210 _01743_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__a22o_4
X_07609_ _00688_ _00691_ _00692_ VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_81_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08589_ _01662_ _01663_ net375 _01671_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__a31oi_4
X_10620_ _03695_ _03699_ _03701_ _03703_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__o22a_4
XTAP_TAPCELL_ROW_40_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10551_ _03633_ _03635_ _03630_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__o21a_1
XFILLER_139_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13270_ net493 _06298_ _06293_ VGND VGND VPWR VPWR _06299_ sky130_fd_sc_hd__a21oi_1
Xrebuffer230 _02277_ VGND VGND VPWR VPWR net3148 sky130_fd_sc_hd__clkbuf_2
Xrebuffer241 _05210_ VGND VGND VPWR VPWR net3159 sky130_fd_sc_hd__buf_6
X_10482_ _03333_ _03335_ net1669 net2467 VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__nand4_2
Xrebuffer274 net195 VGND VGND VPWR VPWR net3192 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer252 _06207_ VGND VGND VPWR VPWR net3170 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer263 _06206_ VGND VGND VPWR VPWR net3181 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_10_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12221_ _04776_ _04893_ _04895_ _04989_ _05306_ VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__o311ai_4
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer285 _06062_ VGND VGND VPWR VPWR net3203 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer296 _04001_ VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_135_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2802 net2803 VGND VGND VPWR VPWR net2802 sky130_fd_sc_hd__clkbuf_2
X_12152_ _05183_ _05185_ _05192_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__a21o_1
XFILLER_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2846 net2847 VGND VGND VPWR VPWR net2846 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2835 net2839 VGND VGND VPWR VPWR net2835 sky130_fd_sc_hd__clkbuf_2
Xfanout2813 net2820 VGND VGND VPWR VPWR net2813 sky130_fd_sc_hd__buf_1
X_11103_ net421 net419 _04177_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__nand3_2
Xfanout2824 net2848 VGND VGND VPWR VPWR net2824 sky130_fd_sc_hd__buf_1
X_12083_ _05166_ _05167_ _05165_ VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__nand3_1
Xfanout2879 net2880 VGND VGND VPWR VPWR net2879 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_92_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2868 net2870 VGND VGND VPWR VPWR net2868 sky130_fd_sc_hd__clkbuf_2
Xfanout2857 net2860 VGND VGND VPWR VPWR net2857 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11034_ net646 _03904_ _03907_ _03908_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_89_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12985_ net1324 _06024_ net1320 VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__o21a_1
XFILLER_91_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11936_ _04910_ _04912_ _04922_ _04924_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_33_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11867_ _04948_ _04949_ _04942_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__a21o_1
X_14586_ clknet_leaf_5_clk net3441 _00408_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
X_13606_ _06615_ _06632_ VGND VGND VPWR VPWR adder_inst.sum_raw\[2\] sky130_fd_sc_hd__xnor2_2
X_11798_ _04877_ _04881_ _04882_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__a21boi_4
X_10818_ _03899_ _03900_ _03901_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__nand3b_2
X_13537_ net511 net177 _06496_ VGND VGND VPWR VPWR _06566_ sky130_fd_sc_hd__o21ai_1
XFILLER_43_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10749_ _03399_ net2641 net1522 VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__nand3_1
XFILLER_118_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13468_ net2577 net515 _06496_ VGND VGND VPWR VPWR _06497_ sky130_fd_sc_hd__o21a_1
XFILLER_142_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12419_ _05462_ _05474_ _05473_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__o21bai_1
X_13399_ _06409_ _06410_ VGND VGND VPWR VPWR _06428_ sky130_fd_sc_hd__nand2b_1
XFILLER_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07960_ _00869_ _00872_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__nand2_1
XFILLER_102_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_4_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_07891_ _00876_ _00877_ net596 _00857_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__o211ai_1
XFILLER_67_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09630_ _02714_ net811 VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_108_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09561_ net1576 net2433 _02219_ _02222_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__a22oi_1
X_08512_ net1500 net2384 _01592_ net909 VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__a22o_1
XFILLER_130_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09492_ _02573_ _02575_ _02564_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__o21ai_4
X_08443_ _01526_ _01520_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__nand2_1
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08374_ _01453_ _01454_ _01459_ VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__a21o_1
XFILLER_139_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07325_ _07037_ _07092_ _07093_ VGND VGND VPWR VPWR _07096_ sky130_fd_sc_hd__nand3_2
X_07256_ _06950_ _07025_ VGND VGND VPWR VPWR _07027_ sky130_fd_sc_hd__nand2_1
X_07187_ _06956_ _06957_ VGND VGND VPWR VPWR _06958_ sky130_fd_sc_hd__nor2_1
XFILLER_3_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2109 net2110 VGND VGND VPWR VPWR net2109 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_6_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout410 _00910_ VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_1
Xfanout1419 net1421 VGND VGND VPWR VPWR net1419 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout432 _02983_ VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_6
Xfanout1408 net1412 VGND VGND VPWR VPWR net1408 sky130_fd_sc_hd__clkbuf_2
Xfanout421 _04184_ VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__buf_6
Xfanout443 _06411_ VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__buf_1
Xfanout465 _02130_ VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout454 _03295_ VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09828_ net399 net398 _02658_ _02660_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout487 net498 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__buf_1
Xfanout498 _06075_ VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__buf_1
XFILLER_46_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09759_ net2313 net810 net1759 _02840_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__a31o_1
XFILLER_73_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12770_ net2685 adder_inst.exp_larger_r\[7\] _05826_ _05831_ net707 VGND VGND VPWR
+ VPWR _05832_ sky130_fd_sc_hd__a311o_1
XFILLER_15_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11721_ _04797_ _04798_ _04801_ _04804_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__nand4_1
XFILLER_15_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14440_ clknet_leaf_8_clk net1318 _00262_ VGND VGND VPWR VPWR add_vld sky130_fd_sc_hd__dfrtp_1
X_11652_ _04454_ _04455_ _04456_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14371_ clknet_leaf_2_clk adder_inst.sum_raw\[20\] _00193_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_10603_ _03675_ _03678_ _03683_ _03686_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__o211ai_2
X_13322_ net769 net536 net1598 VGND VGND VPWR VPWR _06351_ sky130_fd_sc_hd__a21oi_2
X_11583_ net2485 net1935 VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__nand2_1
XFILLER_127_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10534_ _03178_ _03399_ net1497 net2644 _03398_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__o2111ai_4
XFILLER_129_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13253_ net264 _06200_ VGND VGND VPWR VPWR _06282_ sky130_fd_sc_hd__nand2_4
XFILLER_6_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10465_ net454 net452 _03317_ _03319_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__and4_1
XFILLER_135_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10396_ _03481_ _02544_ _02534_ _02087_ _03480_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__a41oi_2
X_13184_ net768 net535 net2267 VGND VGND VPWR VPWR _06214_ sky130_fd_sc_hd__a21o_1
X_12204_ _05289_ _05287_ _05288_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__and3_1
X_12135_ net1938 net2657 VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__nand2_1
Xfanout2610 net2612 VGND VGND VPWR VPWR net2610 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2621 net2635 VGND VGND VPWR VPWR net2621 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2632 net2633 VGND VGND VPWR VPWR net2632 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2643 net2644 VGND VGND VPWR VPWR net2643 sky130_fd_sc_hd__clkbuf_1
Xfanout2654 net2655 VGND VGND VPWR VPWR net2654 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2687 net2695 VGND VGND VPWR VPWR net2687 sky130_fd_sc_hd__buf_1
Xfanout1931 net1932 VGND VGND VPWR VPWR net1931 sky130_fd_sc_hd__clkbuf_1
Xfanout1942 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net1942 sky130_fd_sc_hd__buf_6
X_12066_ _05146_ net200 net197 net189 VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__a211oi_1
Xfanout2665 net2666 VGND VGND VPWR VPWR net2665 sky130_fd_sc_hd__clkbuf_1
Xfanout1920 net1921 VGND VGND VPWR VPWR net1920 sky130_fd_sc_hd__buf_1
Xfanout2676 net2677 VGND VGND VPWR VPWR net2676 sky130_fd_sc_hd__buf_1
Xfanout2698 net2700 VGND VGND VPWR VPWR net2698 sky130_fd_sc_hd__clkbuf_2
Xfanout1975 net1977 VGND VGND VPWR VPWR net1975 sky130_fd_sc_hd__buf_4
Xfanout1953 net1954 VGND VGND VPWR VPWR net1953 sky130_fd_sc_hd__buf_2
XFILLER_49_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1986 net1992 VGND VGND VPWR VPWR net1986 sky130_fd_sc_hd__clkbuf_2
Xfanout1964 net1965 VGND VGND VPWR VPWR net1964 sky130_fd_sc_hd__dlymetal6s2s_1
X_11017_ net1608 net1643 net2593 net2618 VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__nand4_1
XFILLER_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1997 net1998 VGND VGND VPWR VPWR net1997 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_49_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_121_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_121_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12968_ net2757 net2754 net2748 VGND VGND VPWR VPWR _06009_ sky130_fd_sc_hd__mux2_1
X_12899_ net2763 net1055 net2766 net736 net840 VGND VGND VPWR VPWR _05949_ sky130_fd_sc_hd__o221a_1
X_11919_ net1890 net2599 VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_103_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14569_ clknet_leaf_0_clk net3476 _00391_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
X_07110_ net2149 VGND VGND VPWR VPWR _06882_ sky130_fd_sc_hd__inv_2
XFILLER_13_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08090_ _01174_ _01172_ _01171_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__nand3b_4
XTAP_TAPCELL_ROW_11_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08992_ _02072_ net213 _01942_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__a21o_1
X_07943_ _01026_ _01027_ _01025_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__a21o_1
XFILLER_96_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07874_ net1259 net1213 net1047 net981 _00885_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__o221ai_4
XFILLER_29_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09613_ net2515 net2546 VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__nand2_2
XFILLER_141_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09544_ _02625_ _02179_ _02623_ _02627_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_39_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09475_ _02559_ _02560_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08426_ _01510_ _01511_ VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__nor2_1
X_08357_ net1239 net1167 net1021 net913 _01439_ VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__o221ai_2
Xclkload3 clknet_leaf_13_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_16
X_07308_ _07029_ _07077_ _07076_ VGND VGND VPWR VPWR _07079_ sky130_fd_sc_hd__o21ai_1
X_08288_ _01369_ _01370_ net693 VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__o21ai_1
X_07239_ _06990_ _06993_ _07009_ VGND VGND VPWR VPWR _07010_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_76_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10250_ net1669 net2466 VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__nand2_1
XFILLER_105_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1205 _06889_ VGND VGND VPWR VPWR net1205 sky130_fd_sc_hd__buf_2
X_10181_ net2206 net1926 _03032_ net808 VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__a22o_4
XFILLER_132_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout240 net241 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_6
XFILLER_94_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1216 _06888_ VGND VGND VPWR VPWR net1216 sky130_fd_sc_hd__buf_4
Xfanout1227 net1228 VGND VGND VPWR VPWR net1227 sky130_fd_sc_hd__buf_4
Xfanout1238 _06883_ VGND VGND VPWR VPWR net1238 sky130_fd_sc_hd__buf_4
X_13940_ add_res\[4\] net3475 net2792 VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__mux2_1
Xfanout251 _01054_ VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_2
XFILLER_120_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout262 net263 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__clkbuf_2
Xfanout273 net274 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__buf_8
XFILLER_87_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout295 _06129_ VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_6
Xfanout284 _06136_ VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__clkbuf_2
X_13871_ net122 _05572_ _05565_ VGND VGND VPWR VPWR _06830_ sky130_fd_sc_hd__a21boi_1
XFILLER_19_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12822_ net2698 _05883_ _05873_ _05872_ VGND VGND VPWR VPWR _05884_ sky130_fd_sc_hd__a2bb2o_1
X_12753_ _05793_ _05810_ net1290 net1288 VGND VGND VPWR VPWR _05815_ sky130_fd_sc_hd__a211oi_4
XFILLER_61_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11704_ _04786_ _04787_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__nand2_1
XFILLER_15_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14423_ clknet_leaf_14_clk net3358 _00245_ VGND VGND VPWR VPWR adder_inst.man_b_r\[13\]
+ sky130_fd_sc_hd__dfrtp_2
X_12684_ _05753_ _05754_ _05757_ VGND VGND VPWR VPWR _05759_ sky130_fd_sc_hd__or3_1
XFILLER_15_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11635_ _04716_ _04718_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__nand2_2
X_14354_ clknet_leaf_3_clk adder_inst.sum_raw\[3\] _00176_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_11566_ _04625_ _04643_ _04649_ _04648_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__o211ai_4
X_14285_ clknet_leaf_6_clk net65 _00107_ VGND VGND VPWR VPWR adder_inst.i_vld sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_118_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13305_ net265 _06183_ net280 _06306_ VGND VGND VPWR VPWR _06334_ sky130_fd_sc_hd__o211ai_4
X_10517_ _03601_ _03602_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__nand2_4
X_13236_ net267 _06195_ VGND VGND VPWR VPWR _06265_ sky130_fd_sc_hd__nand2_4
X_11497_ _04488_ _04480_ net631 net557 net555 VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__o2111ai_4
X_10448_ net1179 net1175 _03529_ net881 VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_131_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13167_ _06877_ net1271 net481 VGND VGND VPWR VPWR _06197_ sky130_fd_sc_hd__mux2_1
X_10379_ _03233_ _03235_ net3017 net3064 VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__o211ai_4
Xfanout2440 net2443 VGND VGND VPWR VPWR net2440 sky130_fd_sc_hd__clkbuf_2
X_13098_ net335 net312 net3225 VGND VGND VPWR VPWR _06128_ sky130_fd_sc_hd__and3_4
Xfanout2451 net2453 VGND VGND VPWR VPWR net2451 sky130_fd_sc_hd__buf_8
XFILLER_2_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12118_ _05095_ net3127 _05112_ net383 _05128_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__o2111ai_4
Xfanout2462 net2465 VGND VGND VPWR VPWR net2462 sky130_fd_sc_hd__buf_4
Xfanout1750 net1753 VGND VGND VPWR VPWR net1750 sky130_fd_sc_hd__clkbuf_2
Xfanout2484 net2485 VGND VGND VPWR VPWR net2484 sky130_fd_sc_hd__buf_4
X_12049_ _05051_ _05059_ _05055_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__a21o_1
Xfanout2495 net2496 VGND VGND VPWR VPWR net2495 sky130_fd_sc_hd__clkbuf_2
Xfanout2473 net2490 VGND VGND VPWR VPWR net2473 sky130_fd_sc_hd__buf_4
Xfanout1772 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR net1772 sky130_fd_sc_hd__buf_6
Xfanout1794 net1796 VGND VGND VPWR VPWR net1794 sky130_fd_sc_hd__clkbuf_2
Xfanout1761 net1762 VGND VGND VPWR VPWR net1761 sky130_fd_sc_hd__buf_2
XFILLER_38_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07590_ _00521_ _00546_ _00547_ _00566_ _00567_ VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__o2111ai_1
XFILLER_92_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09260_ _02342_ _02344_ _02345_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_16_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08211_ _01295_ _01296_ _01291_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__a21oi_2
XFILLER_60_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09191_ _02272_ _02273_ _02266_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__a21o_1
X_08142_ _01222_ _01224_ _01220_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__a21oi_2
X_08073_ _01124_ _01155_ _01157_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_58_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08975_ net591 _02020_ _02056_ _02057_ VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__o211ai_2
XFILLER_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07926_ _00850_ _01007_ _01008_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_71_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07857_ net2021 net1778 VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__nand2_1
XFILLER_17_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07788_ _00873_ _00867_ _00866_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__nor3b_1
XFILLER_16_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09527_ _02153_ _02154_ _02125_ _02131_ net465 VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__o221a_1
XFILLER_101_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09458_ net1011 _02541_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__nor2_8
X_09389_ _02465_ _02466_ _02473_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__a21o_1
X_08409_ net1411 net2498 VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__nand2_1
XFILLER_138_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11420_ _04278_ _04279_ net451 VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__o21ai_1
XFILLER_124_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11351_ net973 net910 _04433_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__o21ai_1
X_10302_ _03182_ _03180_ _03183_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__a21o_4
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14070_ net2805 VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__inv_2
X_11282_ net2481 net1886 VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__nand2_1
XFILLER_140_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13021_ _06927_ _06047_ _06926_ VGND VGND VPWR VPWR _06051_ sky130_fd_sc_hd__o21ai_2
X_10233_ _03298_ _03301_ net656 _03312_ net802 VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__o2111ai_4
XFILLER_120_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1002 net1004 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__buf_1
Xfanout1013 net1014 VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__buf_1
X_10164_ _03010_ _03011_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__and2_1
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1046 _06960_ VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__buf_8
Xfanout1024 net1026 VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__clkbuf_2
Xfanout1035 net1036 VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__buf_4
XFILLER_121_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1068 net1071 VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__clkbuf_2
Xfanout1057 net1060 VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__buf_1
XFILLER_120_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1079 _06917_ VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__buf_1
X_10095_ net1517 net1544 net2584 net2552 VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__and4_1
X_13923_ _05629_ _05631_ _05636_ _06866_ _06867_ VGND VGND VPWR VPWR multiplier_inst.man_final\[18\]
+ sky130_fd_sc_hd__o311a_4
XTAP_TAPCELL_ROW_89_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13854_ _06787_ _06788_ _06791_ _06816_ VGND VGND VPWR VPWR _06817_ sky130_fd_sc_hd__a211o_1
X_12805_ net740 _05865_ net1312 VGND VGND VPWR VPWR _05867_ sky130_fd_sc_hd__a21bo_1
XFILLER_62_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13785_ multiplier_inst.overflow_calc_r multiplier_inst.is_zero_r _06780_ net1319
+ VGND VGND VPWR VPWR _06781_ sky130_fd_sc_hd__and4bb_1
X_10997_ net1703 net2566 VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__nand2_1
XFILLER_31_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12736_ net1314 net1309 net1303 VGND VGND VPWR VPWR _05798_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_100_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_711 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12667_ _05745_ net107 net110 net102 VGND VGND VPWR VPWR _05746_ sky130_fd_sc_hd__nand4_4
XFILLER_128_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14406_ clknet_leaf_11_clk net3372 _00228_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_30_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11618_ net1767 net2596 _04400_ _04402_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__a22o_1
X_12598_ net861 VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__inv_2
X_14337_ clknet_leaf_14_clk net43 _00159_ VGND VGND VPWR VPWR adder_inst.i_b\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_128_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold507 _00019_ VGND VGND VPWR VPWR net3425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold518 _00023_ VGND VGND VPWR VPWR net3436 sky130_fd_sc_hd__dlygate4sd3_1
X_11549_ _04560_ _04561_ _04632_ _04633_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__o211ai_2
Xhold529 _00001_ VGND VGND VPWR VPWR net3447 sky130_fd_sc_hd__dlygate4sd3_1
X_14268_ net2913 VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__inv_2
X_14199_ net2888 VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__inv_2
X_13219_ net2035 net530 _06247_ VGND VGND VPWR VPWR _06248_ sky130_fd_sc_hd__a21oi_1
XFILLER_97_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_111_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2270 net2271 VGND VGND VPWR VPWR net2270 sky130_fd_sc_hd__buf_4
Xfanout2281 net2283 VGND VGND VPWR VPWR net2281 sky130_fd_sc_hd__buf_2
XFILLER_111_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08760_ net1009 net980 _01647_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__o21a_1
Xfanout2292 net2293 VGND VGND VPWR VPWR net2292 sky130_fd_sc_hd__buf_1
X_07711_ _00635_ _00636_ net717 VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__o21ai_1
Xfanout1591 net1593 VGND VGND VPWR VPWR net1591 sky130_fd_sc_hd__dlymetal6s2s_1
X_08691_ _01775_ _01776_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__nand2_1
Xfanout1580 net1581 VGND VGND VPWR VPWR net1580 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07642_ _00613_ _00611_ _00624_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__o21bai_1
XFILLER_81_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07573_ net717 _00640_ _00654_ _00656_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__a22oi_2
X_09312_ _02039_ _02042_ _02040_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__a21oi_1
XFILLER_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09243_ _01946_ _02000_ _02326_ _02001_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__a211o_1
X_09174_ _01457_ _01460_ _02255_ _02256_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__o211ai_4
X_08125_ _01202_ _01209_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__nand2_1
XFILLER_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08056_ _01140_ _01141_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_749 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08958_ _02039_ _02041_ _02042_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__and3_1
X_07909_ _00841_ _00993_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__nand2_1
X_08889_ net1558 net2276 VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__nand2_1
XFILLER_17_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10920_ _04002_ _04001_ net3027 VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__a21o_1
XFILLER_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10851_ _03914_ _03915_ _03923_ net644 net797 VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__a32o_2
X_13570_ net217 net194 _06598_ VGND VGND VPWR VPWR _06599_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_84_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10782_ _03604_ _03606_ _03654_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__a21o_1
X_12521_ _05602_ _05606_ VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__nand2_1
XFILLER_72_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12452_ _05537_ net3044 _04236_ _04812_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__a31o_1
XFILLER_12_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11403_ _04087_ _04091_ _04481_ _04487_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__o211ai_4
XFILLER_125_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12383_ _05467_ _05468_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__nor2_1
X_14122_ net2901 VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__inv_2
X_11334_ net1610 net1645 net2646 net2671 VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__nand4_1
X_14053_ net2880 VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__inv_2
X_11265_ net2392 net2423 net1984 VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__nand3_2
XFILLER_21_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13004_ net1324 net1996 _06038_ net1320 VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__o31a_1
X_10216_ net2378 net802 net1760 _03298_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__a31o_1
XFILLER_97_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11196_ _04280_ _04281_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__nand2_2
XFILLER_121_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10147_ _06877_ net1093 _02712_ _03232_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__o31a_1
X_10078_ net1233 net1109 net900 _02932_ _02937_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__o221ai_2
X_13906_ _05605_ net128 _06850_ _06848_ _06853_ VGND VGND VPWR VPWR _06856_ sky130_fd_sc_hd__o221ai_2
XFILLER_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13837_ _05214_ net3153 net2948 VGND VGND VPWR VPWR _06800_ sky130_fd_sc_hd__o21ai_1
X_13768_ _06766_ net152 _06255_ VGND VGND VPWR VPWR _06774_ sky130_fd_sc_hd__mux2_4
XFILLER_50_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_12719_ _05768_ _05771_ _05772_ adder_inst.exp_a\[2\] VGND VGND VPWR VPWR adder_inst.is_nan_a
+ sky130_fd_sc_hd__and4_1
X_13699_ _06359_ _06713_ VGND VGND VPWR VPWR adder_inst.sum_raw\[14\] sky130_fd_sc_hd__xnor2_2
XFILLER_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09930_ _02782_ _02783_ _02784_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_55_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout806 _03259_ VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__buf_8
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout839 net845 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout828 _01083_ VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__clkbuf_4
Xfanout817 _02248_ VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__buf_1
X_09861_ _02693_ _02695_ _02701_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__o21bai_1
XFILLER_112_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08812_ _01896_ _01895_ _01891_ _01893_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__o22ai_1
X_09792_ _02640_ _02877_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__nand2_2
X_08743_ _01816_ _01821_ _01823_ _01820_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__o211ai_4
XFILLER_26_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08674_ net1475 net2381 net2410 net1443 VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__a22oi_1
XFILLER_93_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07625_ net2125 net1627 net1660 net2096 VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__a22o_1
XFILLER_81_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07556_ net1482 net2244 VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__nand2_1
XFILLER_139_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07487_ _00487_ net478 _00503_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__a21o_1
X_09226_ _01927_ net3033 _01929_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__a21o_1
XFILLER_21_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer412 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR net3330 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer401 _06240_ VGND VGND VPWR VPWR net3319 sky130_fd_sc_hd__buf_6
XFILLER_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09157_ _02237_ _02240_ _02230_ _02231_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__o211ai_4
X_08108_ _01123_ _01159_ _01192_ _01193_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__nand4_2
X_09088_ _01347_ _02170_ _02172_ _02168_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__o22a_1
X_08039_ net2172 net1800 VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11050_ _04005_ _04004_ _04133_ VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__nand3_4
X_10001_ net660 _03077_ _03083_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__a21oi_1
XFILLER_92_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11952_ net620 net863 net621 VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__and3_1
X_11883_ _04736_ _04968_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__nand2_1
X_10903_ net1184 net1163 _03929_ _03933_ _03984_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__o311a_1
X_13622_ _06638_ _06645_ _06568_ VGND VGND VPWR VPWR _06646_ sky130_fd_sc_hd__a21o_1
XFILLER_60_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10834_ _03916_ _03917_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__nand2_1
X_13553_ _06429_ _06451_ _06422_ VGND VGND VPWR VPWR _06582_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_43_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12504_ net143 net317 _05589_ VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__a21boi_1
X_10765_ _03845_ _03848_ _03849_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__nand3_1
XFILLER_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13484_ net379 net310 net195 VGND VGND VPWR VPWR _06513_ sky130_fd_sc_hd__o21ai_2
X_10696_ net1669 net2502 _03561_ _03562_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__a22o_1
XFILLER_40_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12435_ net1345 net2033 _06935_ _07013_ _07016_ VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__a311oi_2
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12366_ net381 _05451_ VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_113_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14105_ net2812 VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__inv_2
X_11317_ net1767 net2596 VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__nand2_1
X_12297_ _05372_ _05373_ _05374_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__a21bo_1
XFILLER_107_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14036_ net2912 VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__inv_2
X_11248_ _04331_ _04330_ _04328_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__nand3_4
XFILLER_95_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11179_ _04260_ net2536 net1763 _04258_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_128_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_141_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07410_ net1392 net2221 net2254 net1366 VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__a22o_1
X_08390_ net2577 net2603 VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_106_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07341_ _00423_ _00424_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__nand2_1
XFILLER_35_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07272_ net1340 net2192 _07041_ _07042_ VGND VGND VPWR VPWR _07043_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_21_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09011_ net2063 net2089 net1949 net1973 VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__nand4_4
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout614 _00902_ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__buf_1
Xfanout603 _06070_ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__buf_6
X_09913_ _02998_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__inv_2
Xfanout658 _03274_ VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__buf_6
Xfanout647 _03785_ VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__clkbuf_2
X_09844_ _02929_ _02923_ _02928_ VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__nand3_4
Xfanout636 _04305_ VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__buf_6
Xfanout669 _02727_ VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__clkbuf_2
XFILLER_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09775_ _02855_ _02844_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__nand2_1
X_08726_ _01811_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_68_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08657_ _01736_ _01740_ _01742_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__a21oi_2
X_07608_ _00691_ _00692_ _00688_ VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__a21bo_1
XFILLER_81_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08588_ _01667_ _01668_ _01669_ _01258_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07539_ _00614_ _00624_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__nand2_1
XFILLER_22_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10550_ _03618_ _03632_ _03634_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__nand3_2
XFILLER_108_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09209_ _02292_ _02293_ _02294_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__a21oi_1
Xrebuffer220 _03453_ VGND VGND VPWR VPWR net3138 sky130_fd_sc_hd__buf_6
X_10481_ _03333_ _03335_ net1206 net1161 VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__o2bb2ai_1
Xrebuffer231 _04344_ VGND VGND VPWR VPWR net3149 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer264 net3181 VGND VGND VPWR VPWR net3182 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer253 _06056_ VGND VGND VPWR VPWR net3171 sky130_fd_sc_hd__buf_6
X_12220_ _05303_ _05305_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__nand2_4
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer242 _05110_ VGND VGND VPWR VPWR net3160 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_108_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer275 net3192 VGND VGND VPWR VPWR net3193 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_79_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer286 net342 VGND VGND VPWR VPWR net3204 sky130_fd_sc_hd__buf_2
Xrebuffer297 _04996_ VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__buf_6
XFILLER_135_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2803 net2805 VGND VGND VPWR VPWR net2803 sky130_fd_sc_hd__clkbuf_2
XFILLER_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12151_ _05183_ _05185_ _05192_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__nand3_2
Xfanout2836 net2838 VGND VGND VPWR VPWR net2836 sky130_fd_sc_hd__buf_2
Xfanout2825 net2827 VGND VGND VPWR VPWR net2825 sky130_fd_sc_hd__buf_2
X_11102_ net421 net419 _04177_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__and3_4
Xfanout2814 net2815 VGND VGND VPWR VPWR net2814 sky130_fd_sc_hd__clkbuf_2
X_12082_ _05166_ _05167_ _05165_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__and3_1
Xfanout2869 net2870 VGND VGND VPWR VPWR net2869 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_92_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2858 net2860 VGND VGND VPWR VPWR net2858 sky130_fd_sc_hd__clkbuf_2
X_11033_ _03905_ _03906_ net646 _03904_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__o211ai_1
Xfanout2847 net2848 VGND VGND VPWR VPWR net2847 sky130_fd_sc_hd__buf_1
XFILLER_134_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12984_ _06017_ _06023_ net3329 VGND VGND VPWR VPWR _06024_ sky130_fd_sc_hd__o21ba_1
XFILLER_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11935_ _04920_ _04921_ _04910_ _04912_ VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_123_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13605_ net765 _06627_ _06631_ VGND VGND VPWR VPWR _06632_ sky130_fd_sc_hd__o21ai_2
X_11866_ _04948_ net628 _04942_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__a21oi_1
X_14585_ clknet_leaf_5_clk net3417 _00407_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
XFILLER_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11797_ _04869_ _04872_ _04873_ _04881_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__a31o_1
X_10817_ net875 _03776_ _03899_ _03902_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__o211ai_1
X_13536_ _06495_ _06558_ _06563_ _06506_ VGND VGND VPWR VPWR _06565_ sky130_fd_sc_hd__nand4b_4
X_10748_ _03623_ net2619 net1550 VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__nand3_1
XFILLER_13_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13467_ net780 net546 net1893 VGND VGND VPWR VPWR _06496_ sky130_fd_sc_hd__a21o_1
X_12418_ _05493_ _05498_ _05501_ _05503_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__a31o_1
X_10679_ net573 _03547_ net575 VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__and3_4
X_13398_ _06426_ _06424_ VGND VGND VPWR VPWR _06427_ sky130_fd_sc_hd__or2_4
XFILLER_126_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12349_ _05382_ _05412_ _05427_ _05434_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__nor4_1
XFILLER_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14019_ net2815 VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__inv_2
X_07890_ net596 _00857_ _00876_ _00877_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09560_ _02635_ _02636_ _02644_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__nand3_1
X_08511_ _01592_ net909 net1500 net2384 VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__nand4_1
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09491_ _02576_ _02574_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__nand2_2
X_08442_ _01525_ net2400 net1500 _01523_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_63_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08373_ net1409 net2554 VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__nand2_1
X_07324_ _07037_ _07093_ _07092_ VGND VGND VPWR VPWR _07095_ sky130_fd_sc_hd__a21o_1
XFILLER_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07255_ net2054 net2028 net1537 net1566 VGND VGND VPWR VPWR _07026_ sky130_fd_sc_hd__nand4_2
X_07186_ _06955_ net2164 net1342 _06954_ VGND VGND VPWR VPWR _06957_ sky130_fd_sc_hd__and4_1
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout411 _00785_ VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__buf_2
Xfanout400 _02165_ VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_2
Xfanout422 _04184_ VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__clkbuf_1
Xfanout1409 net1410 VGND VGND VPWR VPWR net1409 sky130_fd_sc_hd__buf_1
Xfanout444 net445 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__buf_1
Xfanout466 _02130_ VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_1
Xfanout433 _02981_ VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_2
Xfanout455 _03130_ VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__buf_1
Xfanout477 _01012_ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__clkbuf_2
Xfanout488 net489 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__buf_1
Xfanout499 net501 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlymetal6s2s_1
X_09827_ _02612_ _02618_ net398 _02661_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__o211ai_2
XFILLER_104_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09758_ net810 net1759 net2313 _02840_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__a31oi_4
X_08709_ net1528 net2302 VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__nand2_1
XFILLER_64_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09689_ net209 _02774_ _02749_ _02760_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__o2bb2ai_1
X_11720_ _04795_ _04803_ _04801_ _04797_ _04798_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__o2111a_1
XFILLER_15_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11651_ net1203 net1100 _04424_ _04454_ _04456_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__o311a_1
XFILLER_120_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14370_ clknet_leaf_2_clk adder_inst.sum_raw\[19\] _00192_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_11582_ net2423 net2452 net1958 net1984 VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__nand4_4
X_10602_ _03454_ _03456_ _03469_ net190 VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__o211ai_2
XFILLER_127_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13321_ net221 net211 net255 _06349_ VGND VGND VPWR VPWR _06350_ sky130_fd_sc_hd__o211ai_2
X_10533_ _03398_ _03400_ net1238 net1101 VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_109_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13252_ net266 _06201_ VGND VGND VPWR VPWR _06281_ sky130_fd_sc_hd__nand2_2
X_10464_ _03547_ net575 net573 VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__a21boi_4
X_10395_ _02317_ _02084_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__nand2_4
XFILLER_89_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13183_ net1569 net2251 net479 VGND VGND VPWR VPWR _06213_ sky130_fd_sc_hd__mux2_1
X_12203_ _05269_ net2679 net1920 _05267_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__nand4_1
XFILLER_135_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12134_ net1963 net1988 net2601 net2631 VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__nand4_1
Xfanout2611 net2612 VGND VGND VPWR VPWR net2611 sky130_fd_sc_hd__clkbuf_2
Xfanout2600 net2604 VGND VGND VPWR VPWR net2600 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_97_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2633 net2634 VGND VGND VPWR VPWR net2633 sky130_fd_sc_hd__clkbuf_2
Xfanout2644 net2645 VGND VGND VPWR VPWR net2644 sky130_fd_sc_hd__clkbuf_2
Xfanout2622 net2624 VGND VGND VPWR VPWR net2622 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2688 net2695 VGND VGND VPWR VPWR net2688 sky130_fd_sc_hd__clkbuf_2
XFILLER_89_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1932 net1933 VGND VGND VPWR VPWR net1932 sky130_fd_sc_hd__clkbuf_2
Xfanout1910 net1911 VGND VGND VPWR VPWR net1910 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_8_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12065_ _05146_ net201 net196 VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__a21oi_1
Xfanout2666 net2667 VGND VGND VPWR VPWR net2666 sky130_fd_sc_hd__buf_2
Xfanout1921 net1922 VGND VGND VPWR VPWR net1921 sky130_fd_sc_hd__clkbuf_2
Xfanout2655 net2659 VGND VGND VPWR VPWR net2655 sky130_fd_sc_hd__clkbuf_2
Xfanout2677 net2678 VGND VGND VPWR VPWR net2677 sky130_fd_sc_hd__buf_1
Xfanout2699 net2700 VGND VGND VPWR VPWR net2699 sky130_fd_sc_hd__buf_1
Xfanout1976 net1977 VGND VGND VPWR VPWR net1976 sky130_fd_sc_hd__clkbuf_2
Xfanout1954 net1955 VGND VGND VPWR VPWR net1954 sky130_fd_sc_hd__buf_1
Xfanout1965 net1966 VGND VGND VPWR VPWR net1965 sky130_fd_sc_hd__buf_1
X_11016_ net1644 net2593 VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__nand2_1
XFILLER_38_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1998 net1999 VGND VGND VPWR VPWR net1998 sky130_fd_sc_hd__clkbuf_2
XFILLER_49_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1987 net1989 VGND VGND VPWR VPWR net1987 sky130_fd_sc_hd__clkbuf_4
XFILLER_64_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12967_ _06007_ _06008_ net243 VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__o21a_1
XFILLER_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12898_ net2770 net2729 net833 _05947_ VGND VGND VPWR VPWR _05948_ sky130_fd_sc_hd__a211o_1
X_11918_ net1916 net2597 VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_103_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11849_ _04828_ _04841_ _04928_ _04930_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__o211ai_4
X_14568_ clknet_leaf_0_clk net3449 _00390_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_31_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload10 clknet_leaf_0_clk VGND VGND VPWR VPWR clkload10/X sky130_fd_sc_hd__clkbuf_8
X_14499_ clknet_leaf_8_clk multiplier_inst.overflow_calc _00321_ VGND VGND VPWR VPWR
+ multiplier_inst.overflow_calc_r sky130_fd_sc_hd__dfrtp_1
X_13519_ net1099 net775 net542 _06543_ _06547_ VGND VGND VPWR VPWR _06548_ sky130_fd_sc_hd__a32o_2
XTAP_TAPCELL_ROW_31_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08991_ _02072_ net213 _01942_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__nand3_1
X_07942_ _01025_ _01026_ _01027_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__nand3_1
X_07873_ _00953_ _00957_ _00954_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__a21oi_2
XFILLER_110_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09612_ _02236_ net900 VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__nand2_2
X_09543_ _02180_ net676 _02184_ _02186_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__nand4_2
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09474_ net1257 net1129 net1125 _02096_ _02099_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__o221ai_2
XTAP_TAPCELL_ROW_19_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08425_ net1141 net1118 net1051 _01507_ _01509_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__o311a_1
XFILLER_12_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08356_ _01438_ net822 _01434_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__a21oi_2
XFILLER_24_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07307_ _07077_ _07076_ VGND VGND VPWR VPWR _07078_ sky130_fd_sc_hd__nor2_1
XFILLER_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload4 clknet_leaf_14_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
XFILLER_20_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08287_ _01369_ _01370_ net693 VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__o21a_1
XFILLER_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07238_ _06995_ _07007_ VGND VGND VPWR VPWR _07009_ sky130_fd_sc_hd__or2_1
XFILLER_50_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07169_ _06938_ _06939_ VGND VGND VPWR VPWR _06940_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_76_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10180_ net1005 net925 _03031_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__o21ai_1
XFILLER_120_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout241 _05890_ VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_6
Xfanout230 net231 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_2
Xfanout1228 _06885_ VGND VGND VPWR VPWR net1228 sky130_fd_sc_hd__buf_4
Xfanout1206 net1211 VGND VGND VPWR VPWR net1206 sky130_fd_sc_hd__buf_2
Xfanout252 net259 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_2
Xfanout274 net1542 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_8
Xfanout1239 net1241 VGND VGND VPWR VPWR net1239 sky130_fd_sc_hd__clkbuf_2
Xfanout263 net3260 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_2
X_13870_ _05552_ net117 _06828_ _06829_ VGND VGND VPWR VPWR multiplier_inst.man_final\[3\]
+ sky130_fd_sc_hd__o2bb2a_4
XFILLER_19_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12821_ _05799_ _05858_ _05882_ _05881_ _05880_ VGND VGND VPWR VPWR _05883_ sky130_fd_sc_hd__o311a_1
XFILLER_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12752_ net2688 net2696 VGND VGND VPWR VPWR _05814_ sky130_fd_sc_hd__or2_1
XFILLER_27_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12683_ adder_inst.i_b\[21\] adder_inst.i_b\[20\] adder_inst.i_b\[22\] _05756_ VGND
+ VGND VPWR VPWR _05758_ sky130_fd_sc_hd__or4_1
X_11703_ _04198_ _04199_ _04201_ VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__nand3_1
XFILLER_15_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14422_ clknet_leaf_14_clk net3362 _00244_ VGND VGND VPWR VPWR adder_inst.man_b_r\[12\]
+ sky130_fd_sc_hd__dfrtp_2
X_11634_ _04715_ _04708_ net630 VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__and3_1
XFILLER_128_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14353_ clknet_leaf_2_clk adder_inst.sum_raw\[2\] _00175_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_11565_ _04625_ _04643_ _04648_ _04649_ VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_118_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14284_ clknet_leaf_7_clk net3464 _00106_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
X_13304_ _06331_ net305 _06330_ net413 VGND VGND VPWR VPWR _06333_ sky130_fd_sc_hd__nand4_4
X_11496_ _04488_ _04480_ net631 net557 net555 VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__o2111a_1
X_10516_ net3023 net348 _03360_ _03361_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__o2bb2ai_2
X_13235_ net188 _06263_ VGND VGND VPWR VPWR _06264_ sky130_fd_sc_hd__nand2_1
XFILLER_6_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10447_ _03532_ _03529_ net881 VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__o21ai_2
XFILLER_124_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_131_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13166_ net269 _06193_ VGND VGND VPWR VPWR _06196_ sky130_fd_sc_hd__nand2_1
X_10378_ _03452_ _03448_ _03462_ net208 VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__a2bb2oi_4
Xfanout2441 net2442 VGND VGND VPWR VPWR net2441 sky130_fd_sc_hd__clkbuf_1
XFILLER_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13097_ _06124_ _06125_ VGND VGND VPWR VPWR _06127_ sky130_fd_sc_hd__nand2_2
Xfanout2452 net2453 VGND VGND VPWR VPWR net2452 sky130_fd_sc_hd__clkbuf_2
Xfanout2463 net2464 VGND VGND VPWR VPWR net2463 sky130_fd_sc_hd__clkbuf_2
X_12117_ net383 _05128_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__nand2_1
Xfanout2430 net2434 VGND VGND VPWR VPWR net2430 sky130_fd_sc_hd__clkbuf_2
Xfanout1751 net1752 VGND VGND VPWR VPWR net1751 sky130_fd_sc_hd__clkbuf_2
Xfanout2485 net2486 VGND VGND VPWR VPWR net2485 sky130_fd_sc_hd__clkbuf_2
Xfanout1740 net1741 VGND VGND VPWR VPWR net1740 sky130_fd_sc_hd__clkbuf_1
X_12048_ _05051_ _05059_ _05055_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__nand3_2
Xfanout2474 net2475 VGND VGND VPWR VPWR net2474 sky130_fd_sc_hd__clkbuf_2
Xfanout2496 net2500 VGND VGND VPWR VPWR net2496 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1773 net1775 VGND VGND VPWR VPWR net1773 sky130_fd_sc_hd__clkbuf_2
Xfanout1784 net1793 VGND VGND VPWR VPWR net1784 sky130_fd_sc_hd__buf_2
Xfanout1762 net1772 VGND VGND VPWR VPWR net1762 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_77_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1795 net1796 VGND VGND VPWR VPWR net1795 sky130_fd_sc_hd__buf_1
XFILLER_37_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13999_ net2836 VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__inv_2
XFILLER_25_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08210_ net1269 net1129 _01077_ _01078_ net828 VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_60_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09190_ _02273_ _02266_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__nand2_4
XFILLER_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08141_ _01220_ _01222_ _01224_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__and3_1
XFILLER_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08072_ _01155_ _01157_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__nand2_1
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_804 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08974_ _02021_ _02058_ _02059_ VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__nand3_2
XFILLER_88_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07925_ _01010_ _01006_ _01009_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07856_ net2046 net1806 VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__nand2_2
X_07787_ _00871_ _00872_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__nand2_1
XFILLER_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09526_ net3109 _02581_ _02582_ net463 _02609_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__a32o_1
X_09457_ _02537_ _02538_ _02535_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__a21oi_4
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08408_ _01456_ _01466_ _01462_ VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__a21oi_1
XFILLER_138_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09388_ _02470_ _02472_ _02471_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__o21a_1
X_08339_ net1167 net1161 net1018 net1149 net1237 VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__o32a_1
X_11350_ _04086_ _04428_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__nand2_1
XFILLER_125_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10301_ net886 _03384_ _03382_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__a21oi_1
X_13020_ net1054 _06048_ _06925_ VGND VGND VPWR VPWR _06050_ sky130_fd_sc_hd__a21oi_4
X_11281_ net1856 net2513 VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__nand2_1
XFILLER_133_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10232_ _03302_ net657 _03312_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__and3_1
Xfanout1003 net1004 VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__buf_2
X_10163_ _03241_ _03242_ _03243_ _03245_ _03246_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__a32o_1
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1025 net1026 VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1047 net1050 VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__buf_2
XFILLER_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1014 _00474_ VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__buf_4
Xfanout1036 _00447_ VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__clkbuf_1
XFILLER_120_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1058 net1060 VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__buf_4
Xfanout1069 net1070 VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__clkbuf_2
X_10094_ _02932_ _03178_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__nand2_2
X_13922_ _06863_ _06865_ VGND VGND VPWR VPWR _06867_ sky130_fd_sc_hd__or2_4
XFILLER_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13853_ _05309_ _06789_ _06815_ _06792_ VGND VGND VPWR VPWR _06816_ sky130_fd_sc_hd__o211ai_2
XFILLER_19_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12804_ net1312 net742 _05865_ VGND VGND VPWR VPWR _05866_ sky130_fd_sc_hd__or3b_1
XFILLER_90_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13784_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r VGND VGND VPWR VPWR _06780_
+ sky130_fd_sc_hd__nor2_1
X_10996_ _03981_ _03992_ _04075_ _04079_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_33_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12735_ net1315 net1308 VGND VGND VPWR VPWR _05797_ sky130_fd_sc_hd__and2_4
XFILLER_15_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12666_ _05744_ _05729_ _05741_ VGND VGND VPWR VPWR _05745_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_13_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14405_ clknet_leaf_11_clk net3376 _00227_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_12597_ adder_inst.exp_b_r\[5\] net2004 VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__xor2_1
X_11617_ _04400_ _04402_ _04403_ VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_133_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11548_ _04632_ _04633_ _04563_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__a21o_1
X_14336_ clknet_leaf_14_clk net42 _00158_ VGND VGND VPWR VPWR adder_inst.i_b\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_128_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold508 adder_inst.i_b\[2\] VGND VGND VPWR VPWR net3426 sky130_fd_sc_hd__dlygate4sd3_1
X_14267_ net2913 VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__inv_2
Xhold519 add_res\[24\] VGND VGND VPWR VPWR net3437 sky130_fd_sc_hd__dlygate4sd3_1
X_11479_ _04563_ _04564_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__and2_1
X_14198_ net2892 VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__inv_2
X_13218_ net1968 net215 _06245_ VGND VGND VPWR VPWR _06247_ sky130_fd_sc_hd__and3_1
XFILLER_124_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13149_ net266 _06176_ VGND VGND VPWR VPWR _06179_ sky130_fd_sc_hd__nand2_1
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2271 net2286 VGND VGND VPWR VPWR net2271 sky130_fd_sc_hd__clkbuf_2
Xfanout2260 net2261 VGND VGND VPWR VPWR net2260 sky130_fd_sc_hd__buf_4
X_07710_ _00792_ _00794_ _00685_ VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__nand3b_4
Xfanout2282 net2283 VGND VGND VPWR VPWR net2282 sky130_fd_sc_hd__clkbuf_1
Xfanout2293 net2294 VGND VGND VPWR VPWR net2293 sky130_fd_sc_hd__buf_1
Xfanout1592 net1593 VGND VGND VPWR VPWR net1592 sky130_fd_sc_hd__dlymetal6s2s_1
X_08690_ _01770_ _01772_ _01773_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__nand3_1
Xfanout1581 net1584 VGND VGND VPWR VPWR net1581 sky130_fd_sc_hd__clkbuf_1
X_07641_ _00612_ _00614_ _00618_ _00623_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__nand4_1
XFILLER_65_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07572_ net717 _00640_ _00654_ _00656_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__nand4_1
X_09311_ _02039_ _02042_ _02040_ VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__a21o_1
XFILLER_18_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09242_ _01946_ _02000_ _02326_ _02001_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__a211oi_1
X_09173_ _02255_ _02257_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__nand3b_2
XFILLER_119_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08124_ net2264 net1710 net1744 net2227 VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__a22oi_4
XFILLER_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08055_ net2154 net1803 VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__nand2_1
XFILLER_122_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08957_ net1591 net2238 net1003 net998 VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__o2bb2a_1
X_07908_ net1561 net2239 net2275 net1529 VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__a22oi_2
X_08888_ net1503 net2335 VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__and2_1
X_07839_ _00746_ net829 VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__nand2_1
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10850_ _03914_ _03915_ net549 net644 net797 VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__a32oi_4
XFILLER_112_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09509_ _02593_ _02594_ _02588_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__nand3_4
XFILLER_12_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10781_ _03604_ _03606_ _03651_ _03653_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__nand4_1
XFILLER_25_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12520_ _05603_ _05605_ VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__nor2_1
XFILLER_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12451_ _05535_ _04809_ _04234_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__a21oi_1
X_11402_ _04087_ _04091_ _04481_ _04487_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__o211a_1
X_14121_ net2901 VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__inv_2
X_12382_ _05465_ _05466_ _05464_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__a21oi_1
XANTENNA_90 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11333_ net1646 net2669 VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__nand2_1
XFILLER_141_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14052_ net2878 VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__inv_2
X_11264_ net2426 net1958 VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__nand2_1
XFILLER_4_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13003_ net838 _06036_ _06037_ _06035_ VGND VGND VPWR VPWR _06038_ sky130_fd_sc_hd__o211a_1
X_10215_ net2378 net1759 VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__and2_1
XFILLER_95_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11195_ _04265_ _04267_ net638 _04276_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__o211ai_1
X_10146_ net350 net349 VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__nand2_1
XFILLER_48_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10077_ _03159_ net2583 net1494 VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__nand3_1
X_13905_ _06852_ _06854_ VGND VGND VPWR VPWR _06855_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_126_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13836_ _05296_ _05298_ VGND VGND VPWR VPWR _06799_ sky130_fd_sc_hd__xor2_1
X_13767_ _06252_ _06254_ net856 _06772_ VGND VGND VPWR VPWR _06773_ sky130_fd_sc_hd__o211ai_2
XFILLER_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10979_ net1169 net1163 net3145 _04059_ _04062_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__o32a_4
X_12718_ _05760_ _05769_ _05770_ VGND VGND VPWR VPWR adder_inst.is_nan_b sky130_fd_sc_hd__and3_1
XFILLER_43_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13698_ net760 _06711_ _06712_ VGND VGND VPWR VPWR _06713_ sky130_fd_sc_hd__o21ai_2
X_12649_ _05724_ _05728_ _05711_ VGND VGND VPWR VPWR _05729_ sky130_fd_sc_hd__nor3_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14319_ clknet_leaf_18_clk net44 _00141_ VGND VGND VPWR VPWR adder_inst.i_b\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_131_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout807 _03168_ VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlymetal6s2s_1
X_09860_ _02694_ _02696_ _02702_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__nand3_1
XFILLER_124_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout829 _00748_ VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__buf_1
XFILLER_98_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout818 _02113_ VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__clkbuf_2
XFILLER_97_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08811_ _01874_ _01889_ _01890_ _01896_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__a31o_1
XFILLER_85_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09791_ net1697 net2376 VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__nand2_1
XFILLER_85_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08742_ _01818_ _01819_ _01827_ VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__a21oi_2
Xfanout2090 net2091 VGND VGND VPWR VPWR net2090 sky130_fd_sc_hd__buf_1
X_08673_ net1475 net2381 VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__nand2_1
XFILLER_66_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07624_ net2125 net1627 net1660 net2100 VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__a22oi_1
X_07555_ net717 _00640_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__nand2_1
X_07486_ _00501_ _00502_ net478 _00487_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_66_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09225_ _01927_ _01930_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__nand2_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer413 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR net3331 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_108_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09156_ _02228_ _02223_ _02227_ _02241_ VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__a31oi_2
XFILLER_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08107_ _01177_ _01189_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__nand2_1
X_09087_ _02172_ _02168_ _02171_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__o21ai_1
X_08038_ _01094_ _01106_ _01122_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__o21ai_2
XFILLER_103_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10000_ net660 _03077_ _03084_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__nand3_2
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09989_ net1204 net1182 _02841_ net810 VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__o211ai_2
XFILLER_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11951_ net621 net619 _04936_ _05026_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_29_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11882_ net1738 net2652 net2673 net1705 VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__a22o_1
X_10902_ _03929_ _03934_ _03933_ _03925_ net645 VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__o2111ai_2
X_13621_ _06567_ _06566_ VGND VGND VPWR VPWR _06645_ sky130_fd_sc_hd__nand2_1
X_10833_ net2352 net1867 net1898 net2321 VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__a22oi_1
XFILLER_13_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13552_ _06576_ _06578_ net169 _06451_ VGND VGND VPWR VPWR _06581_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_43_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10764_ _03846_ _03847_ _03844_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__nand3b_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12503_ _01071_ _05588_ VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__xor2_2
XFILLER_12_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13483_ net223 _06398_ VGND VGND VPWR VPWR _06512_ sky130_fd_sc_hd__nand2_2
XFILLER_13_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10695_ net1695 net1727 net2447 net2474 _03563_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__a41o_1
XFILLER_40_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12434_ _07013_ _07016_ net1345 net2033 _06935_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__o2111a_1
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12365_ _07101_ _00461_ _05449_ VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_97_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14104_ net2808 VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__inv_2
XFILLER_4_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11316_ net1798 net1830 net2541 net2568 VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__nand4_2
X_12296_ _05380_ _05381_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__nand2_2
XFILLER_126_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14035_ net2858 VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__inv_2
XFILLER_4_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11247_ _04330_ _04331_ _04328_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_26_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11178_ net1797 net1813 net2480 net2508 _04253_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_128_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10129_ _03152_ _03156_ _03211_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_50_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13819_ net3494 net831 net722 VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__a21o_1
XFILLER_23_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_106_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07340_ net2076 net2107 net1536 net1565 VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__nand4_2
XFILLER_51_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07271_ net1256 net1251 net1053 VGND VGND VPWR VPWR _07042_ sky130_fd_sc_hd__or3_1
X_09010_ net2064 net2089 net1973 VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_139_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_44_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout604 _06070_ VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__clkbuf_1
X_09912_ _02716_ _02728_ net432 _02996_ net670 VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__o2111ai_4
Xfanout648 _03785_ VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__clkbuf_1
X_09843_ net1234 net1117 _02925_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__o21ai_2
Xfanout626 _05001_ VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__buf_6
Xfanout637 _04305_ VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__clkbuf_2
XFILLER_100_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout659 _03177_ VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__buf_4
XFILLER_85_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09774_ net666 net665 _02845_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08725_ _01599_ _01783_ _01807_ _01809_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_68_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08656_ _01736_ _01739_ _01732_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_68_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_53_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07607_ _00692_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__inv_2
X_08587_ _01667_ _01668_ _01670_ _01255_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07538_ _00616_ _00617_ _00623_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_81_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07469_ net1420 net2219 _00489_ _00492_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_139_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer210 _05627_ VGND VGND VPWR VPWR net3128 sky130_fd_sc_hd__dlygate4sd3_1
Xrebuffer221 _02276_ VGND VGND VPWR VPWR net3139 sky130_fd_sc_hd__buf_1
X_09208_ _01479_ net2614 net1329 _01477_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__a31oi_2
Xrebuffer232 _03356_ VGND VGND VPWR VPWR net3150 sky130_fd_sc_hd__buf_2
X_10480_ net1669 net2467 _03333_ _03335_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__a22oi_2
Xrebuffer265 _06458_ VGND VGND VPWR VPWR net3183 sky130_fd_sc_hd__buf_1
X_09139_ _01421_ _01423_ net1237 net1149 VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer243 _05199_ VGND VGND VPWR VPWR net3161 sky130_fd_sc_hd__buf_1
XFILLER_118_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer276 _06136_ VGND VGND VPWR VPWR net3194 sky130_fd_sc_hd__buf_6
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer298 _05311_ VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd1_1
X_12150_ _05235_ _05228_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__nand2_1
X_11101_ net421 net419 _04177_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__a21o_4
XFILLER_1_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2837 net2838 VGND VGND VPWR VPWR net2837 sky130_fd_sc_hd__clkbuf_2
Xfanout2826 net2827 VGND VGND VPWR VPWR net2826 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_9_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2815 net2818 VGND VGND VPWR VPWR net2815 sky130_fd_sc_hd__clkbuf_2
Xfanout2804 net2805 VGND VGND VPWR VPWR net2804 sky130_fd_sc_hd__clkbuf_2
XFILLER_2_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12081_ _05080_ _05082_ net1938 net2600 VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_92_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2859 net2860 VGND VGND VPWR VPWR net2859 sky130_fd_sc_hd__clkbuf_2
Xfanout2848 net2849 VGND VGND VPWR VPWR net2848 sky130_fd_sc_hd__buf_1
X_11032_ _04050_ _04051_ _04053_ _04054_ _04064_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__a32oi_2
XFILLER_76_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12983_ net2719 net2704 _06020_ _06022_ net839 VGND VGND VPWR VPWR _06023_ sky130_fd_sc_hd__o311a_1
XFILLER_92_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_123_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11934_ _04910_ _04912_ _04920_ _04921_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_27_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13604_ net134 _06555_ _06629_ net854 _06628_ VGND VGND VPWR VPWR _06631_ sky130_fd_sc_hd__a311o_1
X_11865_ _04937_ _04941_ _04948_ net628 VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__o211ai_2
XFILLER_33_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14584_ clknet_leaf_5_clk net3397 _00406_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
XFILLER_13_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11796_ _04869_ _04872_ _04873_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__nand3_2
X_10816_ net875 _03773_ _03775_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__o21bai_1
X_13535_ _06560_ _06522_ net171 _06562_ VGND VGND VPWR VPWR _06564_ sky130_fd_sc_hd__o211ai_1
XFILLER_13_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10747_ net1000 net910 _03832_ _03829_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__o22ai_2
XFILLER_127_810 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13466_ _06490_ _06489_ VGND VGND VPWR VPWR _06495_ sky130_fd_sc_hd__and2_4
X_10678_ net575 net573 _03543_ _03545_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__o2bb2ai_4
X_12417_ _05498_ _05500_ _05493_ VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__a21oi_1
X_13397_ _06423_ _06417_ VGND VGND VPWR VPWR _06426_ sky130_fd_sc_hd__nor2_2
XFILLER_142_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12348_ _05431_ _05433_ VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__nand2_1
XFILLER_99_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12279_ _05363_ _05364_ VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__nand2_1
XFILLER_110_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14018_ net2809 VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__inv_2
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08510_ net1239 net1198 _01592_ net909 VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__o211ai_2
X_09490_ net1005 net958 net2207 net1848 _02569_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__o2111ai_4
X_08441_ _01523_ _01525_ net1240 net1174 VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_24_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08372_ net1438 net1468 net2491 net2527 VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__nand4_2
X_07323_ _07037_ _07093_ _07092_ VGND VGND VPWR VPWR _07094_ sky130_fd_sc_hd__a21oi_1
X_07254_ net2028 net1566 VGND VGND VPWR VPWR _07025_ sky130_fd_sc_hd__nand2_1
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07185_ net1342 net2164 _06954_ _06955_ VGND VGND VPWR VPWR _06956_ sky130_fd_sc_hd__a22oi_1
XFILLER_132_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout412 _00575_ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout401 _02065_ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__buf_6
XFILLER_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout423 _04080_ VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_6
XFILLER_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout445 _05698_ VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__buf_1
Xfanout434 _02981_ VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_1
XFILLER_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout456 _03069_ VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__buf_8
Xfanout478 _00504_ VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_2
Xfanout467 _01899_ VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout489 net490 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__clkbuf_1
X_09826_ net399 net397 _02661_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__and3_1
XFILLER_47_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09757_ net2312 net1759 VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__nand2_1
X_08708_ _01792_ _01793_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__nand2_1
XFILLER_64_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09688_ _02769_ _02771_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__nand2_1
XFILLER_27_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08639_ _01719_ _01721_ _01626_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__o21ai_1
XFILLER_120_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11650_ net1705 net1738 net2652 net2668 VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__nand4_2
XFILLER_120_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11581_ _04664_ _04665_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__nand2_1
X_10601_ _03469_ net190 _03458_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__a21o_1
X_13320_ net370 net227 net229 net2942 _06348_ VGND VGND VPWR VPWR _06349_ sky130_fd_sc_hd__o221ai_2
XFILLER_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10532_ _03616_ _03613_ net879 VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__o21a_1
XFILLER_129_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_70_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13251_ _06255_ _06279_ _06256_ _06250_ VGND VGND VPWR VPWR _06280_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_94_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10463_ _03524_ net3072 net3040 _03548_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__a22oi_4
XFILLER_142_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10394_ _02533_ _02542_ _02531_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__a21oi_1
X_13182_ _06210_ _06211_ net280 VGND VGND VPWR VPWR _06212_ sky130_fd_sc_hd__a21o_1
X_12202_ net1919 net2679 _05267_ _05269_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__a22o_1
XFILLER_123_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12133_ net1988 net2601 net2630 net1964 VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__a22o_1
Xfanout2601 net2602 VGND VGND VPWR VPWR net2601 sky130_fd_sc_hd__buf_1
Xfanout2634 net2635 VGND VGND VPWR VPWR net2634 sky130_fd_sc_hd__buf_4
X_12064_ net196 _05071_ _05070_ _05069_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__and4b_1
Xfanout2623 net2624 VGND VGND VPWR VPWR net2623 sky130_fd_sc_hd__buf_1
Xfanout2612 net2613 VGND VGND VPWR VPWR net2612 sky130_fd_sc_hd__clkbuf_1
Xfanout2645 net2661 VGND VGND VPWR VPWR net2645 sky130_fd_sc_hd__clkbuf_2
Xfanout1900 net1901 VGND VGND VPWR VPWR net1900 sky130_fd_sc_hd__buf_4
Xfanout1911 net1912 VGND VGND VPWR VPWR net1911 sky130_fd_sc_hd__buf_4
Xfanout1933 net1934 VGND VGND VPWR VPWR net1933 sky130_fd_sc_hd__buf_1
Xfanout2667 net2684 VGND VGND VPWR VPWR net2667 sky130_fd_sc_hd__clkbuf_2
X_11015_ net1608 net2625 VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__nand2_1
Xfanout1922 net1923 VGND VGND VPWR VPWR net1922 sky130_fd_sc_hd__clkbuf_2
Xfanout2678 net2682 VGND VGND VPWR VPWR net2678 sky130_fd_sc_hd__buf_1
Xfanout2656 net2658 VGND VGND VPWR VPWR net2656 sky130_fd_sc_hd__buf_1
Xfanout2689 net2691 VGND VGND VPWR VPWR net2689 sky130_fd_sc_hd__buf_1
Xfanout1977 net1978 VGND VGND VPWR VPWR net1977 sky130_fd_sc_hd__buf_4
Xfanout1944 net1945 VGND VGND VPWR VPWR net1944 sky130_fd_sc_hd__buf_4
Xfanout1955 net1956 VGND VGND VPWR VPWR net1955 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1966 net1967 VGND VGND VPWR VPWR net1966 sky130_fd_sc_hd__buf_6
Xfanout990 _00731_ VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__buf_6
Xfanout1999 adder_inst.exp_a_r\[7\] VGND VGND VPWR VPWR net1999 sky130_fd_sc_hd__clkbuf_2
Xfanout1988 net1989 VGND VGND VPWR VPWR net1988 sky130_fd_sc_hd__clkbuf_1
X_12966_ net2692 net2710 net2718 net757 VGND VGND VPWR VPWR _06008_ sky130_fd_sc_hd__a22o_1
XFILLER_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12897_ net2772 net1073 net1078 _05946_ VGND VGND VPWR VPWR _05947_ sky130_fd_sc_hd__o211a_1
X_11917_ net1859 net2630 VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_103_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11848_ _04828_ _04841_ _04928_ _04930_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__o211a_1
X_14567_ clknet_leaf_20_clk net3487 _00389_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_109_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13518_ net228 _06311_ _06314_ net524 VGND VGND VPWR VPWR _06547_ sky130_fd_sc_hd__a31oi_4
X_11779_ _04861_ _04862_ _04857_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_31_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14498_ clknet_leaf_8_clk _00070_ _00320_ VGND VGND VPWR VPWR multiplier_inst.is_nan_r
+ sky130_fd_sc_hd__dfrtp_1
Xclkload11 clknet_leaf_1_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__inv_8
X_13449_ _06477_ _06463_ VGND VGND VPWR VPWR _06478_ sky130_fd_sc_hd__nand2b_4
XFILLER_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08990_ _01941_ _01937_ _01940_ _02072_ net213 VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__o2111ai_2
XFILLER_142_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_118_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07941_ net1042 net985 net1417 net2336 _00860_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__o2111ai_2
XFILLER_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07872_ _00953_ _00957_ _00954_ VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__a21o_1
XFILLER_110_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09611_ net1519 net2524 VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__nand2_1
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09542_ _02180_ net676 _02183_ _02185_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_55_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09473_ _02556_ _02100_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__nand2_1
XFILLER_52_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_127_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08424_ _01508_ _01509_ _01507_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__a21oi_1
X_08355_ net1021 net913 _01434_ net822 VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__o211ai_1
X_07306_ _07023_ _07026_ _07028_ VGND VGND VPWR VPWR _07077_ sky130_fd_sc_hd__and3_1
Xclkload5 clknet_leaf_15_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_12
XFILLER_109_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08286_ _01364_ _01367_ net1587 net2371 VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__o211a_1
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07237_ _06943_ _06994_ _07007_ VGND VGND VPWR VPWR _07008_ sky130_fd_sc_hd__or3b_1
XFILLER_124_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07168_ net1341 net2112 _06936_ _06937_ VGND VGND VPWR VPWR _06939_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_76_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1229 _06885_ VGND VGND VPWR VPWR net1229 sky130_fd_sc_hd__clkbuf_1
Xfanout231 net235 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_6
Xfanout1207 net1211 VGND VGND VPWR VPWR net1207 sky130_fd_sc_hd__clkbuf_2
Xfanout1218 net1221 VGND VGND VPWR VPWR net1218 sky130_fd_sc_hd__buf_2
Xfanout242 net243 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_4
Xfanout264 net265 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_8
XFILLER_59_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout253 net254 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout286 net288 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_4
Xfanout275 net277 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__buf_8
Xfanout297 net1725 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__buf_8
X_09809_ _02647_ _02648_ net673 net672 VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__o211ai_1
X_12820_ net1303 net847 net1296 VGND VGND VPWR VPWR _05882_ sky130_fd_sc_hd__o21a_1
XFILLER_28_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12751_ net2688 net2696 VGND VGND VPWR VPWR _05813_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_38_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11702_ _04198_ net212 _04201_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__a21o_1
X_12682_ adder_inst.i_b\[17\] adder_inst.i_b\[16\] adder_inst.i_b\[19\] adder_inst.i_b\[18\]
+ VGND VGND VPWR VPWR _05757_ sky130_fd_sc_hd__or4_1
XFILLER_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14421_ clknet_leaf_17_clk net3356 _00243_ VGND VGND VPWR VPWR adder_inst.man_b_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
X_11633_ net630 _04708_ _04715_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__a21oi_1
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14352_ clknet_leaf_2_clk adder_inst.sum_raw\[1\] _00174_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_11564_ _04647_ _04646_ _04645_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__nand3_2
XFILLER_11_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14283_ clknet_leaf_7_clk net3336 _00105_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
X_13303_ net260 _06185_ VGND VGND VPWR VPWR _06332_ sky130_fd_sc_hd__nand2_1
X_11495_ net631 _04492_ net557 _04577_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__a22o_1
X_10515_ net1311 net348 net3102 _03362_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__nand4_4
X_13234_ net1422 net495 net214 net3174 _06260_ VGND VGND VPWR VPWR _06263_ sky130_fd_sc_hd__a221o_1
X_10446_ net1762 net2418 VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_131_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13165_ net1377 net2061 net480 VGND VGND VPWR VPWR _06195_ sky130_fd_sc_hd__mux2_2
X_10377_ net208 _03462_ net3041 _03448_ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__o2bb2ai_4
Xfanout2420 net2421 VGND VGND VPWR VPWR net2420 sky130_fd_sc_hd__clkbuf_1
XFILLER_124_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2442 net2443 VGND VGND VPWR VPWR net2442 sky130_fd_sc_hd__clkbuf_2
X_13096_ _06124_ _06125_ VGND VGND VPWR VPWR _06126_ sky130_fd_sc_hd__and2_1
Xfanout2453 net2454 VGND VGND VPWR VPWR net2453 sky130_fd_sc_hd__clkbuf_2
X_12116_ _05189_ _05199_ _05196_ _05195_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__o2bb2ai_4
Xfanout2431 net2434 VGND VGND VPWR VPWR net2431 sky130_fd_sc_hd__buf_2
XFILLER_111_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2486 net2487 VGND VGND VPWR VPWR net2486 sky130_fd_sc_hd__buf_6
Xfanout2464 net2465 VGND VGND VPWR VPWR net2464 sky130_fd_sc_hd__clkbuf_2
Xfanout1741 net1742 VGND VGND VPWR VPWR net1741 sky130_fd_sc_hd__clkbuf_1
X_12047_ _05053_ _05054_ _05059_ _05051_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__o211ai_1
Xfanout2475 net2478 VGND VGND VPWR VPWR net2475 sky130_fd_sc_hd__buf_1
Xfanout1730 net1733 VGND VGND VPWR VPWR net1730 sky130_fd_sc_hd__clkbuf_1
Xfanout1752 net1753 VGND VGND VPWR VPWR net1752 sky130_fd_sc_hd__buf_1
Xfanout1774 net1775 VGND VGND VPWR VPWR net1774 sky130_fd_sc_hd__clkbuf_1
Xfanout2497 net2499 VGND VGND VPWR VPWR net2497 sky130_fd_sc_hd__clkbuf_2
Xfanout1763 net1764 VGND VGND VPWR VPWR net1763 sky130_fd_sc_hd__clkbuf_2
Xfanout1785 net1787 VGND VGND VPWR VPWR net1785 sky130_fd_sc_hd__clkbuf_2
XFILLER_92_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1796 net1797 VGND VGND VPWR VPWR net1796 sky130_fd_sc_hd__clkbuf_2
X_13998_ net2836 VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__inv_2
XFILLER_18_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12949_ net2692 net2734 net2743 net757 VGND VGND VPWR VPWR _05993_ sky130_fd_sc_hd__a22o_1
XFILLER_92_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08140_ _01222_ _01224_ net1587 net2346 VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__and4_2
XTAP_TAPCELL_ROW_60_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08071_ net700 net698 _01134_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__a21o_1
XFILLER_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08973_ _01860_ _01863_ _02054_ net590 VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__nand4_1
X_07924_ _00835_ _00847_ _00845_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_71_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07855_ net614 _00940_ _00904_ VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__o21ai_2
XFILLER_28_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07786_ _00870_ net2385 net1333 _00869_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__nand4_2
XFILLER_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09525_ net3108 _02581_ _02582_ net463 _02609_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__a32oi_2
XFILLER_43_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09456_ _02539_ _02540_ _02536_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__a21o_1
X_08407_ _01377_ _01378_ _01379_ net592 net594 VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__a32o_2
XFILLER_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09387_ _02470_ _02472_ _02471_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__o21ai_1
XFILLER_138_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08338_ net1498 net2499 VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__nand2_1
XFILLER_138_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08269_ _01350_ _01353_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__nand2_1
XFILLER_125_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11280_ _04358_ _04362_ _04363_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__nand3_4
X_10300_ net886 _03384_ _03382_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__a21o_1
XFILLER_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10231_ net656 _03312_ net711 VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__a21o_1
XFILLER_106_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10162_ _03241_ _03242_ _03243_ _03245_ _03246_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__a32oi_2
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1004 _00524_ VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__clkbuf_4
XFILLER_126_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1037 net1038 VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1026 net1031 VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__buf_4
X_10093_ net1543 net2552 net2584 net1516 VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__a22oi_4
Xfanout1015 net1017 VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__clkbuf_2
Xfanout1059 net1060 VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__buf_1
X_13921_ _06863_ _06865_ VGND VGND VPWR VPWR _06866_ sky130_fd_sc_hd__nand2_1
Xfanout1048 net1050 VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_89_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13852_ _05309_ _06789_ _06794_ _06814_ _06812_ VGND VGND VPWR VPWR _06815_ sky130_fd_sc_hd__a2111oi_4
XFILLER_19_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12803_ net1076 net745 net2698 net2715 VGND VGND VPWR VPWR _05865_ sky130_fd_sc_hd__a211o_1
X_13783_ net1092 net1087 VGND VGND VPWR VPWR adder_inst.exp_larger\[7\] sky130_fd_sc_hd__nand2_1
XFILLER_16_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12734_ net2708 net1293 net2700 VGND VGND VPWR VPWR _05796_ sky130_fd_sc_hd__a21oi_1
X_10995_ _04075_ _04079_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12665_ _05742_ _05743_ VGND VGND VPWR VPWR _05744_ sky130_fd_sc_hd__nor2_1
X_12596_ _05677_ _05678_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[2\] sky130_fd_sc_hd__and2_4
X_14404_ clknet_leaf_11_clk net3386 _00226_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_11616_ net1195 net1112 _04270_ _04401_ _04400_ VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__o221ai_1
XTAP_TAPCELL_ROW_133_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11547_ _04627_ _04628_ _04610_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__nand3_4
X_14335_ clknet_leaf_14_clk net41 _00157_ VGND VGND VPWR VPWR adder_inst.i_b\[17\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold509 multiplier_inst.man_final_r\[9\] VGND VGND VPWR VPWR net3427 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_51_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14266_ net2912 VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__inv_2
X_11478_ _04560_ _04561_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__nand2_1
X_14197_ net2888 VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__inv_2
X_13217_ net790 _06193_ _06134_ net303 VGND VGND VPWR VPWR _06246_ sky130_fd_sc_hd__or4_1
X_10429_ _03504_ net883 net801 VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__and3_1
X_13148_ net312 net359 _06177_ VGND VGND VPWR VPWR _06178_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_111_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2250 net2251 VGND VGND VPWR VPWR net2250 sky130_fd_sc_hd__clkbuf_2
Xfanout2261 net2262 VGND VGND VPWR VPWR net2261 sky130_fd_sc_hd__clkbuf_2
Xfanout2283 net2284 VGND VGND VPWR VPWR net2283 sky130_fd_sc_hd__clkbuf_1
Xfanout1560 net1561 VGND VGND VPWR VPWR net1560 sky130_fd_sc_hd__clkbuf_1
Xfanout2272 net2273 VGND VGND VPWR VPWR net2272 sky130_fd_sc_hd__buf_1
X_13079_ _05680_ _05687_ net706 net543 net777 VGND VGND VPWR VPWR _06109_ sky130_fd_sc_hd__a32o_2
Xfanout2294 net2301 VGND VGND VPWR VPWR net2294 sky130_fd_sc_hd__clkbuf_2
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1593 net1599 VGND VGND VPWR VPWR net1593 sky130_fd_sc_hd__clkbuf_2
Xfanout1582 net1583 VGND VGND VPWR VPWR net1582 sky130_fd_sc_hd__dlymetal6s2s_1
X_07640_ _00611_ _00613_ _00624_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__o21ai_1
X_07571_ _00641_ _00654_ _00656_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__and3b_2
XFILLER_81_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09310_ _01972_ _01987_ _01983_ _01979_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09241_ net3003 _02004_ _02326_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__a21boi_2
XFILLER_119_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09172_ net1265 net1118 _01455_ _01458_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__o211ai_1
X_08123_ net2263 net1710 VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__nand2_1
X_08054_ net2124 net1835 VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08956_ net2186 net2216 net1625 net1659 VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__nand4_2
X_07907_ net1528 net2276 VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__nand2_1
X_08887_ _01834_ _01838_ _01837_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__o21ai_1
XFILLER_57_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07838_ _00744_ net598 _00909_ _00922_ VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__o211ai_2
XFILLER_57_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07769_ _00719_ _00722_ _00721_ _00716_ net704 VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__o2111ai_1
X_09508_ net992 net945 net2260 net1761 _02136_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_84_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10780_ _03604_ _03606_ _03655_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__a21o_1
XFILLER_25_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09439_ _02520_ _02521_ _02458_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__a21o_1
XFILLER_9_807 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12450_ _05535_ _04809_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__nand2_1
X_11401_ _04085_ _04088_ net1208 net1114 VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_115_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12381_ _05464_ _05465_ _05466_ VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__and3_1
XANTENNA_80 net2951 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14120_ net2853 VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__inv_2
XANTENNA_91 net916 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11332_ net1646 net2668 VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__and2_1
XFILLER_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14051_ net2878 VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__inv_2
X_11263_ net2393 net1983 VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__nand2_1
X_13002_ net2686 net1292 net750 net707 net2016 VGND VGND VPWR VPWR _06037_ sky130_fd_sc_hd__a311oi_1
X_11194_ _04268_ net638 _04271_ _04275_ VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__o2bb2ai_1
X_10214_ _03081_ _03297_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__nand2_1
XFILLER_133_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10145_ _02965_ _03155_ _03215_ _03229_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__nand4_2
XFILLER_102_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10076_ _02938_ _03159_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__and2b_1
X_13904_ net125 _05605_ _06853_ VGND VGND VPWR VPWR _06854_ sky130_fd_sc_hd__o21ai_1
XFILLER_75_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13835_ _04987_ _05150_ _06797_ VGND VGND VPWR VPWR _06798_ sky130_fd_sc_hd__a21oi_1
XFILLER_46_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13766_ _06257_ _06770_ VGND VGND VPWR VPWR _06772_ sky130_fd_sc_hd__nand2_2
X_10978_ _04062_ _04059_ _04061_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__o21ai_2
X_12717_ _05780_ _05781_ VGND VGND VPWR VPWR multiplier_inst.overflow_calc sky130_fd_sc_hd__nand2_1
X_13697_ net136 _06707_ net852 _06708_ VGND VGND VPWR VPWR _06712_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_26_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12648_ _05727_ VGND VGND VPWR VPWR _05728_ sky130_fd_sc_hd__inv_2
XFILLER_30_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12579_ net2926 net322 net787 _05662_ VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__a211o_1
XFILLER_116_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14318_ clknet_leaf_18_clk net33 _00140_ VGND VGND VPWR VPWR adder_inst.i_b\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_14249_ net2859 VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__inv_2
XFILLER_125_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout819 _01978_ VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__clkbuf_2
X_08810_ _01874_ _01887_ _01678_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__o21ai_1
Xfanout808 _03031_ VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__buf_6
XFILLER_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09790_ net1207 net1198 _02166_ _02640_ _02639_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__o221ai_4
Xfanout2080 net2081 VGND VGND VPWR VPWR net2080 sky130_fd_sc_hd__buf_1
X_08741_ _01607_ _01610_ _01816_ _01821_ VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__o22ai_1
Xfanout2091 net2094 VGND VGND VPWR VPWR net2091 sky130_fd_sc_hd__clkbuf_2
X_08672_ net1416 net2440 VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__nand2_1
Xfanout1390 net1404 VGND VGND VPWR VPWR net1390 sky130_fd_sc_hd__buf_2
X_07623_ _00620_ _00621_ _00622_ VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__nand3_1
XFILLER_81_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_18_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
X_07554_ net1337 net2338 _00637_ _00638_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__a22o_1
XFILLER_53_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07485_ _00487_ _00501_ net616 net478 VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_66_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09224_ net183 _02309_ VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__nand2_1
Xrebuffer403 adder_inst.sum_raw_r\[19\] VGND VGND VPWR VPWR net3321 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_22_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09155_ net1237 net1142 _02234_ _02238_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__o31a_1
X_08106_ _01175_ _01176_ net611 _01188_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__nand4_1
X_09086_ net1674 net2348 VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__nand2_1
X_08037_ _01107_ _01093_ _01120_ _01121_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__nand4_2
XFILLER_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09988_ _03071_ _03072_ _03073_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__nand3_2
X_08939_ net2153 net1683 VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__nand2_1
XFILLER_29_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11950_ net621 net620 net863 VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__a21oi_2
X_10901_ _03925_ net644 net797 VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__and3_1
X_11881_ _04868_ _04849_ _04957_ _04962_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__o211ai_4
X_13620_ _06614_ _06633_ _06643_ VGND VGND VPWR VPWR _06644_ sky130_fd_sc_hd__o21bai_4
X_10832_ net2323 net2352 net1867 net1899 VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__nand4_2
XFILLER_44_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13551_ _06441_ _06442_ VGND VGND VPWR VPWR _06580_ sky130_fd_sc_hd__nor2_1
XFILLER_53_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10763_ _03633_ _03635_ _03622_ _03631_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__o211ai_1
XFILLER_25_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12502_ _05324_ net164 _05438_ VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__a21bo_2
XFILLER_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13482_ net290 _06480_ net233 _06510_ VGND VGND VPWR VPWR _06511_ sky130_fd_sc_hd__o211a_1
XFILLER_9_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10694_ net1206 net1149 net971 net917 _03561_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__o221ai_4
X_12433_ _05518_ _05514_ _07018_ VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__o21ai_1
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12364_ net3147 _07100_ _05449_ _00461_ VGND VGND VPWR VPWR _05450_ sky130_fd_sc_hd__nor4b_1
XTAP_TAPCELL_ROW_97_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14103_ net2810 VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__inv_2
X_11315_ net1825 net2569 VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__nand2_2
X_12295_ _05375_ _05376_ _05377_ VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__nand3_1
X_14034_ net2842 VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__inv_2
XFILLER_79_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11246_ _04294_ _04303_ _04331_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__o21a_1
XFILLER_121_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11177_ _04258_ _04260_ _04253_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_128_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10128_ _03212_ _03158_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_50_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10059_ net395 net394 _02903_ _02905_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_141_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13818_ net3456 net831 net722 VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_106_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13749_ _06757_ _06756_ VGND VGND VPWR VPWR _06758_ sky130_fd_sc_hd__nor2_4
XFILLER_90_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07270_ net1396 net2135 net2165 net1369 VGND VGND VPWR VPWR _07041_ sky130_fd_sc_hd__a22o_1
XFILLER_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_7_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
X_09911_ net457 _02982_ net433 net669 _02735_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__o2111ai_4
XFILLER_125_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout605 net3176 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout616 _00502_ VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__buf_1
X_09842_ net1016 net898 net1496 net2556 _02698_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__o2111ai_4
Xfanout638 _04269_ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__clkbuf_2
Xfanout649 _03743_ VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__buf_1
Xfanout627 _05001_ VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__buf_6
XFILLER_98_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09773_ _02845_ net666 net665 VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__and3_1
X_08724_ _01786_ _01804_ _01599_ _01783_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_37_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08655_ _01732_ _01736_ _01739_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_68_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07606_ _00557_ _00565_ _00678_ _00690_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__nand4_2
X_08586_ _01258_ _01669_ _01667_ _01668_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__o211ai_4
XFILLER_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07537_ _00619_ net2224 net1512 _00618_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_81_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07468_ net1419 _00550_ net2242 _00552_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__a31o_1
XFILLER_10_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07399_ _00482_ _00483_ _00471_ VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__o21ai_4
Xrebuffer200 _01845_ VGND VGND VPWR VPWR net3118 sky130_fd_sc_hd__dlygate4sd1_1
X_09207_ _02266_ _02271_ _02273_ _02291_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__o211ai_2
Xrebuffer222 _03856_ VGND VGND VPWR VPWR net3140 sky130_fd_sc_hd__buf_2
Xrebuffer211 net3160 VGND VGND VPWR VPWR net3129 sky130_fd_sc_hd__buf_6
Xrebuffer255 _06258_ VGND VGND VPWR VPWR net3173 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer233 _05216_ VGND VGND VPWR VPWR net3151 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer244 _05196_ VGND VGND VPWR VPWR net3162 sky130_fd_sc_hd__dlymetal6s2s_1
X_09138_ _02219_ _02220_ _02221_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__a21oi_2
Xrebuffer288 adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR net3206 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer266 net3185 VGND VGND VPWR VPWR net3184 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer277 net3304 VGND VGND VPWR VPWR net3195 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_123_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09069_ _02148_ _02149_ _02138_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__a21o_1
X_11100_ net421 net419 _04177_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__a21oi_2
XFILLER_2_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2827 net2834 VGND VGND VPWR VPWR net2827 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_9_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2816 net2817 VGND VGND VPWR VPWR net2816 sky130_fd_sc_hd__clkbuf_2
Xfanout2805 net2813 VGND VGND VPWR VPWR net2805 sky130_fd_sc_hd__buf_1
X_12080_ net1938 net2600 _05080_ _05082_ VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_92_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2838 net2839 VGND VGND VPWR VPWR net2838 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2849 net2918 VGND VGND VPWR VPWR net2849 sky130_fd_sc_hd__dlymetal6s2s_1
X_11031_ _04109_ _04111_ _04113_ _04098_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__a31o_1
XFILLER_134_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12982_ net2704 net1076 net1070 _06021_ VGND VGND VPWR VPWR _06022_ sky130_fd_sc_hd__o211ai_1
XFILLER_94_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11933_ _04922_ _04924_ _04910_ _04912_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_123_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11864_ _04937_ _04941_ _04948_ net628 VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__o211a_1
X_13603_ _06548_ _06550_ _06552_ _06629_ VGND VGND VPWR VPWR _06630_ sky130_fd_sc_hd__o31a_1
X_10815_ _03771_ _03774_ net1670 net2538 VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__nand4b_1
X_14583_ clknet_leaf_5_clk net3480 _00405_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
X_11795_ _04879_ _04880_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__nand2_1
X_13534_ _06521_ _06518_ _06559_ VGND VGND VPWR VPWR _06563_ sky130_fd_sc_hd__o21ai_4
X_10746_ net1580 net2618 VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__nand2_1
XFILLER_41_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13465_ net531 net179 _06488_ _06492_ VGND VGND VPWR VPWR _06494_ sky130_fd_sc_hd__o211ai_2
X_10677_ net573 net575 _03548_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__a21o_1
XFILLER_127_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12416_ _05496_ _05497_ _05498_ _05493_ VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__o211ai_1
XFILLER_126_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13396_ net443 _06419_ net3196 VGND VGND VPWR VPWR _06425_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12347_ _05429_ _05430_ _05428_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__a21o_1
XFILLER_141_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12278_ _05357_ _05359_ _05360_ VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__nand3b_1
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14017_ net2814 VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__inv_2
X_11229_ _04314_ net637 _04298_ _04306_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_68_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_108_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08440_ _01523_ _01525_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08371_ net1435 net1468 net2497 net2528 VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__and4_1
X_07322_ net1267 net1255 _07034_ _07036_ VGND VGND VPWR VPWR _07093_ sky130_fd_sc_hd__o22ai_2
X_07253_ net2054 net1565 VGND VGND VPWR VPWR _07024_ sky130_fd_sc_hd__nand2_1
XFILLER_118_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07184_ net1397 net2111 net2136 net1369 VGND VGND VPWR VPWR _06955_ sky130_fd_sc_hd__a22o_1
XFILLER_129_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout402 _01616_ VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__buf_6
Xfanout413 net415 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_6_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout435 _02424_ VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__buf_2
XFILLER_99_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09825_ net399 net397 _02654_ _02656_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout457 _02975_ VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_2
Xfanout424 _04002_ VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__buf_6
Xfanout446 _05025_ VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout468 _01899_ VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__buf_1
XFILLER_86_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout479 net483 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09756_ _02838_ _02839_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__nand2_1
X_08707_ net1560 net2305 VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__nand2_1
XFILLER_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09687_ _02245_ net817 _02767_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__a21oi_1
XFILLER_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08638_ net2930 _01720_ _01722_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__nand3_4
XFILLER_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08569_ _01647_ _01652_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__nand2_1
XFILLER_42_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11580_ net2451 net1958 net1984 net2423 VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__a22oi_4
X_10600_ _03469_ net190 _03454_ _03456_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__o2bb2ai_4
X_10531_ _03616_ _03613_ net879 VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__o21ai_4
X_13250_ _06277_ net187 net188 VGND VGND VPWR VPWR _06279_ sky130_fd_sc_hd__and3_1
XFILLER_108_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12201_ net1965 net2679 _05262_ _05286_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__and4_1
X_10462_ _03544_ _03546_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__nand2_1
XFILLER_108_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10393_ _03024_ _03476_ _03478_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__o21a_1
X_13181_ net340 net358 _06208_ net362 VGND VGND VPWR VPWR _06211_ sky130_fd_sc_hd__nand4_1
XFILLER_89_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12132_ net1990 net2601 net2630 net1962 VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__a22oi_1
Xfanout2602 net2603 VGND VGND VPWR VPWR net2602 sky130_fd_sc_hd__clkbuf_1
XFILLER_2_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2635 adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR net2635 sky130_fd_sc_hd__buf_4
X_12063_ net247 _05068_ _05070_ _05071_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__nand4_1
Xfanout2613 net2617 VGND VGND VPWR VPWR net2613 sky130_fd_sc_hd__clkbuf_2
Xfanout2624 net2625 VGND VGND VPWR VPWR net2624 sky130_fd_sc_hd__clkbuf_1
Xfanout2679 net2680 VGND VGND VPWR VPWR net2679 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2657 net2658 VGND VGND VPWR VPWR net2657 sky130_fd_sc_hd__clkbuf_2
Xfanout1934 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net1934 sky130_fd_sc_hd__buf_4
XFILLER_2_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11014_ net1581 net2641 VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__nand2_1
Xfanout2646 net2648 VGND VGND VPWR VPWR net2646 sky130_fd_sc_hd__clkbuf_2
Xfanout2668 net2670 VGND VGND VPWR VPWR net2668 sky130_fd_sc_hd__clkbuf_2
Xfanout1901 net1902 VGND VGND VPWR VPWR net1901 sky130_fd_sc_hd__buf_2
Xfanout1912 adder_inst.man_b_r\[3\] VGND VGND VPWR VPWR net1912 sky130_fd_sc_hd__clkbuf_2
Xfanout1923 adder_inst.man_b_r\[3\] VGND VGND VPWR VPWR net1923 sky130_fd_sc_hd__buf_4
XFILLER_77_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1956 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net1956 sky130_fd_sc_hd__buf_6
Xfanout1945 net1946 VGND VGND VPWR VPWR net1945 sky130_fd_sc_hd__buf_4
Xfanout1967 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net1967 sky130_fd_sc_hd__buf_6
Xfanout991 _00721_ VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__buf_2
XFILLER_92_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout980 net981 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__clkbuf_2
XFILLER_64_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1989 net1991 VGND VGND VPWR VPWR net1989 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1978 net1982 VGND VGND VPWR VPWR net1978 sky130_fd_sc_hd__clkbuf_2
X_12965_ net2732 net1061 _06002_ _06006_ net843 VGND VGND VPWR VPWR _06007_ sky130_fd_sc_hd__o221a_1
XFILLER_64_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11916_ _04997_ _04998_ _04995_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__nand3_4
XFILLER_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12896_ net743 net2774 net2776 net749 VGND VGND VPWR VPWR _05946_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_103_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11847_ _04929_ _04930_ _04928_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__a21o_1
X_14566_ clknet_leaf_20_clk net3484 _00388_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
X_11778_ _04861_ net629 _04857_ VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__and3_1
X_13517_ net253 _06541_ _06542_ _06544_ VGND VGND VPWR VPWR _06546_ sky130_fd_sc_hd__a31oi_4
XFILLER_9_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10729_ net387 net386 _03594_ _03595_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_136_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14497_ clknet_leaf_8_clk _00069_ _00319_ VGND VGND VPWR VPWR multiplier_inst.is_inf_r
+ sky130_fd_sc_hd__dfrtp_1
Xclkload12 clknet_leaf_2_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__inv_12
X_13448_ _06475_ _06476_ VGND VGND VPWR VPWR _06477_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_11_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13379_ net491 _06406_ net255 _06405_ VGND VGND VPWR VPWR _06408_ sky130_fd_sc_hd__nand4_4
XFILLER_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07940_ net1417 net2336 _00860_ _00862_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__a22o_1
XFILLER_68_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07871_ net2123 net1684 VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__nand2_1
XFILLER_95_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09610_ _02685_ _02689_ _02691_ _02692_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__o211ai_2
XFILLER_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09541_ _02624_ _02187_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__nand2_2
XFILLER_55_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09472_ _02096_ net1125 _02100_ _02099_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__o211ai_4
X_08423_ net1379 net2530 net2561 net1351 VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_19_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08354_ net1021 net913 net822 VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__o21ai_1
XFILLER_137_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07305_ _07028_ _07068_ _07073_ _07074_ VGND VGND VPWR VPWR _07076_ sky130_fd_sc_hd__nand4_2
X_08285_ net1204 net1201 net1003 _01362_ _01365_ VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__o311a_1
Xclkload6 clknet_leaf_16_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_16
XFILLER_137_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07236_ _07005_ _07006_ VGND VGND VPWR VPWR _07007_ sky130_fd_sc_hd__nor2_1
XFILLER_118_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07167_ _06936_ _06937_ net1341 net2111 VGND VGND VPWR VPWR _06938_ sky130_fd_sc_hd__and4bb_1
XFILLER_3_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1219 net1221 VGND VGND VPWR VPWR net1219 sky130_fd_sc_hd__buf_1
Xfanout210 _01729_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_6
Xfanout221 _06154_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_8
Xfanout232 net234 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_2
Xfanout1208 net1210 VGND VGND VPWR VPWR net1208 sky130_fd_sc_hd__buf_2
Xfanout243 _05890_ VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_4
Xfanout265 net268 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_8
Xfanout254 net259 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout287 net288 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_6
Xfanout298 net1725 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__clkbuf_2
X_09808_ _02650_ _02649_ net673 net672 VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__o211ai_2
XFILLER_74_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09739_ net1226 net1151 _02820_ net897 VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__o211ai_1
XFILLER_28_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_120_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12750_ _05811_ net1288 VGND VGND VPWR VPWR _05812_ sky130_fd_sc_hd__and2b_1
XFILLER_15_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12681_ adder_inst.i_b\[9\] adder_inst.i_b\[8\] adder_inst.i_b\[11\] adder_inst.i_b\[10\]
+ VGND VGND VPWR VPWR _05756_ sky130_fd_sc_hd__or4_1
X_11701_ _04198_ net212 _04200_ VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__nand3_1
X_14420_ clknet_leaf_17_clk net3338 _00242_ VGND VGND VPWR VPWR adder_inst.man_b_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_11632_ net630 _04708_ _04714_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__nand3_1
X_14351_ clknet_leaf_2_clk adder_inst.sum_raw\[0\] _00173_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_42_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13302_ net260 _06186_ VGND VGND VPWR VPWR _06331_ sky130_fd_sc_hd__nand2_2
X_11563_ net323 _04136_ _04161_ _04162_ VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_7_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_118_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14282_ net2855 VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__inv_2
X_11494_ _04485_ _04491_ net556 net555 VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__a2bb2oi_4
X_10514_ net3023 net348 _03363_ _03365_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__o2bb2ai_2
X_13233_ _06259_ _06260_ VGND VGND VPWR VPWR _06262_ sky130_fd_sc_hd__nand2_1
X_10445_ net2350 net2388 net1784 net1815 VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__nand4_1
XFILLER_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13164_ net1349 net487 _06192_ VGND VGND VPWR VPWR _06194_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_131_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2410 net2411 VGND VGND VPWR VPWR net2410 sky130_fd_sc_hd__dlymetal6s2s_1
X_10376_ _03460_ _03461_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__nor2_2
X_12115_ _05195_ net3162 _05190_ _05198_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__o22a_1
X_13095_ _06123_ _05647_ VGND VGND VPWR VPWR _06125_ sky130_fd_sc_hd__nand2_1
Xfanout2443 net2444 VGND VGND VPWR VPWR net2443 sky130_fd_sc_hd__buf_1
Xfanout2432 net2434 VGND VGND VPWR VPWR net2432 sky130_fd_sc_hd__clkbuf_2
Xfanout2421 net2425 VGND VGND VPWR VPWR net2421 sky130_fd_sc_hd__clkbuf_1
Xfanout1720 net1721 VGND VGND VPWR VPWR net1720 sky130_fd_sc_hd__clkbuf_1
Xfanout2487 net2488 VGND VGND VPWR VPWR net2487 sky130_fd_sc_hd__buf_6
Xfanout2454 net2455 VGND VGND VPWR VPWR net2454 sky130_fd_sc_hd__clkbuf_2
Xfanout1731 net1732 VGND VGND VPWR VPWR net1731 sky130_fd_sc_hd__buf_2
Xfanout2465 net2469 VGND VGND VPWR VPWR net2465 sky130_fd_sc_hd__clkbuf_2
Xfanout1742 net1743 VGND VGND VPWR VPWR net1742 sky130_fd_sc_hd__clkbuf_2
X_12046_ _05051_ _05059_ _05056_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__a21o_1
Xfanout2476 net2478 VGND VGND VPWR VPWR net2476 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1753 net1754 VGND VGND VPWR VPWR net1753 sky130_fd_sc_hd__clkbuf_2
Xfanout1775 net1776 VGND VGND VPWR VPWR net1775 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2498 net2499 VGND VGND VPWR VPWR net2498 sky130_fd_sc_hd__buf_1
Xfanout1764 net1770 VGND VGND VPWR VPWR net1764 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1797 net1798 VGND VGND VPWR VPWR net1797 sky130_fd_sc_hd__buf_4
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1786 net1787 VGND VGND VPWR VPWR net1786 sky130_fd_sc_hd__buf_1
X_13997_ net2835 VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__inv_2
XFILLER_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12948_ _05990_ _05991_ net843 VGND VGND VPWR VPWR _05992_ sky130_fd_sc_hd__and3_1
XFILLER_92_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12879_ net2689 net2766 net754 net2767 VGND VGND VPWR VPWR _05932_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_16_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14549_ clknet_leaf_4_clk _00079_ _00371_ VGND VGND VPWR VPWR mul_res\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_119_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08070_ net700 net698 net714 VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__a21oi_1
XFILLER_134_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08972_ _01860_ _01863_ _02054_ net590 VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__a22o_1
X_07923_ _00839_ _00844_ _00848_ _00836_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__o211ai_2
XFILLER_110_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07854_ _00770_ _00891_ _00893_ _00882_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__a31o_1
XFILLER_84_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07785_ net1333 net2385 _00869_ _00870_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__a22o_1
X_09524_ net3088 _02579_ net3090 _02606_ _02607_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__a32oi_4
XFILLER_45_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09455_ _02539_ _02540_ _02536_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__a21oi_4
XFILLER_52_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08406_ _01377_ _01378_ _01379_ net592 net594 VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__a32oi_4
XFILLER_24_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09386_ net1052 net915 _02468_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__o21ai_1
XFILLER_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08337_ _01410_ _01420_ VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__nand2_2
XFILLER_138_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08268_ _01352_ _01349_ _01351_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07219_ _06983_ _06985_ _06988_ VGND VGND VPWR VPWR _06990_ sky130_fd_sc_hd__a21oi_2
XFILLER_106_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08199_ _01078_ _01283_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__nand2_4
X_10230_ net657 _03312_ net711 VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__a21oi_1
XFILLER_133_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10161_ _03246_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__inv_2
XFILLER_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1038 _00447_ VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__buf_1
Xfanout1027 net1028 VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__buf_2
Xfanout1005 net1007 VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__buf_6
X_10092_ net1517 net2584 VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__nand2_2
Xfanout1016 net1017 VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__buf_4
X_13920_ net126 _05623_ _06864_ VGND VGND VPWR VPWR _06865_ sky130_fd_sc_hd__o21ai_1
XFILLER_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1049 _06959_ VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__buf_6
XFILLER_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13851_ net167 net2934 _06813_ VGND VGND VPWR VPWR _06814_ sky130_fd_sc_hd__a21oi_1
X_12802_ _05862_ _05857_ _05863_ net709 VGND VGND VPWR VPWR _05864_ sky130_fd_sc_hd__a211o_1
X_13782_ net2002 net1276 net509 VGND VGND VPWR VPWR adder_inst.exp_larger\[6\] sky130_fd_sc_hd__mux2_1
X_10994_ _04077_ _04074_ _04076_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__nand3_4
X_12733_ net1302 net849 net2708 VGND VGND VPWR VPWR _05795_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12664_ net120 _05726_ _05740_ VGND VGND VPWR VPWR _05743_ sky130_fd_sc_hd__and3_1
X_14403_ clknet_leaf_11_clk net3382 _00225_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_42_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12595_ _05673_ _05674_ _05639_ VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__o21ai_1
X_11615_ _04695_ _04696_ _04697_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_133_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11546_ _04598_ _04604_ _04629_ _04630_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__o211ai_2
X_14334_ clknet_leaf_14_clk net40 _00156_ VGND VGND VPWR VPWR adder_inst.i_b\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14265_ net2908 VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__inv_2
XFILLER_7_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13216_ net308 net415 _06194_ net785 VGND VGND VPWR VPWR _06245_ sky130_fd_sc_hd__and4_1
X_11477_ _04560_ _04561_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__or2_1
X_14196_ net2888 VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__inv_2
X_10428_ net883 net801 _03504_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__a21oi_1
X_13147_ net1457 net768 net535 _06175_ VGND VGND VPWR VPWR _06177_ sky130_fd_sc_hd__a31o_1
XFILLER_3_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10359_ _03147_ net324 VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__nand2_1
XFILLER_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2240 net2241 VGND VGND VPWR VPWR net2240 sky130_fd_sc_hd__buf_1
Xfanout2251 net2252 VGND VGND VPWR VPWR net2251 sky130_fd_sc_hd__buf_4
X_13078_ net706 _06060_ net543 net776 VGND VGND VPWR VPWR _06108_ sky130_fd_sc_hd__a22oi_2
Xfanout2262 net2265 VGND VGND VPWR VPWR net2262 sky130_fd_sc_hd__clkbuf_2
Xfanout2284 net2285 VGND VGND VPWR VPWR net2284 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_111_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2273 net2274 VGND VGND VPWR VPWR net2273 sky130_fd_sc_hd__clkbuf_1
Xfanout1550 net1551 VGND VGND VPWR VPWR net1550 sky130_fd_sc_hd__buf_1
X_12029_ _05114_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__inv_2
Xfanout2295 net2296 VGND VGND VPWR VPWR net2295 sky130_fd_sc_hd__clkbuf_2
Xfanout1561 net1562 VGND VGND VPWR VPWR net1561 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1583 net1584 VGND VGND VPWR VPWR net1583 sky130_fd_sc_hd__clkbuf_1
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1572 net1574 VGND VGND VPWR VPWR net1572 sky130_fd_sc_hd__buf_1
Xfanout1594 net1596 VGND VGND VPWR VPWR net1594 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07570_ _00651_ _00652_ _00653_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__nand3_1
XFILLER_18_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09240_ _01954_ _01965_ _01966_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__a21boi_1
X_09171_ _01455_ _01458_ _01459_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__a21o_1
X_08122_ _01200_ _01204_ _01196_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__a21o_1
X_08053_ net2172 net1773 VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08955_ net2216 net1625 net1662 net2186 VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__a22o_1
XFILLER_130_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07906_ _00990_ _00991_ _00986_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__nand3_2
X_08886_ net1503 _01794_ net2362 _01796_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__a31o_1
XFILLER_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07837_ _00745_ _00750_ _00910_ _00921_ _00743_ VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__o2111ai_4
XFILLER_56_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07768_ net705 _00717_ _00723_ VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__a21bo_1
XFILLER_84_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09507_ net1222 net1187 _02590_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__o21ai_2
X_07699_ _00783_ _00759_ _00779_ _00784_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_84_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09438_ _02458_ _02520_ _02521_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__nand3_1
X_09369_ net1173 net1168 net1051 net815 _02453_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__o311a_1
XFILLER_9_819 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12380_ _07040_ _07045_ _05445_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__nand3_2
X_11400_ _04482_ _04483_ _04484_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__nand3_1
XFILLER_122_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_81 net3176 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_92 net983 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_70 net2523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11331_ _04389_ _04392_ _04393_ _04402_ _04405_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__a32oi_2
XFILLER_125_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_115_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14050_ net2879 VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__inv_2
X_11262_ _04343_ net451 _04282_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__a21o_2
XFILLER_106_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13001_ net2685 net1315 _05787_ net1292 VGND VGND VPWR VPWR _06036_ sky130_fd_sc_hd__a31o_1
X_11193_ _04268_ net638 _04277_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__and3_1
X_10213_ net2311 net2342 net1785 net1816 VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__nand4_1
XFILLER_133_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10144_ net431 _03215_ _03228_ _02966_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10075_ net900 _02932_ net1494 net2583 _02937_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__o2111ai_2
X_13903_ _05523_ _05525_ _05603_ VGND VGND VPWR VPWR _06853_ sky130_fd_sc_hd__a21o_1
XFILLER_47_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13834_ net196 net200 _05153_ _04988_ VGND VGND VPWR VPWR _06797_ sky130_fd_sc_hd__o211a_1
X_13765_ _06257_ _06771_ VGND VGND VPWR VPWR adder_inst.sum_raw\[22\] sky130_fd_sc_hd__xor2_1
XFILLER_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10977_ _03931_ _04058_ _04062_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__o21ai_2
X_13696_ _06696_ _06709_ _06710_ VGND VGND VPWR VPWR _06711_ sky130_fd_sc_hd__a21bo_1
X_12716_ _05726_ _05740_ VGND VGND VPWR VPWR _05781_ sky130_fd_sc_hd__nand2_1
XFILLER_16_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12647_ net120 _05726_ VGND VGND VPWR VPWR _05727_ sky130_fd_sc_hd__nand2_1
XFILLER_30_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12578_ _06930_ _05651_ _06931_ VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__or3b_2
X_14317_ clknet_leaf_7_clk net25 _00139_ VGND VGND VPWR VPWR adder_inst.i_a\[31\]
+ sky130_fd_sc_hd__dfrtp_1
X_11529_ _04569_ _04576_ _04611_ net639 net556 VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__o221a_1
XFILLER_109_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14248_ net2872 VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__inv_2
X_14179_ net2853 VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_55_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout809 _02878_ VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__buf_6
XFILLER_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2070 net2072 VGND VGND VPWR VPWR net2070 sky130_fd_sc_hd__clkbuf_2
Xfanout2081 net2082 VGND VGND VPWR VPWR net2081 sky130_fd_sc_hd__buf_1
X_08740_ _01822_ _01820_ _01823_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__a21o_4
Xfanout2092 net2094 VGND VGND VPWR VPWR net2092 sky130_fd_sc_hd__buf_2
Xfanout1391 net1393 VGND VGND VPWR VPWR net1391 sky130_fd_sc_hd__clkbuf_2
X_08671_ net1045 net922 _01562_ _01567_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__o22a_1
Xfanout1380 net1381 VGND VGND VPWR VPWR net1380 sky130_fd_sc_hd__buf_1
X_07622_ _00671_ _00707_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__nor2_1
XFILLER_93_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07553_ _00638_ net2338 net1337 _00637_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__nand4_1
X_07484_ _00521_ _00546_ _00547_ _00568_ VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__a2bb2o_2
XTAP_TAPCELL_ROW_66_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09223_ _02299_ _02302_ _02301_ _02308_ VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__a31o_1
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer404 adder_inst.exp_larger_r\[1\] VGND VGND VPWR VPWR net3322 sky130_fd_sc_hd__buf_2
X_09154_ _02235_ net2529 net1496 VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__and3_1
X_08105_ _01177_ net611 _01188_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__nand3_1
X_09085_ net2290 net1700 net2314 net1731 VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__nand4_2
X_08036_ _01120_ _01121_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__nand2_1
XFILLER_116_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09987_ _02842_ net1759 net2312 _02841_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__nand4_1
X_08938_ _01890_ _01873_ _01889_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__a21boi_2
X_08869_ _01758_ net908 _01760_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_86_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10900_ _03925_ net645 _03935_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__a21o_1
X_11880_ _04962_ _04957_ VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__nand2_1
X_10831_ net2326 net1911 VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__nand2_1
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13550_ _06449_ _06577_ VGND VGND VPWR VPWR _06579_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_43_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10762_ _03626_ _03629_ _03636_ _03622_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__a22o_1
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12501_ net143 net317 _05581_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__nand3_1
X_13481_ _06140_ net3294 _06509_ net290 VGND VGND VPWR VPWR _06510_ sky130_fd_sc_hd__o211ai_2
XFILLER_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12432_ _07064_ _05516_ VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_23_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10693_ _03561_ _03562_ _03563_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__a21o_1
XFILLER_138_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12363_ _07084_ _07085_ _07094_ _07096_ VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_97_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12294_ _05375_ _05378_ _05379_ VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__nand3b_4
X_14102_ net2810 VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__inv_2
X_11314_ _04397_ _04398_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__nand2_2
X_14033_ net2842 VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__inv_2
X_11245_ _04011_ _04013_ _04014_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11176_ _04255_ _04256_ _04253_ VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_128_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10127_ net431 _03157_ _03211_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__a21oi_2
XFILLER_94_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10058_ _02900_ _02902_ net395 net394 VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_141_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13817_ net3500 net831 net721 VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_106_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13748_ _06599_ _06601_ _06753_ VGND VGND VPWR VPWR _06757_ sky130_fd_sc_hd__a21boi_1
XFILLER_50_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13679_ net169 _06672_ _06695_ VGND VGND VPWR VPWR _06696_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_139_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09910_ net433 net457 VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__nand2_1
Xfanout606 _06069_ VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__buf_6
XFILLER_86_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout628 _04949_ VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__buf_1
X_09841_ _02925_ _02700_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__nand2_1
Xfanout617 _05101_ VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09772_ _02850_ _02851_ _02846_ _02844_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__a31o_1
X_08723_ net682 net681 _01787_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_1_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08654_ _01554_ _01737_ _01732_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_68_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07605_ _00678_ _00690_ _00689_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__a21o_1
X_08585_ _01241_ net609 _01255_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__a21oi_2
X_07536_ net1512 net2224 VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07467_ net1446 net1481 net2187 net2218 VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__nand4_1
X_09206_ _02272_ _02276_ _02290_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__nand3_1
XFILLER_50_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07398_ _00428_ _00465_ _00466_ _00469_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__o2bb2ai_2
Xrebuffer201 _02306_ VGND VGND VPWR VPWR net3119 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_20_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer223 _03800_ VGND VGND VPWR VPWR net3141 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer212 net3161 VGND VGND VPWR VPWR net3130 sky130_fd_sc_hd__clkbuf_1
Xrebuffer256 net3173 VGND VGND VPWR VPWR net3174 sky130_fd_sc_hd__buf_1
X_09137_ _02219_ _02220_ _02221_ VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__a21o_1
Xrebuffer245 _05110_ VGND VGND VPWR VPWR net3163 sky130_fd_sc_hd__buf_6
XFILLER_136_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer278 _06417_ VGND VGND VPWR VPWR net3196 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_79_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer289 adder_inst.exp_a_r\[0\] VGND VGND VPWR VPWR net3207 sky130_fd_sc_hd__dlymetal6s2s_1
X_09068_ net678 net677 _02138_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__a21oi_1
Xrebuffer267 net3303 VGND VGND VPWR VPWR net3185 sky130_fd_sc_hd__clkbuf_2
XFILLER_118_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08019_ net827 net1850 net2118 net966 VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__nand4_1
XFILLER_2_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2817 net2818 VGND VGND VPWR VPWR net2817 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2806 net2808 VGND VGND VPWR VPWR net2806 sky130_fd_sc_hd__clkbuf_2
Xfanout2828 net2829 VGND VGND VPWR VPWR net2828 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_92_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2839 net2845 VGND VGND VPWR VPWR net2839 sky130_fd_sc_hd__clkbuf_1
X_11030_ _04108_ _04110_ _04112_ _04099_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__o31a_1
XFILLER_134_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12981_ net1082 net2738 net2718 net2704 VGND VGND VPWR VPWR _06021_ sky130_fd_sc_hd__a211o_1
XFILLER_85_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11932_ net626 _05016_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_123_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11863_ _04945_ _04947_ _04943_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__nand3_1
X_13602_ _06549_ _06553_ _06240_ VGND VGND VPWR VPWR _06629_ sky130_fd_sc_hd__o21ai_2
X_10814_ net875 _03773_ _03775_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__o21ai_1
X_14582_ clknet_leaf_5_clk net3393 _00404_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
X_11794_ _04739_ _04878_ _04865_ net629 VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__o211ai_2
X_13533_ _06522_ _06533_ _06557_ VGND VGND VPWR VPWR _06562_ sky130_fd_sc_hd__or3_1
XFILLER_9_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10745_ net1609 net1643 net2565 net2593 VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__nand4_1
X_13464_ net512 net179 _06487_ _06491_ VGND VGND VPWR VPWR _06493_ sky130_fd_sc_hd__o211a_1
X_10676_ _03543_ _03545_ net575 net573 VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__o211ai_4
X_12415_ _05496_ _05497_ _05499_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__or3_1
X_13395_ net443 _06419_ net222 net193 _06416_ VGND VGND VPWR VPWR _06424_ sky130_fd_sc_hd__o221a_1
XFILLER_127_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12346_ _05431_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__inv_2
XFILLER_126_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12277_ _01014_ _01016_ _05359_ _05360_ VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_107_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14016_ net2814 VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__inv_2
X_11228_ _04311_ _04313_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__nand2_1
XFILLER_68_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11159_ net2448 net1886 net1914 net2420 VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__a22o_1
XFILLER_68_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08370_ net1436 net2497 VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__nand2_1
X_07321_ net1255 _07088_ _07091_ VGND VGND VPWR VPWR _07092_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_63_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07252_ _06949_ _06951_ _07022_ VGND VGND VPWR VPWR _07023_ sky130_fd_sc_hd__a21o_1
X_07183_ net1372 net1397 net2111 net2135 VGND VGND VPWR VPWR _06954_ sky130_fd_sc_hd__nand4_1
XFILLER_129_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout403 _01548_ VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__buf_4
Xfanout414 net415 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout436 _01452_ VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__buf_6
X_09824_ net399 net397 _02655_ _02657_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__nand4_1
Xfanout425 _03947_ VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_6
Xfanout447 _05025_ VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__buf_1
Xfanout469 _01713_ VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout458 _02837_ VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__buf_6
XFILLER_58_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09755_ net2259 net2288 net1787 net1819 VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__nand4_2
X_08706_ net1528 net2332 VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__nand2_1
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09686_ net1111 net1103 net1051 net817 _02767_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__o311a_1
XFILLER_104_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08637_ _01720_ _01722_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__nand2_1
XFILLER_15_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08568_ _01652_ _01646_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__nand2_1
XFILLER_120_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07519_ net2126 net1598 VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__nand2_1
XFILLER_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08499_ net1201 net1198 net1023 _01521_ _01524_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__o32a_1
X_10530_ net1573 net2591 VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__nand2_2
X_10461_ _03543_ _03545_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_94_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12200_ _05263_ _05285_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__xor2_1
XFILLER_136_675 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10392_ _02791_ _03477_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__nand2_1
X_13180_ net263 _06209_ VGND VGND VPWR VPWR _06210_ sky130_fd_sc_hd__nand2_1
XFILLER_123_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12131_ net246 net3158 _05208_ _05201_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__o2bb2ai_4
Xfanout2614 net2615 VGND VGND VPWR VPWR net2614 sky130_fd_sc_hd__clkbuf_2
Xfanout2603 net2604 VGND VGND VPWR VPWR net2603 sky130_fd_sc_hd__clkbuf_2
X_12062_ _04985_ _05147_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__nand2_1
Xfanout2625 net2634 VGND VGND VPWR VPWR net2625 sky130_fd_sc_hd__clkbuf_2
Xfanout2636 net2640 VGND VGND VPWR VPWR net2636 sky130_fd_sc_hd__clkbuf_2
Xhold490 adder_inst.i_a\[20\] VGND VGND VPWR VPWR net3408 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2658 net2659 VGND VGND VPWR VPWR net2658 sky130_fd_sc_hd__clkbuf_2
Xfanout2647 net2648 VGND VGND VPWR VPWR net2647 sky130_fd_sc_hd__buf_1
Xfanout2669 net2670 VGND VGND VPWR VPWR net2669 sky130_fd_sc_hd__buf_1
X_11013_ _04092_ _04096_ _04097_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__nand3_1
Xfanout1913 net1922 VGND VGND VPWR VPWR net1913 sky130_fd_sc_hd__clkbuf_2
Xfanout1902 net1912 VGND VGND VPWR VPWR net1902 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1946 net1952 VGND VGND VPWR VPWR net1946 sky130_fd_sc_hd__buf_4
Xfanout1935 net1936 VGND VGND VPWR VPWR net1935 sky130_fd_sc_hd__clkbuf_2
Xfanout1957 net1958 VGND VGND VPWR VPWR net1957 sky130_fd_sc_hd__clkbuf_2
Xfanout970 net972 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__buf_8
Xfanout981 net982 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__buf_6
Xfanout992 net994 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__buf_4
Xfanout1979 net1980 VGND VGND VPWR VPWR net1979 sky130_fd_sc_hd__buf_2
X_12964_ net2757 net2747 net1070 net846 _06005_ VGND VGND VPWR VPWR _06006_ sky130_fd_sc_hd__a41o_1
XFILLER_92_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11915_ _05000_ _04999_ net442 VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__nand3_4
X_12895_ _05944_ _05945_ net240 VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__o21a_1
XFILLER_61_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11846_ _04911_ _04927_ _04929_ _04930_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__a2bb2oi_2
X_14565_ clknet_leaf_20_clk net3443 _00387_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_103_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11777_ net629 _04857_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__and2_1
X_13516_ _06309_ _06310_ net254 VGND VGND VPWR VPWR _06545_ sky130_fd_sc_hd__a21o_1
X_10728_ net387 net386 VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_136_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14496_ clknet_leaf_8_clk net3498 _00318_ VGND VGND VPWR VPWR multiplier_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_1
Xclkload13 clknet_leaf_3_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__inv_12
X_13447_ _06464_ _06472_ _06473_ _06474_ VGND VGND VPWR VPWR _06476_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_11_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10659_ net2387 net1820 VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__nand2_1
XFILLER_142_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13378_ net256 _06406_ _06405_ net491 VGND VGND VPWR VPWR _06407_ sky130_fd_sc_hd__a31o_4
XFILLER_141_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12329_ _05391_ _05392_ VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__nand2_1
XFILLER_114_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07870_ net1252 net1212 VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__nor2_1
XFILLER_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09540_ _02183_ _02185_ _02180_ net676 VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__o211ai_2
X_09471_ _02097_ _02099_ net1254 net1129 VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__o2bb2ai_4
X_08422_ net1351 net1379 net2530 net2561 VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_19_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08353_ _01409_ _01435_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__nand2_1
X_07304_ _07070_ _07071_ _07072_ VGND VGND VPWR VPWR _07075_ sky130_fd_sc_hd__a21oi_1
X_08284_ _01365_ _01368_ net1588 net2374 VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__and4_2
XFILLER_137_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07235_ _07003_ _07004_ _07000_ VGND VGND VPWR VPWR _07006_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload7 clknet_leaf_17_clk VGND VGND VPWR VPWR clkload7/X sky130_fd_sc_hd__clkbuf_4
XFILLER_20_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07166_ net2056 net1398 net2083 net1370 VGND VGND VPWR VPWR _06937_ sky130_fd_sc_hd__a22oi_1
XFILLER_105_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout222 _06154_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_2
Xfanout211 _06251_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_2
Xfanout200 _05149_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_2
Xfanout1209 net1210 VGND VGND VPWR VPWR net1209 sky130_fd_sc_hd__buf_1
XFILLER_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout255 net258 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout233 net234 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_2
XFILLER_87_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07999_ net2064 net1931 VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__nand2_1
Xfanout299 net300 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_8
Xfanout288 net289 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_8
Xfanout266 net268 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout277 net1542 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__buf_8
X_09807_ net673 net672 _02647_ _02648_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__o2bb2ai_2
X_09738_ _02820_ net897 _02816_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__a21o_1
XFILLER_27_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_120_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09669_ net330 _02214_ _02274_ _02275_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_27_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12680_ adder_inst.i_b\[13\] adder_inst.i_b\[12\] adder_inst.i_b\[15\] adder_inst.i_b\[14\]
+ VGND VGND VPWR VPWR _05755_ sky130_fd_sc_hd__or4_1
X_11700_ _04198_ net212 _04200_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__a21o_1
XFILLER_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11631_ net630 _04714_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__nand2_1
XFILLER_30_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14350_ clknet_leaf_5_clk net66 _00172_ VGND VGND VPWR VPWR opcode_stage1 sky130_fd_sc_hd__dfrtp_1
X_11562_ _04159_ _04160_ net2986 _04136_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__o211ai_2
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13301_ net358 net362 net340 _06213_ VGND VGND VPWR VPWR _06330_ sky130_fd_sc_hd__nand4_2
X_10513_ _03328_ _03329_ _03364_ _03366_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_118_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14281_ net2859 VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__inv_2
XFILLER_7_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11493_ _04569_ net556 net555 VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_118_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13232_ net1968 net3182 net216 net529 net2112 VGND VGND VPWR VPWR _06261_ sky130_fd_sc_hd__a32o_1
X_10444_ _03527_ _03528_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__nand2_1
XFILLER_123_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13163_ net1349 net486 _06192_ VGND VGND VPWR VPWR _06193_ sky130_fd_sc_hd__o21ai_1
X_10375_ _03411_ _03423_ _03432_ _03435_ _03455_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__o311a_1
XFILLER_40_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_131_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2411 net2412 VGND VGND VPWR VPWR net2411 sky130_fd_sc_hd__buf_1
Xfanout2400 net2402 VGND VGND VPWR VPWR net2400 sky130_fd_sc_hd__clkbuf_2
X_12114_ _05156_ _05157_ _05185_ _05194_ _05189_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__a41oi_2
X_13094_ _05644_ _05646_ _06123_ VGND VGND VPWR VPWR _06124_ sky130_fd_sc_hd__a21o_1
Xfanout2433 net2434 VGND VGND VPWR VPWR net2433 sky130_fd_sc_hd__buf_1
Xfanout2422 net2424 VGND VGND VPWR VPWR net2422 sky130_fd_sc_hd__buf_4
XFILLER_2_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2444 net2956 VGND VGND VPWR VPWR net2444 sky130_fd_sc_hd__buf_4
Xfanout1721 net1722 VGND VGND VPWR VPWR net1721 sky130_fd_sc_hd__clkbuf_1
XFILLER_78_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1710 net1711 VGND VGND VPWR VPWR net1710 sky130_fd_sc_hd__buf_2
Xfanout1732 net1733 VGND VGND VPWR VPWR net1732 sky130_fd_sc_hd__clkbuf_1
X_12045_ _05122_ _05126_ _05127_ net3156 _05116_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__a32oi_4
Xfanout2466 net2468 VGND VGND VPWR VPWR net2466 sky130_fd_sc_hd__clkbuf_2
Xfanout2455 net2456 VGND VGND VPWR VPWR net2455 sky130_fd_sc_hd__buf_4
Xfanout2477 net2478 VGND VGND VPWR VPWR net2477 sky130_fd_sc_hd__buf_2
XFILLER_93_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1754 net1755 VGND VGND VPWR VPWR net1754 sky130_fd_sc_hd__clkbuf_2
Xfanout1776 net1777 VGND VGND VPWR VPWR net1776 sky130_fd_sc_hd__clkbuf_4
Xfanout2488 net2489 VGND VGND VPWR VPWR net2488 sky130_fd_sc_hd__buf_6
Xfanout2499 net2500 VGND VGND VPWR VPWR net2499 sky130_fd_sc_hd__clkbuf_2
Xfanout1765 net1766 VGND VGND VPWR VPWR net1765 sky130_fd_sc_hd__buf_1
Xfanout1743 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR net1743 sky130_fd_sc_hd__buf_6
Xfanout1798 net1799 VGND VGND VPWR VPWR net1798 sky130_fd_sc_hd__clkbuf_4
Xfanout1787 net1792 VGND VGND VPWR VPWR net1787 sky130_fd_sc_hd__clkbuf_4
XFILLER_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13996_ net2832 VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__inv_2
X_12947_ net2749 net1058 net2753 net739 VGND VGND VPWR VPWR _05991_ sky130_fd_sc_hd__o22a_1
XFILLER_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12878_ _05929_ _05930_ net840 VGND VGND VPWR VPWR _05931_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_16_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11829_ net1884 net2568 VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14548_ clknet_leaf_5_clk _00078_ _00370_ VGND VGND VPWR VPWR mul_res\[15\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14479_ clknet_leaf_9_clk adder_inst.exp_larger\[5\] _00301_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[5\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08971_ _02054_ net590 _02022_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__a21o_1
X_07922_ _00839_ _00844_ _00847_ _00835_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__o22ai_1
X_07853_ _00937_ _00938_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__nand2b_1
XFILLER_96_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07784_ net1387 net2337 net2368 net1360 VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09523_ _02606_ _02607_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__nand2_2
XFILLER_37_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09454_ _02443_ net191 _02445_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_35_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09385_ _02469_ _02470_ net1332 net2441 VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__o211ai_1
X_08405_ net436 _01489_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__nand2_1
XFILLER_52_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08336_ net1548 net2430 net2464 net1521 VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__a22oi_2
XFILLER_138_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08267_ net984 net974 _01352_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__o21ai_1
X_07218_ _06983_ _06985_ VGND VGND VPWR VPWR _06989_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08198_ net2064 net1947 net1974 net2039 VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__a22oi_1
XFILLER_4_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07149_ net2705 VGND VGND VPWR VPWR _06921_ sky130_fd_sc_hd__inv_2
XFILLER_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10160_ _02952_ net349 net2977 VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__a21boi_2
XFILLER_126_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1028 net1029 VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__clkbuf_2
Xfanout1006 net1007 VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__buf_1
XFILLER_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1017 net1018 VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__clkbuf_2
X_10091_ _03160_ _03161_ _03173_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_89_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13850_ _04782_ _05312_ net453 VGND VGND VPWR VPWR _06813_ sky130_fd_sc_hd__a21oi_1
XFILLER_142_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12801_ net1306 net752 net1083 _05851_ VGND VGND VPWR VPWR _05863_ sky130_fd_sc_hd__o22ai_1
X_13781_ net2004 adder_inst.exp_b_r\[5\] net509 VGND VGND VPWR VPWR adder_inst.exp_larger\[5\]
+ sky130_fd_sc_hd__mux2_1
X_10993_ _03982_ net565 _03989_ _03990_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__o2bb2ai_2
X_12732_ net1310 net1305 net1300 net2708 VGND VGND VPWR VPWR _05794_ sky130_fd_sc_hd__o31a_1
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_67_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12663_ net119 _05726_ _05740_ VGND VGND VPWR VPWR _05742_ sky130_fd_sc_hd__a21oi_1
X_14402_ clknet_leaf_8_clk net3385 _00224_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12594_ _05676_ net103 net108 net113 VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__nand4_4
X_11614_ _04694_ _04698_ _04699_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_133_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11545_ _04598_ _04604_ _04629_ _04630_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__o211a_1
X_14333_ clknet_leaf_14_clk net39 _00155_ VGND VGND VPWR VPWR adder_inst.i_b\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14264_ net2907 VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__inv_2
X_11476_ _04560_ _04561_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__nor2_1
XFILLER_109_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13215_ net341 net358 _06194_ net364 VGND VGND VPWR VPWR _06244_ sky130_fd_sc_hd__nand4_2
X_10427_ net801 net1843 net2321 net882 VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__nand4_1
X_14195_ net2887 VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__inv_2
XFILLER_124_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13146_ net1457 net524 _06175_ VGND VGND VPWR VPWR _06176_ sky130_fd_sc_hd__a21oi_1
XFILLER_3_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10358_ _03377_ _03441_ _03371_ _03378_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_97_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2241 net2247 VGND VGND VPWR VPWR net2241 sky130_fd_sc_hd__buf_1
Xfanout2252 net2253 VGND VGND VPWR VPWR net2252 sky130_fd_sc_hd__buf_6
X_13077_ _06105_ _06106_ VGND VGND VPWR VPWR _06107_ sky130_fd_sc_hd__nand2_2
Xfanout2230 net2231 VGND VGND VPWR VPWR net2230 sky130_fd_sc_hd__buf_1
X_10289_ net3019 net391 _03132_ _03133_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2285 net2286 VGND VGND VPWR VPWR net2285 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_111_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2274 net2280 VGND VGND VPWR VPWR net2274 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1540 net2965 VGND VGND VPWR VPWR net1540 sky130_fd_sc_hd__clkbuf_2
Xfanout2263 net2264 VGND VGND VPWR VPWR net2263 sky130_fd_sc_hd__clkbuf_2
Xfanout1551 net1552 VGND VGND VPWR VPWR net1551 sky130_fd_sc_hd__clkbuf_1
X_12028_ _05004_ _05094_ _05098_ VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__o21bai_2
Xfanout1562 net2962 VGND VGND VPWR VPWR net1562 sky130_fd_sc_hd__clkbuf_2
Xfanout2296 net2299 VGND VGND VPWR VPWR net2296 sky130_fd_sc_hd__clkbuf_2
Xfanout1584 net1585 VGND VGND VPWR VPWR net1584 sky130_fd_sc_hd__buf_1
Xfanout1573 net1574 VGND VGND VPWR VPWR net1573 sky130_fd_sc_hd__buf_1
Xfanout1595 net1596 VGND VGND VPWR VPWR net1595 sky130_fd_sc_hd__buf_1
XFILLER_66_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13979_ net2828 VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__inv_2
XFILLER_34_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09170_ net1409 net2555 _01455_ _01458_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__a22o_1
XFILLER_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08121_ net1223 net1216 net993 net975 _01200_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__o221ai_1
X_08052_ net2172 net1775 VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__and2_1
XFILLER_135_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08954_ net2216 net1625 net1659 net2186 VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__a22oi_1
XFILLER_88_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07905_ net1025 net995 net1505 net2276 _00840_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__o2111ai_1
X_08885_ _01794_ net2361 net1503 VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__and3_1
X_07836_ _00905_ _00906_ _00903_ _00878_ net596 VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__a32o_1
X_07767_ net705 net704 _00723_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__a21o_1
XFILLER_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09506_ _02590_ net1761 net2260 VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__nand3_4
X_07698_ _00632_ _00633_ _00658_ _00660_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_84_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09437_ _02457_ _02521_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__nand2_4
X_09368_ _02374_ net815 _02452_ _02453_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__a22oi_1
XFILLER_40_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09299_ _02383_ _02384_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__nand2_2
X_08319_ net1527 net2432 VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__nand2_1
XFILLER_126_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_93 net1010 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_60 net2952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_82 net3178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11330_ _04346_ _04345_ _04415_ _04348_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__o211ai_4
XANTENNA_71 net2549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_115_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11261_ _04315_ _04339_ _04340_ _04346_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__a31o_1
XFILLER_140_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13000_ net837 _06033_ _06034_ _05793_ VGND VGND VPWR VPWR _06035_ sky130_fd_sc_hd__or4b_1
X_11192_ _04268_ _04269_ _04277_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__a21oi_1
X_10212_ net2311 net2342 net1785 net1816 VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__and4_1
XFILLER_134_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10143_ net896 _02953_ net661 VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__or3b_1
XFILLER_0_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10074_ net1233 net1109 _03159_ VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__o21ai_2
X_13902_ _06851_ _06852_ VGND VGND VPWR VPWR multiplier_inst.man_final\[12\] sky130_fd_sc_hd__nor2_2
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13833_ _05146_ net196 _05301_ net3001 VGND VGND VPWR VPWR _06796_ sky130_fd_sc_hd__o22ai_1
XFILLER_35_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_126_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13764_ _06768_ _06766_ _06770_ net851 VGND VGND VPWR VPWR _06771_ sky130_fd_sc_hd__a22o_1
XFILLER_15_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10976_ net1763 net2508 VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__nand2_1
X_12715_ multiplier_inst.exp_final\[5\] _05777_ _05779_ VGND VGND VPWR VPWR _05780_
+ sky130_fd_sc_hd__nand3_1
X_13695_ _06373_ _06374_ _06376_ _06391_ _06394_ VGND VGND VPWR VPWR _06710_ sky130_fd_sc_hd__o32a_1
XFILLER_71_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12646_ _05665_ _05710_ _05723_ VGND VGND VPWR VPWR _05726_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_26_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12577_ _05653_ _05660_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__xnor2_2
X_14316_ clknet_leaf_12_clk net24 _00138_ VGND VGND VPWR VPWR adder_inst.exp_a\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11528_ _04612_ _04613_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__nor2_1
X_14247_ net2859 VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__inv_2
X_11459_ _04500_ _04501_ _04541_ net344 VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__nand4_1
X_14178_ net2858 VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_55_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13129_ net1863 net500 _06157_ VGND VGND VPWR VPWR _06159_ sky130_fd_sc_hd__o21ai_1
XFILLER_97_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2060 net2061 VGND VGND VPWR VPWR net2060 sky130_fd_sc_hd__buf_1
XFILLER_86_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2082 net2086 VGND VGND VPWR VPWR net2082 sky130_fd_sc_hd__buf_1
Xfanout2071 net2072 VGND VGND VPWR VPWR net2071 sky130_fd_sc_hd__clkbuf_2
Xfanout2093 net2094 VGND VGND VPWR VPWR net2093 sky130_fd_sc_hd__buf_1
Xfanout1392 net1393 VGND VGND VPWR VPWR net1392 sky130_fd_sc_hd__clkbuf_2
Xfanout1370 net1372 VGND VGND VPWR VPWR net1370 sky130_fd_sc_hd__buf_1
X_08670_ _01562_ _01567_ _01566_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__o21ai_1
Xfanout1381 net1382 VGND VGND VPWR VPWR net1381 sky130_fd_sc_hd__clkbuf_1
X_07621_ _00663_ net716 _00670_ VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__nor3_1
XFILLER_38_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07552_ _00635_ _00636_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__nand2_1
XFILLER_81_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07483_ _00521_ _00546_ _00547_ _00568_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__a2bb2oi_1
XTAP_TAPCELL_ROW_66_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09222_ _02307_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__inv_2
XFILLER_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer405 net3322 VGND VGND VPWR VPWR net3323 sky130_fd_sc_hd__buf_2
X_09153_ net1234 net1141 _01420_ _02236_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__o22a_1
X_08104_ _01175_ _01176_ _01189_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__nand3_1
X_09084_ net2313 net1731 VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__nand2_2
XFILLER_135_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08035_ _01108_ _01116_ _01117_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__nand3b_1
XFILLER_122_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09986_ _02841_ net810 net1204 net1182 VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08937_ _01873_ _01890_ _01888_ _01885_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__o2bb2ai_2
X_08868_ _01952_ _01953_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__nand2_1
XFILLER_85_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07819_ net600 _00730_ net598 _00752_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_83_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08799_ _01879_ net906 net2097 net1778 VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__and4_1
X_10830_ net2355 net1868 VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__nand2_1
XFILLER_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10761_ _03622_ _03636_ _03630_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__a21o_1
XFILLER_40_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12500_ _05578_ _05582_ _05584_ VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__nand3_4
X_13480_ net500 net1893 _06160_ net3265 VGND VGND VPWR VPWR _06509_ sky130_fd_sc_hd__o211ai_4
XFILLER_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10692_ _03559_ _03772_ _03775_ net875 VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__o22a_1
XFILLER_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12431_ _05516_ VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_23_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12362_ net1368 net1394 net2163 net2191 _07085_ VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_97_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12293_ _01060_ _01061_ _01062_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_97_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14101_ net2810 VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__inv_2
X_11313_ net1828 net2541 net2568 net1797 VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__a22oi_2
XFILLER_107_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14032_ net2838 VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__inv_2
X_11244_ _04011_ _04013_ net1202 net1132 VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_122_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11175_ net1192 net1145 _04255_ _04256_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_128_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10126_ _03211_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__inv_2
XFILLER_94_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10057_ net395 net394 _02900_ _02902_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_63_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_141_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13816_ net3412 net832 net721 VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_106_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13747_ _06321_ _06727_ _06734_ _06755_ VGND VGND VPWR VPWR _06756_ sky130_fd_sc_hd__o31a_1
X_10959_ _04038_ _04043_ _04044_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__nand3_2
XFILLER_16_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13678_ _06426_ _06428_ _06694_ _06678_ VGND VGND VPWR VPWR _06695_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_139_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12629_ _05703_ _05709_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[4\] sky130_fd_sc_hd__nor2_1
XFILLER_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout607 _04680_ VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__buf_4
Xfanout629 _04862_ VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__clkbuf_2
X_09840_ net1235 net1117 net1016 net898 _02698_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__o221ai_2
Xfanout618 _05100_ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__buf_4
XFILLER_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09771_ net666 net665 _02844_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_13_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08722_ net682 net681 _01787_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08653_ _01554_ _01737_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07604_ _00662_ _00679_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__nand2_1
XFILLER_81_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08584_ net824 net823 _01258_ VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__a21oi_1
X_07535_ _00616_ net1563 net2156 VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_81_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07466_ net1446 net1478 net2188 net2218 VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__and4_1
XFILLER_22_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09205_ net713 _01482_ net689 VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_22_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07397_ _00428_ _00465_ _00470_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__a21oi_1
Xrebuffer202 _02306_ VGND VGND VPWR VPWR net3120 sky130_fd_sc_hd__buf_1
Xrebuffer213 _02093_ VGND VGND VPWR VPWR net3131 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_20_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09136_ net1641 net2375 net2399 net1606 VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__a22o_1
Xrebuffer224 _03673_ VGND VGND VPWR VPWR net3142 sky130_fd_sc_hd__buf_6
Xrebuffer235 _05255_ VGND VGND VPWR VPWR net3153 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer246 net326 VGND VGND VPWR VPWR net3164 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer257 _06393_ VGND VGND VPWR VPWR net3175 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer268 net1570 VGND VGND VPWR VPWR net3186 sky130_fd_sc_hd__buf_6
X_09067_ net678 net677 _02138_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_79_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08018_ net826 net1850 net2118 net965 VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__and4_1
XFILLER_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2807 net2808 VGND VGND VPWR VPWR net2807 sky130_fd_sc_hd__buf_1
Xfanout2818 net2819 VGND VGND VPWR VPWR net2818 sky130_fd_sc_hd__buf_1
XFILLER_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2829 net2833 VGND VGND VPWR VPWR net2829 sky130_fd_sc_hd__buf_1
X_09969_ net894 net893 net1222 net1151 VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_134_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12980_ _06018_ _06019_ net1069 VGND VGND VPWR VPWR _06020_ sky130_fd_sc_hd__o21a_1
XFILLER_85_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11931_ _04999_ net3074 _05000_ _05002_ _05015_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__a32oi_2
XTAP_TAPCELL_ROW_123_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11862_ _04944_ _04946_ _04943_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__o21bai_2
X_14581_ clknet_leaf_5_clk net3455 _00403_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
X_13601_ net152 _06556_ _06554_ VGND VGND VPWR VPWR _06628_ sky130_fd_sc_hd__and3_1
X_10813_ _03895_ _03898_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__nand2_1
X_13532_ _06534_ _06556_ _06554_ _06523_ VGND VGND VPWR VPWR _06561_ sky130_fd_sc_hd__and4_1
X_11793_ net629 _04865_ _04878_ net710 VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__a211o_4
XPHY_EDGE_ROW_40_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10744_ net1643 net2565 net2593 net1608 VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__a22o_1
X_13463_ net511 net179 _06487_ VGND VGND VPWR VPWR _06492_ sky130_fd_sc_hd__o21ai_4
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10675_ net570 _03759_ _03731_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__a21oi_4
X_12414_ _05470_ _05495_ _05497_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__a21o_1
X_13394_ net1199 net772 net539 net443 VGND VGND VPWR VPWR _06423_ sky130_fd_sc_hd__a31o_1
XFILLER_9_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12345_ _05428_ _05429_ _05430_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__nand3_2
XFILLER_142_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12276_ _05357_ _05359_ _05360_ VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__and3_1
X_14015_ net2802 VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__inv_2
X_11227_ net961 net923 net2479 net1855 _04245_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__o2111ai_1
X_11158_ net2448 net1871 net1901 net2419 VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__a22oi_4
XFILLER_49_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10109_ net1463 net2610 net2636 net1433 VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__a22oi_1
X_11089_ _04167_ _04168_ net3025 VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_108_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07320_ net1256 _07088_ net2165 net1424 _07090_ VGND VGND VPWR VPWR _07091_ sky130_fd_sc_hd__o2111ai_4
XFILLER_16_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07251_ net2055 net1507 net1536 net2028 VGND VGND VPWR VPWR _07022_ sky130_fd_sc_hd__a22oi_1
XFILLER_136_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07182_ net1372 net1397 net2111 net2135 VGND VGND VPWR VPWR _06953_ sky130_fd_sc_hd__and4_1
XFILLER_133_816 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout437 _01452_ VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__clkbuf_1
Xfanout415 _06133_ VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__buf_6
X_09823_ _02907_ net396 _02872_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__a21boi_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout448 _04745_ VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__buf_1
Xfanout426 _03770_ VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__buf_8
XFILLER_101_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout459 _02835_ VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__clkbuf_2
XFILLER_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09754_ net2259 net2287 net1788 net1818 VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__and4_1
XFILLER_27_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08705_ net1242 net1200 VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__nor2_1
XFILLER_73_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09685_ _02245_ net816 _02765_ net351 VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__a22o_1
XFILLER_27_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08636_ _01278_ _01718_ _01717_ net438 VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__nand4_4
XFILLER_42_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08567_ net1009 net978 _01647_ _01651_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__o211ai_2
X_07518_ net2065 net2101 net1632 net1664 VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__nand4_1
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08498_ net2345 net2373 net1034 _01520_ _01525_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__a32o_1
X_07449_ net2132 net2160 net1534 net1567 VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__nand4_2
X_10460_ _03542_ _03533_ net651 VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__nand3_1
XFILLER_136_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09119_ _02196_ _02202_ _02204_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_94_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10391_ _02792_ _03020_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__nand2_2
XFILLER_136_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12130_ net246 _05210_ _05209_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__a21boi_4
XFILLER_89_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2615 net2616 VGND VGND VPWR VPWR net2615 sky130_fd_sc_hd__buf_1
Xfanout2604 net2605 VGND VGND VPWR VPWR net2604 sky130_fd_sc_hd__clkbuf_2
Xfanout2626 net2629 VGND VGND VPWR VPWR net2626 sky130_fd_sc_hd__clkbuf_2
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12061_ _04981_ _04983_ _04984_ _04890_ VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__a22o_1
Xhold480 adder_inst.i_b\[0\] VGND VGND VPWR VPWR net3398 sky130_fd_sc_hd__dlygate4sd3_1
Xhold491 add_res\[14\] VGND VGND VPWR VPWR net3409 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2659 net2660 VGND VGND VPWR VPWR net2659 sky130_fd_sc_hd__buf_1
Xfanout1903 net1905 VGND VGND VPWR VPWR net1903 sky130_fd_sc_hd__buf_2
XFILLER_49_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1925 net1927 VGND VGND VPWR VPWR net1925 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2637 net2640 VGND VGND VPWR VPWR net2637 sky130_fd_sc_hd__buf_1
Xfanout2648 net2650 VGND VGND VPWR VPWR net2648 sky130_fd_sc_hd__dlymetal6s2s_1
X_11012_ _04087_ _04090_ _04094_ _04095_ VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__a2bb2oi_1
Xfanout1914 net1922 VGND VGND VPWR VPWR net1914 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_89_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1947 net1951 VGND VGND VPWR VPWR net1947 sky130_fd_sc_hd__clkbuf_2
Xfanout1936 net1942 VGND VGND VPWR VPWR net1936 sky130_fd_sc_hd__clkbuf_2
Xfanout1958 net1959 VGND VGND VPWR VPWR net1958 sky130_fd_sc_hd__buf_4
Xfanout960 net964 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout993 net994 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__buf_1
Xfanout982 net983 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__buf_6
Xfanout1969 net1971 VGND VGND VPWR VPWR net1969 sky130_fd_sc_hd__clkbuf_2
XFILLER_46_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout971 net972 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__clkbuf_2
X_12963_ net2747 net1069 net2719 net2704 _06004_ VGND VGND VPWR VPWR _06005_ sky130_fd_sc_hd__a311o_1
X_11914_ net1144 net1136 _04816_ _04904_ net794 VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__o221ai_4
X_12894_ net2690 net2761 net755 net2763 VGND VGND VPWR VPWR _05945_ sky130_fd_sc_hd__a22o_1
X_11845_ _04828_ _04841_ _04930_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_103_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14564_ clknet_leaf_7_clk _00096_ _00386_ VGND VGND VPWR VPWR mul_res\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_54_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11776_ _04713_ _04858_ _04860_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__nand3_2
X_14495_ clknet_leaf_8_clk adder_inst.is_zero_b _00317_ VGND VGND VPWR VPWR adder_inst.is_zero_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_13515_ net310 net379 _06314_ net1541 VGND VGND VPWR VPWR _06544_ sky130_fd_sc_hd__o211a_1
X_10727_ _03810_ net426 _03768_ _03765_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_41_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13446_ _06464_ _06472_ _06473_ _06474_ VGND VGND VPWR VPWR _06475_ sky130_fd_sc_hd__and4_1
Xclkload14 clknet_leaf_4_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_11_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10658_ net1789 net2415 VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__nand2_4
XFILLER_126_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13377_ net226 net195 VGND VGND VPWR VPWR _06406_ sky130_fd_sc_hd__nand2_4
X_10589_ net347 _03459_ _03448_ net3134 net3087 VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__o221a_4
XFILLER_115_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12328_ _02449_ _02527_ _02526_ VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__a21bo_4
XFILLER_142_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12259_ _05341_ _05343_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__nand2_1
XFILLER_141_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09470_ net1125 _02096_ _02099_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__o21ai_1
XFILLER_64_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08421_ net1328 net2587 VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__and2_1
XFILLER_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08352_ net1527 net1556 net2372 net2400 VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__nand4_1
X_07303_ _07024_ _07069_ _07071_ VGND VGND VPWR VPWR _07074_ sky130_fd_sc_hd__o21ai_1
X_08283_ net1587 net2371 _01364_ _01367_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_137_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07234_ _07000_ _07003_ _07004_ VGND VGND VPWR VPWR _07005_ sky130_fd_sc_hd__and3_1
Xclkload8 clknet_leaf_18_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_30_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07165_ net2056 net1370 net1397 net2084 VGND VGND VPWR VPWR _06936_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_76_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout223 net225 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_2
Xfanout201 _05149_ VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_1
Xfanout212 _04199_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_4
XFILLER_141_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout256 net258 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_1
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_1
Xfanout245 _05137_ VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_2
Xfanout267 net268 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_4
X_07998_ net2063 net1929 VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__and2_1
Xfanout289 _06135_ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_6
X_09806_ _02853_ _02844_ _02852_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__o21ai_4
XFILLER_101_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09737_ _02820_ net897 net2233 net1842 VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__nand4_4
XFILLER_131_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09668_ _02278_ _02214_ net330 VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_38_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08619_ _01691_ _01696_ net686 _01700_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__o211ai_2
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09599_ net1604 net1639 net2398 net2431 VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__and4_1
X_11630_ _04709_ _04715_ VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__nand2_1
X_11561_ net323 _04136_ _04159_ _04160_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13300_ _06326_ _06327_ _06319_ _06320_ VGND VGND VPWR VPWR _06329_ sky130_fd_sc_hd__a211oi_2
X_10512_ net387 net429 net386 VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_118_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14280_ net2872 VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__inv_2
XFILLER_7_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11492_ net556 net555 _04569_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_118_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13231_ net2112 net529 net215 net3173 VGND VGND VPWR VPWR _06260_ sky130_fd_sc_hd__a22oi_1
X_10443_ net2388 net1786 net1817 net2350 VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__a22oi_2
XFILLER_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13162_ net768 net535 net2037 VGND VGND VPWR VPWR _06192_ sky130_fd_sc_hd__a21o_1
X_10374_ net430 net389 _03455_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_131_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2401 net2402 VGND VGND VPWR VPWR net2401 sky130_fd_sc_hd__buf_1
X_12113_ _05184_ _05193_ _05158_ _05159_ VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__o211ai_4
XFILLER_123_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2412 net2413 VGND VGND VPWR VPWR net2412 sky130_fd_sc_hd__clkbuf_2
X_13093_ _06050_ net506 _06122_ VGND VGND VPWR VPWR _06123_ sky130_fd_sc_hd__o21ai_1
Xfanout2423 net2424 VGND VGND VPWR VPWR net2423 sky130_fd_sc_hd__clkbuf_2
Xfanout1700 net1701 VGND VGND VPWR VPWR net1700 sky130_fd_sc_hd__clkbuf_1
Xfanout2434 net2439 VGND VGND VPWR VPWR net2434 sky130_fd_sc_hd__buf_2
Xfanout1722 net1723 VGND VGND VPWR VPWR net1722 sky130_fd_sc_hd__clkbuf_2
Xfanout1711 net1712 VGND VGND VPWR VPWR net1711 sky130_fd_sc_hd__clkbuf_1
X_12044_ _05128_ _05129_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__nand2_4
Xfanout2467 net2468 VGND VGND VPWR VPWR net2467 sky130_fd_sc_hd__buf_1
Xfanout2445 net2447 VGND VGND VPWR VPWR net2445 sky130_fd_sc_hd__clkbuf_2
Xfanout1733 net1734 VGND VGND VPWR VPWR net1733 sky130_fd_sc_hd__buf_4
Xfanout2456 net2457 VGND VGND VPWR VPWR net2456 sky130_fd_sc_hd__clkbuf_2
Xfanout2478 net2488 VGND VGND VPWR VPWR net2478 sky130_fd_sc_hd__buf_1
Xfanout1755 net1756 VGND VGND VPWR VPWR net1755 sky130_fd_sc_hd__buf_6
Xfanout1744 net1746 VGND VGND VPWR VPWR net1744 sky130_fd_sc_hd__clkbuf_2
Xfanout2489 net2490 VGND VGND VPWR VPWR net2489 sky130_fd_sc_hd__buf_6
Xfanout1766 net1769 VGND VGND VPWR VPWR net1766 sky130_fd_sc_hd__clkbuf_1
XFILLER_93_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout790 _05529_ VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__clkbuf_2
Xfanout1777 net1781 VGND VGND VPWR VPWR net1777 sky130_fd_sc_hd__clkbuf_2
XFILLER_65_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1788 net1792 VGND VGND VPWR VPWR net1788 sky130_fd_sc_hd__clkbuf_1
Xfanout1799 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net1799 sky130_fd_sc_hd__buf_4
X_13995_ net2841 VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__inv_2
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12946_ net2755 net2720 _05989_ _05988_ net747 VGND VGND VPWR VPWR _05990_ sky130_fd_sc_hd__a221o_1
XFILLER_46_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12877_ net1055 net2769 net2771 net736 VGND VGND VPWR VPWR _05930_ sky130_fd_sc_hd__o22a_1
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11828_ net1859 net2597 VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__nand2_1
X_14547_ clknet_leaf_4_clk _00077_ _00369_ VGND VGND VPWR VPWR mul_res\[14\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_60_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11759_ _04679_ net607 _04691_ _04692_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__o2bb2ai_1
X_14478_ clknet_leaf_9_clk adder_inst.exp_larger\[4\] _00300_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_13429_ _06457_ _06456_ net257 _06452_ VGND VGND VPWR VPWR _06458_ sky130_fd_sc_hd__a31o_4
XFILLER_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08970_ _01859_ net3118 net2982 _02054_ net590 VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__o2111ai_4
XFILLER_111_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07921_ _00999_ _01001_ _00992_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__o21ai_1
XFILLER_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07852_ _00820_ _00821_ _00933_ _00936_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__nand4_1
XFILLER_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput1 i_a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
X_07783_ net1360 net1387 net2336 net2367 VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__nand4_2
X_09522_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__inv_2
XFILLER_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09453_ _02443_ net191 _02445_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__a21o_1
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09384_ net1386 net2383 net2411 net1359 VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__a22oi_2
X_08404_ _01428_ _01448_ _01449_ _01488_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__a31oi_1
X_08335_ net1521 net1548 net2430 net2459 VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__nand4_2
XFILLER_138_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08266_ net1680 net2318 VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__nand2_1
X_07217_ net601 _06985_ _06986_ VGND VGND VPWR VPWR _06988_ sky130_fd_sc_hd__nand3b_1
X_08197_ net2063 net1947 VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__nand2_1
X_07148_ net2718 VGND VGND VPWR VPWR _06920_ sky130_fd_sc_hd__inv_2
XFILLER_105_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1029 net1030 VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__clkbuf_2
Xfanout1007 net1008 VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__clkbuf_2
Xfanout1018 net1019 VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__buf_4
X_10090_ _03163_ _03164_ _03174_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_89_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12800_ net1062 _05844_ _05851_ _05861_ VGND VGND VPWR VPWR _05862_ sky130_fd_sc_hd__o31a_1
XFILLER_28_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13780_ net2005 net1277 net509 VGND VGND VPWR VPWR adder_inst.exp_larger\[4\] sky130_fd_sc_hd__mux2_1
X_10992_ _03982_ net565 _03991_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__and3_1
X_12731_ net1061 net1315 net1293 _05791_ VGND VGND VPWR VPWR _05793_ sky130_fd_sc_hd__or4_4
XFILLER_83_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12662_ _05711_ _05725_ _05727_ _05740_ VGND VGND VPWR VPWR _05741_ sky130_fd_sc_hd__nand4b_1
XTAP_TAPCELL_ROW_100_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14401_ clknet_leaf_8_clk net3383 _00223_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11613_ _04372_ _04374_ _04365_ net635 VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__o211ai_4
X_12593_ _05533_ _05662_ _05675_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__o21ai_1
X_11544_ _04624_ _04626_ _04616_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__a21o_1
X_14332_ clknet_leaf_17_clk net38 _00154_ VGND VGND VPWR VPWR adder_inst.i_b\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_14263_ net2907 VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11475_ _04496_ _04499_ _04495_ VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__a21boi_2
XFILLER_109_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13214_ net521 net379 net376 net311 VGND VGND VPWR VPWR _06243_ sky130_fd_sc_hd__or4_4
X_10426_ _03509_ net1843 net2321 net882 VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__and4_1
X_14194_ net2881 VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__inv_2
X_13145_ net768 net535 net1257 VGND VGND VPWR VPWR _06175_ sky130_fd_sc_hd__a21oi_1
X_10357_ _03370_ _03372_ _03373_ net3021 net3035 VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__a32oi_4
XFILLER_111_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2220 net2223 VGND VGND VPWR VPWR net2220 sky130_fd_sc_hd__clkbuf_2
Xfanout2242 net2245 VGND VGND VPWR VPWR net2242 sky130_fd_sc_hd__clkbuf_2
XFILLER_97_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2253 net2257 VGND VGND VPWR VPWR net2253 sky130_fd_sc_hd__buf_4
X_13076_ _06102_ net527 _05680_ _06104_ VGND VGND VPWR VPWR _06106_ sky130_fd_sc_hd__o211ai_1
Xfanout2231 net2232 VGND VGND VPWR VPWR net2231 sky130_fd_sc_hd__buf_6
X_10288_ _03135_ _03136_ net3019 net391 VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_111_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2275 net2276 VGND VGND VPWR VPWR net2275 sky130_fd_sc_hd__clkbuf_2
Xfanout1530 net1531 VGND VGND VPWR VPWR net1530 sky130_fd_sc_hd__clkbuf_1
Xfanout2264 net2265 VGND VGND VPWR VPWR net2264 sky130_fd_sc_hd__buf_2
Xfanout2286 adder_inst.man_a_r\[14\] VGND VGND VPWR VPWR net2286 sky130_fd_sc_hd__clkbuf_2
X_12027_ net864 _05111_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__or2_1
XFILLER_120_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1563 net1568 VGND VGND VPWR VPWR net1563 sky130_fd_sc_hd__clkbuf_2
Xfanout2297 net2298 VGND VGND VPWR VPWR net2297 sky130_fd_sc_hd__clkbuf_4
Xfanout1552 net1553 VGND VGND VPWR VPWR net1552 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1574 net1575 VGND VGND VPWR VPWR net1574 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1596 net1597 VGND VGND VPWR VPWR net1596 sky130_fd_sc_hd__clkbuf_2
Xfanout1585 net1586 VGND VGND VPWR VPWR net1585 sky130_fd_sc_hd__clkbuf_2
X_13978_ net2828 VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__inv_2
X_12929_ net744 net2765 net2768 net749 _05974_ VGND VGND VPWR VPWR _05975_ sky130_fd_sc_hd__o221a_1
XFILLER_33_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08120_ net993 net974 net2264 net1680 _01200_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__o2111ai_4
X_08051_ _01095_ net965 net826 VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_73_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08953_ net1591 net2239 VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__nand2_1
XFILLER_88_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07904_ _00840_ _00842_ net1242 net1225 VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__o2bb2ai_1
X_08884_ _01787_ net681 net682 VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__a21boi_4
XFILLER_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07835_ net441 _00880_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__nand2_1
X_07766_ net705 net704 _00723_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__nand3_1
X_09505_ net1222 net1187 net992 net945 _02136_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__o221ai_4
X_09436_ _02520_ _02521_ _02457_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__a21o_1
X_07697_ _00657_ _00659_ _00780_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_84_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09367_ net435 _02430_ _02451_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__nand3_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_50 net1477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09298_ _02380_ _02382_ net1414 net2382 VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__nand4b_2
X_08318_ net1502 net2464 VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__nand2_1
XANTENNA_61 net2952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08249_ _01323_ _01333_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__nand2_2
XANTENNA_83 _01022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_72 net2551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_94 net1097 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11260_ _04343_ _04282_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__nand2_4
XFILLER_97_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11191_ net1148 net1143 net3145 _04271_ _04274_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__o32a_1
X_10211_ net2342 net1785 VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__nand2_1
XFILLER_133_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_732 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10142_ net661 _02954_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__and2_1
XFILLER_121_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10073_ _02933_ _02935_ net900 _02932_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__o2bb2ai_2
X_13901_ _06850_ _06848_ VGND VGND VPWR VPWR _06852_ sky130_fd_sc_hd__nor2_8
XFILLER_87_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13832_ net2984 _05305_ VGND VGND VPWR VPWR _06795_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_126_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13763_ _06758_ _06276_ _06264_ _06769_ VGND VGND VPWR VPWR _06770_ sky130_fd_sc_hd__a31o_1
X_12714_ _05703_ _05709_ _05778_ VGND VGND VPWR VPWR _05779_ sky130_fd_sc_hd__nor3_1
XFILLER_71_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10975_ net1790 net1821 net2446 net2477 VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__nand4_4
X_13694_ net1812 _06697_ _06393_ VGND VGND VPWR VPWR _06709_ sky130_fd_sc_hd__and3b_1
XFILLER_31_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12645_ net119 _05665_ _05696_ _05699_ _05723_ VGND VGND VPWR VPWR _05725_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_26_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12576_ _05658_ _05659_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__nand2_1
XFILLER_129_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14315_ clknet_leaf_12_clk net22 _00137_ VGND VGND VPWR VPWR adder_inst.exp_a\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_11527_ _04485_ _04491_ _04576_ net556 VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__o31a_1
X_14246_ net2899 VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__inv_2
XFILLER_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11458_ net344 _04504_ _04541_ VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__and3_1
XFILLER_125_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14177_ net2854 VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__inv_2
X_10409_ net806 net891 VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__nand2_1
X_11389_ net638 _04276_ _04268_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__a21boi_2
XFILLER_125_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13128_ net1089 net1273 net602 net3297 net1863 VGND VGND VPWR VPWR _06158_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_55_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2050 net2051 VGND VGND VPWR VPWR net2050 sky130_fd_sc_hd__clkbuf_2
Xfanout2061 net534 VGND VGND VPWR VPWR net2061 sky130_fd_sc_hd__buf_1
Xfanout2083 net2085 VGND VGND VPWR VPWR net2083 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2072 net2073 VGND VGND VPWR VPWR net2072 sky130_fd_sc_hd__buf_1
X_13059_ _06087_ net3300 VGND VGND VPWR VPWR _06089_ sky130_fd_sc_hd__and2_1
Xfanout2094 net2095 VGND VGND VPWR VPWR net2094 sky130_fd_sc_hd__clkbuf_2
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1360 net1361 VGND VGND VPWR VPWR net1360 sky130_fd_sc_hd__buf_1
Xfanout1393 net1402 VGND VGND VPWR VPWR net1393 sky130_fd_sc_hd__clkbuf_1
Xfanout1371 net1372 VGND VGND VPWR VPWR net1371 sky130_fd_sc_hd__buf_1
Xfanout1382 net1383 VGND VGND VPWR VPWR net1382 sky130_fd_sc_hd__clkbuf_2
X_07620_ _00688_ _00693_ _00697_ _00699_ _00691_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__o221ai_2
X_07551_ net1364 net1391 net2281 net2306 VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__nand4_2
XFILLER_46_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07482_ _00566_ _00567_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_66_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09221_ _02272_ _02276_ _02290_ _02293_ _02294_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__a32o_1
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09152_ net1518 net1545 net2460 net2492 VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__nand4_2
Xrebuffer406 net3323 VGND VGND VPWR VPWR net3324 sky130_fd_sc_hd__dlygate4sd1_1
XPHY_EDGE_ROW_86_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08103_ net611 _01188_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__nand2_1
X_09083_ _02166_ _02167_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nand2_2
XFILLER_107_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08034_ _01118_ _01119_ _01108_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__nand3_2
XFILLER_107_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09985_ _03049_ net894 _03051_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__a21oi_2
XFILLER_130_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08936_ _01841_ _01843_ net680 _01859_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__a31o_1
X_08867_ net1335 net2504 _01950_ _01951_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_4_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07818_ _00894_ net613 _00882_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__o21ai_2
XFILLER_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08798_ _01876_ _01877_ _01875_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__a21o_1
X_07749_ _00831_ _00832_ _00830_ VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__a21oi_4
X_10760_ _03633_ _03635_ _03630_ _03622_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__o211a_1
XFILLER_13_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09419_ _02501_ _02502_ _02503_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__a21o_1
X_10691_ _03775_ net875 _03774_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__o21ai_1
XFILLER_139_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12430_ _07008_ _07010_ _07016_ _07017_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_23_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12361_ _05445_ _05446_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_97_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14100_ net2810 VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__inv_2
X_12292_ _01060_ _01061_ _01062_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_97_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11312_ net1798 net2568 VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__nand2_1
XFILLER_106_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14031_ net2842 VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__inv_2
X_11243_ _04011_ _04013_ _04015_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__a21oi_4
X_11174_ _04255_ _04256_ VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_128_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10125_ net3101 _03210_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_50_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10056_ _02903_ _02905_ net395 net394 VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_50_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13815_ net3403 net832 net721 VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__a21o_1
XFILLER_90_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13746_ _06754_ _06740_ _06753_ VGND VGND VPWR VPWR _06755_ sky130_fd_sc_hd__and3_1
XFILLER_73_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10958_ net643 _03967_ _03968_ _03969_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__o2bb2ai_1
X_13677_ net1692 net521 _06405_ _06693_ VGND VGND VPWR VPWR _06694_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_42_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12628_ net102 net111 net107 _05668_ _05708_ VGND VGND VPWR VPWR _05709_ sky130_fd_sc_hd__a41oi_2
X_10889_ _03971_ _03973_ _03963_ _03956_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_139_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12559_ net1281 net2010 VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__and2b_2
XFILLER_117_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14229_ net2892 VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout608 _02361_ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__clkbuf_2
Xfanout619 _05035_ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ net666 net665 _02844_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__a21oi_1
X_08721_ _01593_ _01785_ net682 net681 VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__o211ai_2
X_08652_ net405 _01554_ _01733_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__and3_1
Xfanout1190 net1191 VGND VGND VPWR VPWR net1190 sky130_fd_sc_hd__clkbuf_2
X_07603_ _00557_ _00565_ VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_68_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08583_ net824 net823 net695 VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__and3_1
X_07534_ _00617_ net2185 net1533 VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_81_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07465_ net2173 net2209 VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__nand2_1
X_09204_ net713 _01482_ net689 VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__a21bo_1
XFILLER_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07396_ net1262 net1255 net1029 net719 VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__o31a_1
Xrebuffer203 _01673_ VGND VGND VPWR VPWR net3121 sky130_fd_sc_hd__buf_6
Xrebuffer214 _03097_ VGND VGND VPWR VPWR net3132 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_20_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer225 _03673_ VGND VGND VPWR VPWR net3143 sky130_fd_sc_hd__buf_1
Xrebuffer236 _05131_ VGND VGND VPWR VPWR net3154 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer247 net3163 VGND VGND VPWR VPWR net3165 sky130_fd_sc_hd__clkbuf_2
X_09135_ net1640 net2375 net2399 net1605 VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__a22oi_2
XFILLER_135_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer269 net3186 VGND VGND VPWR VPWR net3187 sky130_fd_sc_hd__buf_6
X_09066_ _02144_ net2959 net550 _02139_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__a31o_1
Xrebuffer258 _06069_ VGND VGND VPWR VPWR net3176 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_79_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08017_ net966 net827 net1254 net1154 VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2819 net2820 VGND VGND VPWR VPWR net2819 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2808 net2811 VGND VGND VPWR VPWR net2808 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_92_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09968_ _03049_ net893 net894 VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__and3_1
XFILLER_49_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08919_ _01812_ _01814_ _02000_ net3004 VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__o211ai_2
XFILLER_76_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09899_ net433 net432 _02975_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__and3_1
X_11930_ net624 _05015_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__nand2_1
XFILLER_73_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11861_ _04710_ _04854_ net1765 net2652 _04853_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_28_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14580_ clknet_leaf_5_clk net3452 _00402_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
X_13600_ _06623_ _06612_ _06553_ _06548_ VGND VGND VPWR VPWR _06627_ sky130_fd_sc_hd__o2bb2ai_2
X_11792_ _04454_ _04457_ _04735_ _04738_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__a211oi_1
X_10812_ _03896_ _03897_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__nand2_1
X_13531_ net176 net525 _06524_ net3190 VGND VGND VPWR VPWR _06560_ sky130_fd_sc_hd__o211ai_4
X_10743_ net1643 net2557 net2591 net1608 VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__a22oi_1
XFILLER_139_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13462_ net531 net179 _06488_ VGND VGND VPWR VPWR _06491_ sky130_fd_sc_hd__o21ai_1
XFILLER_43_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10674_ _03759_ net570 _03724_ _03730_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_126_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12413_ _05498_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__inv_2
X_13393_ _06410_ _06421_ _06409_ VGND VGND VPWR VPWR _06422_ sky130_fd_sc_hd__a21oi_1
XFILLER_138_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12344_ _05406_ _05407_ _05408_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__a21bo_1
XFILLER_114_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12275_ _05359_ _05360_ _05357_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__a21oi_1
X_14014_ net2803 VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__inv_2
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11226_ _04245_ _04250_ net2479 net1855 VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__and4_1
X_11157_ net3015 _03892_ _03690_ _04241_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__nand4_4
X_10108_ _03192_ _03188_ _03191_ VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__nand3_4
XFILLER_110_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11088_ _04166_ _04171_ _04172_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_108_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10039_ net664 _02884_ _02886_ _02887_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_90_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13729_ _06316_ _06317_ _06327_ _06321_ VGND VGND VPWR VPWR _06740_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07250_ net601 _06987_ VGND VGND VPWR VPWR _07021_ sky130_fd_sc_hd__xnor2_1
XFILLER_118_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07181_ net2028 net1507 _06949_ VGND VGND VPWR VPWR _06952_ sky130_fd_sc_hd__and3_1
XFILLER_133_828 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout405 _01545_ VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout438 _01194_ VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__buf_6
X_09822_ _02907_ net396 _02865_ _02871_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout416 _04614_ VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__buf_4
Xfanout427 _03612_ VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__buf_4
X_09753_ net2259 net1819 VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__nand2_1
Xfanout449 _04745_ VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_1
X_08704_ _01639_ _01788_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__nand2_1
XFILLER_55_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09684_ _02765_ net351 _02762_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__a21oi_1
X_08635_ _01716_ _01715_ _01628_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__a21oi_4
XFILLER_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08566_ _01648_ _01649_ net1009 net978 VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__o2bb2ai_2
X_07517_ net2100 net1630 VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__nand2_1
X_08497_ _01534_ _01518_ _01533_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__a21boi_2
X_07448_ net2132 net1567 VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__nand2_1
XFILLER_22_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07379_ _00426_ _00427_ net1255 net1246 VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09118_ _02181_ _02188_ _02200_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_94_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10390_ _03255_ _03475_ _03253_ _03254_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_136_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09049_ net2234 net1801 net1831 net2199 VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__a22oi_2
Xhold481 multiplier_inst.man_final_r\[11\] VGND VGND VPWR VPWR net3399 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2616 net2617 VGND VGND VPWR VPWR net2616 sky130_fd_sc_hd__buf_1
Xfanout2605 net2606 VGND VGND VPWR VPWR net2605 sky130_fd_sc_hd__clkbuf_2
X_12060_ _05073_ _05144_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__nand2_1
Xhold470 adder_inst.i_b\[22\] VGND VGND VPWR VPWR net3388 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2627 net2628 VGND VGND VPWR VPWR net2627 sky130_fd_sc_hd__clkbuf_2
Xhold492 _00005_ VGND VGND VPWR VPWR net3410 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1904 net1905 VGND VGND VPWR VPWR net1904 sky130_fd_sc_hd__clkbuf_2
Xfanout2638 net2640 VGND VGND VPWR VPWR net2638 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2649 net2651 VGND VGND VPWR VPWR net2649 sky130_fd_sc_hd__dlymetal6s2s_1
X_11011_ net973 net899 net1678 net2565 _03895_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__o2111ai_1
Xfanout1915 net1918 VGND VGND VPWR VPWR net1915 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout950 net951 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__buf_1
Xfanout1948 net1949 VGND VGND VPWR VPWR net1948 sky130_fd_sc_hd__clkbuf_2
Xfanout1959 net1967 VGND VGND VPWR VPWR net1959 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1926 net1927 VGND VGND VPWR VPWR net1926 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout961 net962 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__clkbuf_2
Xfanout1937 net1941 VGND VGND VPWR VPWR net1937 sky130_fd_sc_hd__buf_6
Xfanout994 net995 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__clkbuf_4
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout972 net973 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__buf_8
Xfanout983 _00886_ VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__buf_6
X_12962_ net2710 _06003_ _05858_ net2738 VGND VGND VPWR VPWR _06004_ sky130_fd_sc_hd__o211a_1
XFILLER_18_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12893_ net2765 net1056 net841 _05943_ VGND VGND VPWR VPWR _05944_ sky130_fd_sc_hd__o211a_1
X_11913_ _04903_ _04905_ _04907_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__a21o_1
XFILLER_18_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11844_ _04829_ _04830_ _04837_ _04839_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_103_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14563_ clknet_leaf_8_clk _00095_ _00385_ VGND VGND VPWR VPWR mul_res\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_60_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11775_ _04713_ _04858_ _04859_ _04835_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__o2bb2ai_4
X_14494_ clknet_leaf_7_clk net3335 _00316_ VGND VGND VPWR VPWR adder_inst.sign_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_13514_ _06541_ _06542_ net253 VGND VGND VPWR VPWR _06543_ sky130_fd_sc_hd__nand3_4
X_10726_ _03765_ _03768_ net426 net2997 VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__a2bb2oi_2
XTAP_TAPCELL_ROW_136_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13445_ _06471_ net530 VGND VGND VPWR VPWR _06474_ sky130_fd_sc_hd__nand2_1
X_10657_ _03734_ _03735_ _03736_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__nand3_1
Xclkload15 clknet_leaf_5_clk VGND VGND VPWR VPWR clkload15/Y sky130_fd_sc_hd__inv_8
XFILLER_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13376_ net372 net228 net295 _06403_ net3180 VGND VGND VPWR VPWR _06405_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_11_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10588_ net580 net3085 net347 _03459_ VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_142_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12327_ _05382_ _05412_ VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__or2_1
XFILLER_126_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12258_ _05338_ net382 _05342_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__a21oi_2
XFILLER_107_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11209_ net2324 net2354 net1954 net1979 VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__nand4_4
XFILLER_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12189_ _05274_ _05260_ _05270_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__and3_1
XFILLER_110_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08420_ _01467_ _01462_ _01465_ _01500_ _01501_ VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_19_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08351_ net2395 net2426 VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__nand2_1
X_07302_ _07024_ _07069_ VGND VGND VPWR VPWR _07073_ sky130_fd_sc_hd__nand2_2
X_08282_ net1616 net1652 net2315 net2344 VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__nand4_1
X_07233_ net1344 net2084 _07001_ _07002_ VGND VGND VPWR VPWR _07004_ sky130_fd_sc_hd__a22o_1
Xclkload9 clknet_leaf_19_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__clkinv_16
XFILLER_118_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07164_ net2057 net1373 VGND VGND VPWR VPWR _06935_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout213 _02073_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__buf_4
Xfanout202 _04650_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__buf_4
XFILLER_101_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout235 _06128_ VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_1
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_1
Xfanout246 _05137_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_6
XFILLER_115_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout257 net258 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_2
X_07997_ _01079_ _01080_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__nand2_1
Xfanout268 net270 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__buf_6
X_09805_ _02846_ _02851_ net2955 _02854_ _02845_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__a32oi_2
XFILLER_101_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09736_ net2233 net1844 _02820_ _02821_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__a22o_4
XFILLER_27_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09667_ net329 _02214_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_120_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08618_ _01697_ net686 _01699_ _01166_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_38_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09598_ net1640 net2399 net2431 net1605 VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__a22o_4
X_08549_ net2236 net1657 VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__nand2_1
X_11560_ _04161_ _04162_ net323 _04136_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__o211ai_2
XFILLER_24_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10511_ _03596_ net2999 _03551_ _03557_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__o2bb2ai_1
X_13230_ net1968 net3181 net214 net495 net1422 VGND VGND VPWR VPWR _06259_ sky130_fd_sc_hd__a32o_1
X_11491_ _04517_ _04570_ _04573_ _04114_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__o22ai_1
XTAP_TAPCELL_ROW_118_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10442_ net2350 net1817 VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__nand2_1
XFILLER_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13161_ _06181_ net229 VGND VGND VPWR VPWR _06191_ sky130_fd_sc_hd__nand2_1
X_10373_ net430 net389 _03456_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_131_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13092_ net506 _06056_ VGND VGND VPWR VPWR _06122_ sky130_fd_sc_hd__nand2_1
Xfanout2402 net2403 VGND VGND VPWR VPWR net2402 sky130_fd_sc_hd__clkbuf_2
X_12112_ _05184_ _05193_ _05158_ _05159_ VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__o211a_1
Xfanout2413 net2414 VGND VGND VPWR VPWR net2413 sky130_fd_sc_hd__buf_2
Xfanout2424 net2425 VGND VGND VPWR VPWR net2424 sky130_fd_sc_hd__clkbuf_2
XFILLER_2_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12043_ net383 _05116_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__nand2_4
Xfanout2435 net2437 VGND VGND VPWR VPWR net2435 sky130_fd_sc_hd__clkbuf_2
Xfanout1712 net1723 VGND VGND VPWR VPWR net1712 sky130_fd_sc_hd__buf_1
Xfanout1723 net1724 VGND VGND VPWR VPWR net1723 sky130_fd_sc_hd__buf_4
Xfanout2446 net2447 VGND VGND VPWR VPWR net2446 sky130_fd_sc_hd__buf_1
Xfanout2468 net2469 VGND VGND VPWR VPWR net2468 sky130_fd_sc_hd__buf_1
Xfanout1701 net1702 VGND VGND VPWR VPWR net1701 sky130_fd_sc_hd__clkbuf_2
Xfanout2457 adder_inst.man_a_r\[8\] VGND VGND VPWR VPWR net2457 sky130_fd_sc_hd__buf_6
Xfanout1745 net1746 VGND VGND VPWR VPWR net1745 sky130_fd_sc_hd__clkbuf_1
Xfanout1756 net1757 VGND VGND VPWR VPWR net1756 sky130_fd_sc_hd__buf_2
Xfanout1734 net1743 VGND VGND VPWR VPWR net1734 sky130_fd_sc_hd__clkbuf_2
Xfanout1767 net1769 VGND VGND VPWR VPWR net1767 sky130_fd_sc_hd__clkbuf_2
Xfanout2479 net2480 VGND VGND VPWR VPWR net2479 sky130_fd_sc_hd__clkbuf_2
Xfanout1778 net1780 VGND VGND VPWR VPWR net1778 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout780 net781 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__buf_1
Xfanout1789 net1791 VGND VGND VPWR VPWR net1789 sky130_fd_sc_hd__clkbuf_2
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout791 _05175_ VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__buf_1
XFILLER_58_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13994_ net2814 VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__inv_2
X_12945_ net2756 net1079 net1063 _05986_ _05987_ VGND VGND VPWR VPWR _05989_ sky130_fd_sc_hd__o2111a_1
XFILLER_80_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12876_ net2774 net2717 _05927_ _05928_ net746 VGND VGND VPWR VPWR _05929_ sky130_fd_sc_hd__a221o_1
XFILLER_33_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11827_ net1858 net2599 VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__and2_1
X_14546_ clknet_leaf_4_clk _00076_ _00368_ VGND VGND VPWR VPWR mul_res\[13\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_60_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11758_ _04675_ _04678_ net607 _04693_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__o211ai_2
XFILLER_119_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10709_ _03740_ _03737_ _03751_ _03742_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__o22ai_2
X_14477_ clknet_leaf_9_clk adder_inst.exp_larger\[3\] _00299_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[3\] sky130_fd_sc_hd__dfrtp_1
X_11689_ _04606_ net220 _04554_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__a21o_1
X_13428_ net230 net2943 net255 net376 _06348_ VGND VGND VPWR VPWR _06457_ sky130_fd_sc_hd__o2111ai_1
XFILLER_127_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13359_ net770 net180 net537 _06386_ _06385_ VGND VGND VPWR VPWR _06388_ sky130_fd_sc_hd__a311o_1
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07920_ _01002_ _00998_ _00992_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__a21boi_1
XFILLER_88_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07851_ _00820_ _00821_ _00933_ _00936_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_71_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07782_ _00738_ _00865_ _00864_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__a21o_1
XFILLER_68_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput2 i_a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_110_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09521_ _02595_ _02596_ _02603_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__nand3_2
XFILLER_25_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09452_ _01938_ _01941_ net191 _02443_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_35_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09383_ net1359 net1386 net2383 net2411 VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__and4_1
X_08403_ _01483_ _01484_ _01487_ net436 VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__o211ai_4
X_08334_ net1518 net2460 VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__nand2_2
XFILLER_137_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08265_ net2263 net2293 net1712 net1744 VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__nand4_1
XFILLER_137_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07216_ _06985_ _06986_ VGND VGND VPWR VPWR _06987_ sky130_fd_sc_hd__nand2_1
X_08196_ _01268_ _01264_ _01195_ net438 _01276_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__o2111ai_2
X_07147_ net2712 VGND VGND VPWR VPWR _06919_ sky130_fd_sc_hd__inv_2
XFILLER_106_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1008 _00491_ VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__buf_6
Xfanout1019 net1032 VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__clkbuf_2
XFILLER_102_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09719_ net1036 net930 _02804_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__o21a_1
XFILLER_28_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10991_ _03982_ net565 _03985_ _03987_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__o2bb2ai_4
X_12730_ net1316 net1310 VGND VGND VPWR VPWR _05792_ sky130_fd_sc_hd__nor2_1
XFILLER_27_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_106_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12661_ _05733_ _05739_ VGND VGND VPWR VPWR _05740_ sky130_fd_sc_hd__xor2_2
XFILLER_15_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14400_ clknet_leaf_9_clk _00035_ _00222_ VGND VGND VPWR VPWR adder_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11612_ _04365_ net635 _04376_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__a21o_1
X_12592_ _06932_ _05533_ _05673_ _05674_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__o22ai_1
XFILLER_30_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11543_ _04624_ _04626_ _04616_ VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__nand3_1
XFILLER_7_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14331_ clknet_leaf_14_clk net37 _00153_ VGND VGND VPWR VPWR adder_inst.i_b\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_14262_ net2893 VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11474_ _04143_ _04559_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__nand2_1
XFILLER_137_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14193_ net2881 VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__inv_2
X_13213_ net257 net1841 net492 VGND VGND VPWR VPWR _06242_ sky130_fd_sc_hd__and3_1
X_10425_ net882 net801 net1205 net1151 VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_109_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13144_ _06150_ _06173_ net252 net222 VGND VGND VPWR VPWR _06174_ sky130_fd_sc_hd__nand4_4
XFILLER_124_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_115_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2210 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net2210 sky130_fd_sc_hd__buf_6
X_10356_ net3052 net574 VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__nand2_2
Xfanout2221 net2222 VGND VGND VPWR VPWR net2221 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2243 net2245 VGND VGND VPWR VPWR net2243 sky130_fd_sc_hd__buf_1
X_13075_ _06101_ net509 net861 _06103_ VGND VGND VPWR VPWR _06105_ sky130_fd_sc_hd__o211ai_1
Xfanout2232 net2233 VGND VGND VPWR VPWR net2232 sky130_fd_sc_hd__buf_4
XFILLER_3_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10287_ _03129_ _03134_ net3089 net391 net3019 VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__o2111ai_4
Xfanout2254 net2256 VGND VGND VPWR VPWR net2254 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_111_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1531 net1532 VGND VGND VPWR VPWR net1531 sky130_fd_sc_hd__buf_1
Xfanout2276 net2279 VGND VGND VPWR VPWR net2276 sky130_fd_sc_hd__clkbuf_2
Xfanout2265 net2271 VGND VGND VPWR VPWR net2265 sky130_fd_sc_hd__buf_1
Xfanout1520 net1521 VGND VGND VPWR VPWR net1520 sky130_fd_sc_hd__buf_6
X_12026_ net863 _05111_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__nor2_2
Xfanout1564 net1568 VGND VGND VPWR VPWR net1564 sky130_fd_sc_hd__buf_1
XFILLER_78_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2298 net2299 VGND VGND VPWR VPWR net2298 sky130_fd_sc_hd__clkbuf_2
Xfanout1553 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net1553 sky130_fd_sc_hd__buf_4
Xfanout1575 net1579 VGND VGND VPWR VPWR net1575 sky130_fd_sc_hd__clkbuf_2
Xfanout2287 net2289 VGND VGND VPWR VPWR net2287 sky130_fd_sc_hd__clkbuf_2
Xfanout1597 net1598 VGND VGND VPWR VPWR net1597 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_65_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1586 net1600 VGND VGND VPWR VPWR net1586 sky130_fd_sc_hd__buf_1
X_13977_ net2830 VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_124_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12928_ _06914_ net2742 net2733 VGND VGND VPWR VPWR _05974_ sky130_fd_sc_hd__a21oi_1
XFILLER_74_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12859_ net2783 net2726 net1073 _05913_ VGND VGND VPWR VPWR _05914_ sky130_fd_sc_hd__o31a_1
X_14529_ clknet_leaf_8_clk multiplier_inst.exp_final\[6\] _00351_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_08050_ net826 _01135_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_133_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08952_ _02031_ _02032_ _02036_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__nand3_1
XFILLER_88_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07903_ _00840_ _00842_ _00843_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__a21o_1
X_08883_ _01967_ _01968_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__nor2_2
XFILLER_69_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07834_ _00917_ _00918_ _00792_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__nand3b_4
XFILLER_96_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_142_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07765_ _00848_ _00845_ _00835_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__a21oi_1
XFILLER_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07696_ _00780_ _00661_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__nand2_1
X_09504_ _02133_ _02134_ net992 net945 VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_37_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09435_ _02432_ net2983 _02371_ _02516_ _02517_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_84_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09366_ net435 _02430_ _02451_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__a21o_1
X_09297_ _02380_ _02381_ _02379_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__o21ai_2
XANTENNA_40 net1221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08317_ net1239 net1161 VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__nor2_1
XFILLER_138_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_62 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08248_ _01326_ _01331_ _01322_ _01330_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__o211ai_4
XANTENNA_51 net1586 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_73 net2576 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_84 _06892_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_95 net1099 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08179_ _01260_ _01233_ _01259_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__nand3_4
X_10210_ _03289_ _03290_ _03291_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__nand3_4
XFILLER_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11190_ _04274_ _04271_ _04273_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__o21ai_2
XFILLER_106_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10141_ _03220_ _03222_ _03223_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__nand3_4
XFILLER_0_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10072_ _03152_ _03156_ net431 VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__o21ai_4
X_13900_ net115 _05586_ _05595_ _06850_ VGND VGND VPWR VPWR _06851_ sky130_fd_sc_hd__o31a_1
XFILLER_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13831_ _04989_ _05306_ _06793_ VGND VGND VPWR VPWR _06794_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_126_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13762_ _06259_ _06261_ _06276_ _06272_ _06270_ VGND VGND VPWR VPWR _06769_ sky130_fd_sc_hd__a32o_1
XFILLER_46_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10974_ _03931_ _04058_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__nand2_1
X_12713_ _05640_ _05642_ _05641_ VGND VGND VPWR VPWR _05778_ sky130_fd_sc_hd__nand3_1
XFILLER_55_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13693_ _06585_ net136 VGND VGND VPWR VPWR _06708_ sky130_fd_sc_hd__nor2_1
XFILLER_70_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12644_ net119 _05665_ _05696_ _05699_ _05723_ VGND VGND VPWR VPWR _05724_ sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_26_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12575_ _05657_ net2009 net1281 VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__nand3_1
X_14314_ clknet_leaf_12_clk net21 _00136_ VGND VGND VPWR VPWR adder_inst.exp_a\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_11526_ net639 _04611_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__or2_1
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14245_ net2867 VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__inv_2
X_11457_ _04541_ net344 VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__nand2_1
XFILLER_140_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14176_ net2842 VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__inv_2
X_10408_ net994 net925 _03492_ _03486_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__o22a_1
X_11388_ _04276_ net638 _04267_ _04265_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_124_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13127_ net774 net541 net2550 VGND VGND VPWR VPWR _06157_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_55_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10339_ _03193_ _03194_ _03208_ _03209_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2051 net2052 VGND VGND VPWR VPWR net2051 sky130_fd_sc_hd__buf_1
Xfanout2040 net2041 VGND VGND VPWR VPWR net2040 sky130_fd_sc_hd__clkbuf_2
X_13058_ _06085_ net505 _05656_ _06084_ VGND VGND VPWR VPWR _06088_ sky130_fd_sc_hd__o211ai_4
Xfanout2084 net2085 VGND VGND VPWR VPWR net2084 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2073 net2074 VGND VGND VPWR VPWR net2073 sky130_fd_sc_hd__buf_2
Xfanout1350 adder_inst.man_b_r\[23\] VGND VGND VPWR VPWR net1350 sky130_fd_sc_hd__clkbuf_2
Xfanout2095 net2104 VGND VGND VPWR VPWR net2095 sky130_fd_sc_hd__clkbuf_2
X_12009_ net1889 net1917 net2598 net2628 VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__and4_1
Xfanout1361 net1362 VGND VGND VPWR VPWR net1361 sky130_fd_sc_hd__buf_1
Xfanout1372 net1373 VGND VGND VPWR VPWR net1372 sky130_fd_sc_hd__buf_1
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1383 net1390 VGND VGND VPWR VPWR net1383 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1394 net1395 VGND VGND VPWR VPWR net1394 sky130_fd_sc_hd__dlymetal6s2s_1
X_07550_ net1364 net2306 VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__nand2_1
XFILLER_81_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07481_ _00557_ _00558_ _00562_ _00563_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__nand4_1
X_09220_ _02299_ _02302_ _02301_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_45_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09151_ net1521 net1548 net2460 net2491 VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__and4_1
Xrebuffer407 adder_inst.sum_raw_r\[19\] VGND VGND VPWR VPWR net3325 sky130_fd_sc_hd__dlygate4sd1_1
X_08102_ _01089_ _01120_ _01182_ _01183_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__o2bb2ai_2
X_09082_ net1699 net2314 net1732 net2290 VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__a22oi_1
X_08033_ net1049 net959 net2105 net1853 _01113_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__o2111ai_1
Xinput60 i_b[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_131_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09984_ _03049_ net894 _03051_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__a21o_1
XFILLER_130_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08935_ net591 _02020_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__nor2_1
XFILLER_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08866_ _01951_ net2504 net1335 _01950_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__nand4_1
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07817_ _00894_ net613 _00882_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__o21a_1
X_08797_ net1259 net1188 net1047 net953 _01879_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_4_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07748_ _00720_ net991 net1245 net1228 VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_45_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07679_ net2023 net1755 VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__nand2_1
XFILLER_13_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09418_ _02501_ _02502_ _02503_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__a21oi_1
XFILLER_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10690_ _03559_ _03772_ _03775_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__o21ai_1
X_09349_ _02369_ _02371_ _02431_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_23_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12360_ _07080_ _07097_ _07098_ _05444_ _07078_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__a311o_1
XFILLER_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11311_ net1829 net2541 VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__nand2_1
X_12291_ _01062_ _01061_ _01060_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_97_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14030_ net2836 VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__inv_2
X_11242_ _04292_ _04296_ _04295_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__o21ai_2
X_11173_ net1813 net2476 net2508 net1784 VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__a22oi_1
X_10124_ _03188_ _03191_ _03192_ _03206_ _03207_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_128_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10055_ _02907_ net394 net395 VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__and3_1
XFILLER_57_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_141_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13814_ net3490 net832 net721 VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__a21o_1
XFILLER_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13745_ net218 net194 _06598_ _06601_ VGND VGND VPWR VPWR _06754_ sky130_fd_sc_hd__or4b_1
X_10957_ _03970_ _03972_ net643 _03967_ VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_106_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13676_ net2369 net491 net256 _06406_ VGND VGND VPWR VPWR _06693_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_42_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12627_ _05700_ _05707_ VGND VGND VPWR VPWR _05708_ sky130_fd_sc_hd__nor2_1
X_10888_ net798 _03922_ _03972_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_139_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12558_ _05640_ _05642_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[0\] sky130_fd_sc_hd__and2_4
XFILLER_8_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12489_ _05564_ _05574_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__nor2_4
X_11509_ _04581_ _04583_ net418 _04592_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__a22o_1
X_14228_ net2885 VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__inv_2
XFILLER_125_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14159_ net2854 VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__inv_2
Xfanout609 _01257_ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__buf_4
XFILLER_140_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08720_ _01593_ _01785_ net683 _01803_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__o211a_1
X_08651_ _01544_ _01492_ _01543_ _01734_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_1_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1180 net1181 VGND VGND VPWR VPWR net1180 sky130_fd_sc_hd__clkbuf_1
Xfanout1191 _06893_ VGND VGND VPWR VPWR net1191 sky130_fd_sc_hd__buf_4
X_07602_ _00560_ net2306 net1338 _00561_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__a31oi_2
XFILLER_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08582_ _01662_ _01631_ _01663_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__nand3_4
X_07533_ _00616_ _00617_ VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07464_ _00548_ _00549_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09203_ _02280_ _02282_ _02283_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__nand3_4
X_07395_ net1027 net1014 net2160 net1511 _00479_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__o2111ai_2
X_09134_ net1576 net2433 VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__nand2_1
Xrebuffer204 _04798_ VGND VGND VPWR VPWR net3122 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_20_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer226 _03038_ VGND VGND VPWR VPWR net3144 sky130_fd_sc_hd__buf_6
Xrebuffer237 net3154 VGND VGND VPWR VPWR net3155 sky130_fd_sc_hd__buf_2
Xrebuffer215 net325 VGND VGND VPWR VPWR net3133 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_136_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer259 _06053_ VGND VGND VPWR VPWR net3177 sky130_fd_sc_hd__dlymetal6s2s_1
X_09065_ _02139_ net678 net677 VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__and3_1
Xrebuffer248 net2550 VGND VGND VPWR VPWR net3166 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_79_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08016_ net2118 net1850 net966 net827 VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_9_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2809 net2811 VGND VGND VPWR VPWR net2809 sky130_fd_sc_hd__clkbuf_2
XFILLER_104_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09967_ net894 net893 _03049_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__a21oi_1
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08918_ _01812_ _01814_ _02000_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__o21ai_2
XFILLER_76_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09898_ net433 net432 net457 VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__a21oi_2
X_08849_ _01816_ _01821_ _01824_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_28_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11860_ _04710_ _04854_ _04856_ _04853_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_28_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11791_ _04870_ _04874_ _04875_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__nand3_2
X_10811_ net1678 net2565 VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__nand2_1
X_13530_ net175 net525 _06524_ _06532_ VGND VGND VPWR VPWR _06559_ sky130_fd_sc_hd__o211a_1
X_10742_ _03806_ _03822_ _03823_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__nand3_2
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13461_ net512 net3167 _06487_ net2937 VGND VGND VPWR VPWR _06490_ sky130_fd_sc_hd__o211ai_4
XFILLER_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10673_ _03756_ _03758_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__nand2_1
XFILLER_138_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12412_ _05470_ _05495_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__or2_1
X_13392_ net772 net3196 net539 net443 _06420_ VGND VGND VPWR VPWR _06421_ sky130_fd_sc_hd__a311o_1
X_12343_ _05398_ _05393_ _05396_ _05406_ _05407_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__o2111ai_2
XFILLER_142_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12274_ _05358_ _05347_ _05340_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__nand3b_2
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14013_ net2808 VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__inv_2
XFILLER_5_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11225_ _04244_ _04249_ _04246_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__o21ai_1
X_11156_ _04238_ _04239_ _04234_ VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__a21o_1
XFILLER_95_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11087_ net2958 _04171_ _04172_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__and3_1
X_10107_ _03187_ _03190_ _03189_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__nand3_4
X_10038_ _02884_ net664 VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_108_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_740 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13728_ net1493 net136 VGND VGND VPWR VPWR _06739_ sky130_fd_sc_hd__nor2_4
XFILLER_90_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_732 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11989_ _05011_ _05014_ net624 net627 VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_63_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13659_ _06436_ _06437_ _06439_ _06673_ net169 VGND VGND VPWR VPWR _06678_ sky130_fd_sc_hd__o32ai_1
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07180_ net2028 net1507 VGND VGND VPWR VPWR _06951_ sky130_fd_sc_hd__and2_1
XFILLER_8_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout439 _01194_ VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__clkbuf_1
Xfanout406 _01545_ VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__clkbuf_1
X_09821_ _02904_ _02906_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__nand2_1
Xfanout428 _03612_ VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_1
Xfanout417 _04592_ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09752_ net2287 net1788 VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__nand2_1
XFILLER_104_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08703_ _01632_ _01638_ _01637_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__o21ai_1
X_09683_ _02245_ net817 _02765_ _02766_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__nand4_1
XFILLER_39_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08634_ _01628_ _01715_ _01716_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__nand3_4
X_08565_ net2183 net1718 net1747 net2154 VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__a22o_1
X_07516_ net2075 net1664 VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__nand2_1
XFILLER_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08496_ _01580_ _01581_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__nand2_1
X_07447_ net2160 net1534 VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__nand2_1
X_07378_ _00432_ _00429_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__nand2_1
XFILLER_135_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09117_ _02181_ _02188_ _02197_ _02198_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_136_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09048_ net2199 net1831 VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__nand2_1
XFILLER_123_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold471 multiplier_inst.man_final_r\[15\] VGND VGND VPWR VPWR net3389 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2606 net2607 VGND VGND VPWR VPWR net2606 sky130_fd_sc_hd__buf_4
Xfanout2617 net2621 VGND VGND VPWR VPWR net2617 sky130_fd_sc_hd__clkbuf_2
Xhold460 adder_inst.i_a\[18\] VGND VGND VPWR VPWR net3378 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold482 multiplier_inst.man_final_r\[1\] VGND VGND VPWR VPWR net3400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold493 multiplier_inst.man_final_r\[20\] VGND VGND VPWR VPWR net3411 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1905 net1910 VGND VGND VPWR VPWR net1905 sky130_fd_sc_hd__clkbuf_2
X_11010_ _03895_ _03896_ net1208 net1121 VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout2639 net2640 VGND VGND VPWR VPWR net2639 sky130_fd_sc_hd__buf_1
Xfanout1916 net1917 VGND VGND VPWR VPWR net1916 sky130_fd_sc_hd__clkbuf_2
Xfanout2628 net2629 VGND VGND VPWR VPWR net2628 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout951 net956 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__clkbuf_1
Xfanout1949 net1951 VGND VGND VPWR VPWR net1949 sky130_fd_sc_hd__buf_4
Xfanout1927 net1933 VGND VGND VPWR VPWR net1927 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1938 net1939 VGND VGND VPWR VPWR net1938 sky130_fd_sc_hd__buf_1
XFILLER_92_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout984 _00861_ VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__buf_2
Xfanout995 _00643_ VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__buf_6
Xfanout962 net963 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__buf_2
XFILLER_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout973 net983 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__buf_8
X_12961_ net1076 net2754 VGND VGND VPWR VPWR _06003_ sky130_fd_sc_hd__and2_1
X_12892_ net2703 _05942_ VGND VGND VPWR VPWR _05943_ sky130_fd_sc_hd__or2_1
X_11912_ _04816_ _04904_ net2542 net1937 net794 VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__o2111ai_2
XFILLER_54_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11843_ _04829_ _04830_ _04840_ VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__nand3_1
XFILLER_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14562_ clknet_leaf_7_clk _00093_ _00384_ VGND VGND VPWR VPWR mul_res\[29\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_103_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11774_ _04831_ _04835_ _04834_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__o21ai_1
X_14493_ clknet_leaf_8_clk adder_inst.is_zero_a _00315_ VGND VGND VPWR VPWR adder_inst.is_zero_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_13513_ _06433_ _06434_ net223 VGND VGND VPWR VPWR _06542_ sky130_fd_sc_hd__nand3_2
X_10725_ _03802_ _03803_ _03769_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_136_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13444_ net513 net1811 VGND VGND VPWR VPWR _06473_ sky130_fd_sc_hd__nand2_1
X_10656_ _03738_ _03739_ _03733_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__a21oi_2
XFILLER_139_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload16 clknet_leaf_6_clk VGND VGND VPWR VPWR clkload16/Y sky130_fd_sc_hd__inv_6
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13375_ _06402_ net231 _06401_ VGND VGND VPWR VPWR _06404_ sky130_fd_sc_hd__and3_1
X_10587_ _03460_ _03461_ net3085 net3138 VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_11_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12326_ _05410_ _05411_ VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__nand2_2
XFILLER_126_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12257_ _02479_ _02483_ _02482_ VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__o21a_1
XFILLER_141_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11208_ net2324 net2354 net1954 net1980 VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__and4_1
X_12188_ _05272_ _05273_ VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__nor2_1
XFILLER_122_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11139_ net205 net204 _03872_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__and3_1
XFILLER_110_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08350_ net1525 net2372 VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07301_ net2079 net1537 net1565 net2054 VGND VGND VPWR VPWR _07072_ sky130_fd_sc_hd__a22oi_2
X_08281_ net1617 net1651 net2318 net2344 VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__and4_1
XFILLER_32_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07232_ _07002_ net2084 net1344 _07001_ VGND VGND VPWR VPWR _07003_ sky130_fd_sc_hd__nand4_4
XFILLER_20_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07163_ net2058 net1454 VGND VGND VPWR VPWR _06934_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout214 _06253_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_2
Xfanout203 _04210_ VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_6
Xfanout225 _06153_ VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_2
X_09804_ _02875_ _02876_ _02883_ net2975 _02885_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__a32o_1
Xfanout247 _05067_ VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_2
XFILLER_115_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_1
X_07996_ net2039 net1950 net1977 net2017 VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__a22oi_1
Xfanout269 net270 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09735_ net2171 net2197 net1873 net1903 VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__nand4_2
X_09666_ _02746_ net249 _02749_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__a21oi_2
XFILLER_27_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08617_ _01697_ net686 _01701_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_19_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09597_ net1639 net2398 net2431 net1604 VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__a22oi_2
X_08548_ net1622 net2272 VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__nand2_1
X_08479_ net1477 net2412 VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__nand2_1
XFILLER_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10510_ _03594_ _03595_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__nand2_1
X_11490_ _04518_ _04571_ _04574_ _04115_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__a22oi_2
XFILLER_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10441_ net2388 net1786 VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_118_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13160_ net287 _06188_ _06181_ VGND VGND VPWR VPWR _06190_ sky130_fd_sc_hd__a21boi_1
X_10372_ net347 VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_131_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13091_ net378 net373 net365 net3204 VGND VGND VPWR VPWR _06121_ sky130_fd_sc_hd__o211ai_4
X_12111_ _05156_ _05157_ _05185_ _05194_ VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__nand4_2
XFILLER_123_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2403 net2404 VGND VGND VPWR VPWR net2403 sky130_fd_sc_hd__clkbuf_4
X_12042_ _05122_ _05126_ _05127_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__nand3_4
Xfanout2425 net2426 VGND VGND VPWR VPWR net2425 sky130_fd_sc_hd__clkbuf_2
Xfanout2414 adder_inst.man_a_r\[9\] VGND VGND VPWR VPWR net2414 sky130_fd_sc_hd__buf_6
XFILLER_104_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1713 net1717 VGND VGND VPWR VPWR net1713 sky130_fd_sc_hd__buf_2
XFILLER_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1724 net2981 VGND VGND VPWR VPWR net1724 sky130_fd_sc_hd__buf_2
Xfanout1702 net1709 VGND VGND VPWR VPWR net1702 sky130_fd_sc_hd__clkbuf_2
Xfanout2436 net2437 VGND VGND VPWR VPWR net2436 sky130_fd_sc_hd__clkbuf_2
Xfanout2469 net2473 VGND VGND VPWR VPWR net2469 sky130_fd_sc_hd__clkbuf_2
Xfanout2447 net2456 VGND VGND VPWR VPWR net2447 sky130_fd_sc_hd__clkbuf_2
Xfanout1757 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR net1757 sky130_fd_sc_hd__buf_6
XFILLER_78_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1746 net1756 VGND VGND VPWR VPWR net1746 sky130_fd_sc_hd__clkbuf_1
Xfanout1735 net1742 VGND VGND VPWR VPWR net1735 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1779 net1780 VGND VGND VPWR VPWR net1779 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout770 net771 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__clkbuf_1
Xfanout781 net782 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13993_ net2814 VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__inv_2
Xfanout792 _04939_ VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__clkbuf_2
Xfanout1768 net1769 VGND VGND VPWR VPWR net1768 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_37_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12944_ net2762 net2734 net2743 net1082 VGND VGND VPWR VPWR _05988_ sky130_fd_sc_hd__or4_1
X_12875_ net2782 net2728 net743 net2783 _05836_ VGND VGND VPWR VPWR _05928_ sky130_fd_sc_hd__o32a_1
XFILLER_65_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11826_ _04899_ _04900_ _04909_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__nand3_2
X_14545_ clknet_leaf_1_clk _00075_ _00367_ VGND VGND VPWR VPWR mul_res\[12\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_60_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11757_ _04829_ _04841_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__nand2_1
XFILLER_81_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10708_ net876 _03750_ _03737_ _03740_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__o22a_1
X_14476_ clknet_leaf_9_clk adder_inst.exp_larger\[2\] _00298_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[2\] sky130_fd_sc_hd__dfrtp_1
X_11688_ _04420_ _04552_ _04606_ net198 VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__o211ai_1
X_13427_ _06454_ net232 net223 _06455_ VGND VGND VPWR VPWR _06456_ sky130_fd_sc_hd__a211o_1
X_10639_ _03510_ _03512_ net652 _03503_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__o211ai_2
XFILLER_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13358_ net519 net180 _06386_ VGND VGND VPWR VPWR _06387_ sky130_fd_sc_hd__a21oi_1
XFILLER_142_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12309_ _02490_ _02492_ VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__nand2_1
XFILLER_102_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13289_ net1231 net493 _06243_ net1515 _06316_ VGND VGND VPWR VPWR _06318_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_58_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07850_ _00934_ _00935_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_71_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07781_ _00738_ _00865_ _00864_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__a21oi_1
XFILLER_84_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09520_ _02595_ _02596_ net902 _02602_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__o2bb2ai_4
Xinput3 i_a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_09451_ _01938_ _01941_ _02443_ net191 VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__nand4_2
XFILLER_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09382_ net1332 net2441 VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__nand2_1
XFILLER_101_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08402_ _01483_ _01484_ _01487_ net436 VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08333_ net2450 net2482 VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__nand2_4
X_08264_ _01347_ _01348_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__nand2_2
XFILLER_137_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07215_ _06947_ _06980_ _06983_ _06984_ VGND VGND VPWR VPWR _06986_ sky130_fd_sc_hd__a22o_1
X_08195_ net438 _01195_ _01275_ _01277_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07146_ net2738 VGND VGND VPWR VPWR _06918_ sky130_fd_sc_hd__inv_2
XFILLER_105_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1009 net1010 VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__buf_2
XFILLER_120_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07979_ _00933_ _00934_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__nand2_1
X_09718_ net2180 net1930 VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__nand2_1
XFILLER_83_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10990_ _03982_ net565 _03986_ _03988_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09649_ _02714_ net811 net671 VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__or3b_1
XFILLER_28_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12660_ _05737_ _05738_ VGND VGND VPWR VPWR _05739_ sky130_fd_sc_hd__or2_1
XFILLER_15_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11611_ _04365_ _04366_ _04372_ _04374_ VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__o2bb2ai_1
X_12591_ _05651_ _05672_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__nor2_1
X_14330_ clknet_leaf_17_clk net36 _00152_ VGND VGND VPWR VPWR adder_inst.i_b\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_129_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11542_ _04614_ _04615_ _04624_ _04626_ VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__o211ai_2
XFILLER_11_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14261_ net2893 VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11473_ _04141_ net867 _03841_ _04139_ VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__o211ai_1
X_14192_ net2884 VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__inv_2
XFILLER_124_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13212_ net513 net1340 VGND VGND VPWR VPWR _06241_ sky130_fd_sc_hd__nand2_1
X_10424_ net882 net801 net1205 net1151 VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__o2bb2a_2
X_13143_ net307 net334 _06172_ _06164_ VGND VGND VPWR VPWR _06173_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2200 net2202 VGND VGND VPWR VPWR net2200 sky130_fd_sc_hd__clkbuf_2
XFILLER_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10355_ _03433_ net1197 _03439_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__a21oi_4
Xfanout2222 net2223 VGND VGND VPWR VPWR net2222 sky130_fd_sc_hd__clkbuf_1
Xfanout2244 net2246 VGND VGND VPWR VPWR net2244 sky130_fd_sc_hd__clkbuf_2
Xfanout2211 net2212 VGND VGND VPWR VPWR net2211 sky130_fd_sc_hd__clkbuf_2
X_13074_ net527 _06101_ VGND VGND VPWR VPWR _06104_ sky130_fd_sc_hd__nand2_1
Xfanout2233 net2234 VGND VGND VPWR VPWR net2233 sky130_fd_sc_hd__buf_6
XFILLER_3_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10286_ net3019 net391 _03135_ _03136_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__o2bb2ai_4
Xfanout2255 net2256 VGND VGND VPWR VPWR net2255 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_111_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2277 net2278 VGND VGND VPWR VPWR net2277 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_111_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1510 net1511 VGND VGND VPWR VPWR net1510 sky130_fd_sc_hd__buf_2
Xfanout1532 net2965 VGND VGND VPWR VPWR net1532 sky130_fd_sc_hd__clkbuf_2
Xfanout2266 net2268 VGND VGND VPWR VPWR net2266 sky130_fd_sc_hd__buf_2
Xfanout1521 net1524 VGND VGND VPWR VPWR net1521 sky130_fd_sc_hd__buf_6
X_12025_ net1826 net2655 net2677 net1795 VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__a22oi_2
Xfanout1565 net1568 VGND VGND VPWR VPWR net1565 sky130_fd_sc_hd__clkbuf_2
Xfanout1554 net1557 VGND VGND VPWR VPWR net1554 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_53_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2299 net2300 VGND VGND VPWR VPWR net2299 sky130_fd_sc_hd__clkbuf_2
Xfanout1543 net1545 VGND VGND VPWR VPWR net1543 sky130_fd_sc_hd__buf_2
Xfanout2288 net2289 VGND VGND VPWR VPWR net2288 sky130_fd_sc_hd__buf_1
Xfanout1598 net1599 VGND VGND VPWR VPWR net1598 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1587 net1589 VGND VGND VPWR VPWR net1587 sky130_fd_sc_hd__clkbuf_2
XFILLER_65_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1576 net1578 VGND VGND VPWR VPWR net1576 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13976_ net2830 VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__inv_2
X_12927_ _05972_ _05973_ net242 VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__o21a_1
XFILLER_74_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12858_ _06912_ net2726 net2716 VGND VGND VPWR VPWR _05913_ sky130_fd_sc_hd__a21oi_1
XFILLER_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11809_ _04769_ _04894_ VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__nand2b_4
XFILLER_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12789_ net1312 _05786_ _05798_ VGND VGND VPWR VPWR _05851_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14528_ clknet_leaf_8_clk multiplier_inst.exp_final\[5\] _00350_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_14459_ clknet_leaf_4_clk _00044_ _00281_ VGND VGND VPWR VPWR add_res\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_134_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08951_ _02033_ _02035_ _02034_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__nand3_2
X_07902_ _00840_ _00842_ _00843_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__a21oi_1
XFILLER_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08882_ _01954_ _01965_ _01966_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__and3_1
XFILLER_97_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07833_ _00792_ _00918_ _00916_ _00913_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__o2bb2ai_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07764_ _00836_ _00845_ _00848_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__nand3_1
X_07695_ _00657_ _00659_ _00632_ _00633_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__o211ai_2
X_09503_ net1005 net958 _02565_ _02568_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__o22a_2
X_09434_ _02516_ _02517_ _02518_ _02370_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_84_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09365_ _02388_ _02391_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__nand2_1
X_09296_ net1440 net1472 net2333 net2364 VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__nand4_1
XANTENNA_41 net1268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08316_ _01396_ _01400_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__nand2_1
XANTENNA_30 net1098 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_52 net1593 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08247_ _01326_ _01331_ net694 VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__o21ai_1
XANTENNA_74 net2591 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_63 net2330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_96 net1107 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_85 _06893_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08178_ _01260_ _01233_ _01259_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__and3_1
XFILLER_134_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07129_ net1937 VGND VGND VPWR VPWR _06901_ sky130_fd_sc_hd__inv_2
XFILLER_106_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10140_ _03225_ _03224_ _03221_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__nand3_4
X_10071_ net455 _03134_ _03153_ _03154_ VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__nand4_1
XFILLER_47_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13830_ _04776_ _04893_ _04895_ _05311_ VGND VGND VPWR VPWR _06793_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_126_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13761_ net134 _06767_ net851 VGND VGND VPWR VPWR _06768_ sky130_fd_sc_hd__a21oi_2
XFILLER_16_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10973_ net1821 net2446 net2477 net1790 VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__a22oi_4
X_12712_ _05775_ _05776_ VGND VGND VPWR VPWR _05777_ sky130_fd_sc_hd__nor2_1
X_13692_ _06691_ _06396_ _06706_ VGND VGND VPWR VPWR _06707_ sky130_fd_sc_hd__a21oi_1
X_12643_ _05722_ VGND VGND VPWR VPWR _05723_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_26_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12574_ net1281 net2009 _05657_ VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__a21o_1
XFILLER_11_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14313_ clknet_leaf_12_clk net20 _00135_ VGND VGND VPWR VPWR adder_inst.exp_a\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_8_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11525_ _04146_ _04147_ _04143_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__o21a_1
X_14244_ net2868 VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__inv_2
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11456_ _04535_ _04532_ _04508_ _04537_ VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__o211ai_4
XFILLER_125_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14175_ net2835 VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__inv_2
X_10407_ _03492_ _03486_ _03490_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__o21ai_2
X_11387_ _04347_ _04348_ _04415_ _04468_ net384 VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__a32o_1
XFILLER_140_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13126_ net380 net376 net311 VGND VGND VPWR VPWR _06156_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_55_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10338_ _03406_ _03407_ _03408_ _03422_ _03413_ VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__a32o_2
XFILLER_140_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2030 net2031 VGND VGND VPWR VPWR net2030 sky130_fd_sc_hd__clkbuf_1
XFILLER_97_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2052 net2053 VGND VGND VPWR VPWR net2052 sky130_fd_sc_hd__buf_1
X_13057_ _06083_ net525 _05657_ _06086_ VGND VGND VPWR VPWR _06087_ sky130_fd_sc_hd__o211ai_4
Xfanout2041 net2043 VGND VGND VPWR VPWR net2041 sky130_fd_sc_hd__buf_4
XFILLER_3_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1340 net1347 VGND VGND VPWR VPWR net1340 sky130_fd_sc_hd__clkbuf_2
Xfanout2085 net2086 VGND VGND VPWR VPWR net2085 sky130_fd_sc_hd__buf_1
Xfanout2074 net2077 VGND VGND VPWR VPWR net2074 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2063 net2068 VGND VGND VPWR VPWR net2063 sky130_fd_sc_hd__buf_4
X_12008_ net1887 net2627 VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__nand2_1
X_10269_ _03113_ net388 _03117_ _03118_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_39_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1362 net1363 VGND VGND VPWR VPWR net1362 sky130_fd_sc_hd__clkbuf_2
Xfanout1373 net1374 VGND VGND VPWR VPWR net1373 sky130_fd_sc_hd__buf_1
Xfanout2096 net2099 VGND VGND VPWR VPWR net2096 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1384 net1389 VGND VGND VPWR VPWR net1384 sky130_fd_sc_hd__clkbuf_2
Xfanout1351 net1353 VGND VGND VPWR VPWR net1351 sky130_fd_sc_hd__buf_1
Xfanout1395 net1396 VGND VGND VPWR VPWR net1395 sky130_fd_sc_hd__clkbuf_1
X_13959_ net3428 mul_res\[23\] net2790 VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__mux2_1
XFILLER_81_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07480_ _00557_ _00558_ _00564_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__a21bo_1
XFILLER_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09150_ net1546 net2493 VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__nand2_2
Xrebuffer408 adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR net3326 sky130_fd_sc_hd__dlygate4sd1_1
X_08101_ _01186_ _01120_ _01089_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__nand3_2
X_09081_ net2290 net1731 VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__nand2_1
XFILLER_30_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08032_ net2093 net1854 _01113_ _01115_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__a22o_1
XFILLER_135_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput50 i_b[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
Xinput61 i_b[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
XFILLER_107_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09983_ _03061_ _03063_ _03062_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__nand3_4
X_08934_ _02014_ _02015_ _01891_ _01893_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__o22a_1
XFILLER_89_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08865_ net1385 net2440 net2470 net1358 VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__a22o_1
X_07816_ _00896_ _00897_ _00901_ _00895_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__o211a_1
X_08796_ _01879_ net906 _01875_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__a21o_1
XFILLER_84_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07747_ _00720_ net991 net1506 net2244 VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__nand4_1
XFILLER_83_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07678_ net2076 net1687 VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__nand2_1
XFILLER_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09417_ _02342_ _02344_ _02345_ _02349_ _02353_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__a32o_2
XFILLER_138_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09348_ _02369_ _02370_ _02431_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_23_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09279_ net608 net464 _02357_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__nand3b_1
XFILLER_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11310_ _04389_ _04392_ _04393_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__nand3_1
XFILLER_138_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12290_ _01060_ _01061_ _01062_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__a21bo_1
XFILLER_113_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11241_ _04325_ _04326_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__nand2_2
XFILLER_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11172_ net1784 net1813 net2476 net2508 VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__nand4_2
XFILLER_0_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10123_ _02951_ _03204_ _03205_ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_128_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10054_ net393 _03138_ _03099_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__a21boi_4
XFILLER_87_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_141_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13813_ net3391 net831 net721 VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13744_ _06288_ _06290_ VGND VGND VPWR VPWR _06753_ sky130_fd_sc_hd__nand2_1
X_10956_ net643 _03967_ _03970_ _03972_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_16_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13675_ net154 net160 _06691_ VGND VGND VPWR VPWR _06692_ sky130_fd_sc_hd__o21ai_1
XFILLER_73_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10887_ net873 net798 _03921_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_42_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12626_ net788 _05662_ _05661_ _05526_ net444 VGND VGND VPWR VPWR _05707_ sky130_fd_sc_hd__o41a_1
XTAP_TAPCELL_ROW_42_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12557_ _05533_ _05639_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__nand2_1
X_12488_ _05568_ _05565_ _05573_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__nand3_4
X_11508_ _04581_ _04583_ net418 net417 VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__nand4_2
X_14227_ net2890 VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__inv_2
X_11439_ _04524_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__inv_2
XFILLER_113_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14158_ net2868 VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__inv_2
XFILLER_140_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13109_ net776 net543 net1113 VGND VGND VPWR VPWR _06139_ sky130_fd_sc_hd__a21oi_1
X_14089_ net2840 VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__inv_2
XFILLER_112_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08650_ _01548_ _01735_ _01734_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__nand3_2
Xfanout1170 net1171 VGND VGND VPWR VPWR net1170 sky130_fd_sc_hd__buf_4
Xfanout1181 net1186 VGND VGND VPWR VPWR net1181 sky130_fd_sc_hd__buf_4
Xfanout1192 net1194 VGND VGND VPWR VPWR net1192 sky130_fd_sc_hd__clkbuf_2
X_07601_ _00684_ _00599_ _00578_ VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__nand3_2
XFILLER_82_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08581_ _01665_ _01664_ _01630_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__nand3_4
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07532_ net2155 net1533 net1563 net2194 VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_81_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07463_ net1446 net2218 VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09202_ _02281_ _01556_ net329 _02279_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__a22oi_1
X_07394_ _00479_ net1511 net2160 _00478_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__and4_1
XFILLER_10_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer205 _05209_ VGND VGND VPWR VPWR net3123 sky130_fd_sc_hd__buf_1
X_09133_ net1604 net1639 net2375 net2398 VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__nand4_4
XFILLER_136_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer227 net948 VGND VGND VPWR VPWR net3145 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer216 net2996 VGND VGND VPWR VPWR net3134 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer238 net383 VGND VGND VPWR VPWR net3156 sky130_fd_sc_hd__buf_6
XFILLER_108_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer249 net3166 VGND VGND VPWR VPWR net3167 sky130_fd_sc_hd__dlymetal6s2s_1
X_09064_ net678 net677 _02139_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__a21oi_2
XFILLER_135_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08015_ _01095_ net965 net826 VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__and3_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09966_ net2229 net1865 net1895 net2197 VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__a22o_1
X_08917_ _02000_ _02002_ _01946_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__a21o_1
X_09897_ _02897_ _02901_ _02978_ _02979_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__o211ai_2
X_08848_ _01755_ _01920_ _01919_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__o21ai_2
XFILLER_73_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08779_ _01859_ _01863_ _01832_ _01864_ VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__o211ai_4
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11790_ _04874_ _04875_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__nand2_1
X_10810_ net1708 net1742 net2510 net2538 VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__nand4_1
XFILLER_26_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10741_ _03806_ _03822_ _03823_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__and3_2
XFILLER_41_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13460_ _06487_ _06488_ net179 VGND VGND VPWR VPWR _06489_ sky130_fd_sc_hd__a21o_1
XFILLER_13_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12411_ _05464_ _05466_ _05465_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__a21boi_2
X_10672_ _03737_ _03740_ _03743_ _03752_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__o211ai_1
XFILLER_138_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
X_13391_ net3196 net491 _06419_ VGND VGND VPWR VPWR _06420_ sky130_fd_sc_hd__a21oi_1
X_12342_ _05418_ _05421_ _05419_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__o21a_1
XFILLER_138_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12273_ _05339_ _05346_ _05358_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__o21ai_2
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14012_ net2803 VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__inv_2
XFILLER_5_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11224_ net1164 net1159 _04244_ _04249_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__o22a_1
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11155_ _04237_ _04233_ _04236_ _04231_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__and4_1
XFILLER_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11086_ _03769_ net426 _03808_ _03809_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__o2bb2ai_2
X_10106_ _02936_ _02940_ _02930_ net663 VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__o211ai_2
X_10037_ _03083_ _03077_ net660 VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__a21boi_4
XTAP_TAPCELL_ROW_108_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11988_ net626 net623 VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__nand2_1
X_13727_ net154 net161 _06737_ VGND VGND VPWR VPWR _06738_ sky130_fd_sc_hd__o21a_1
X_10939_ _03950_ _04019_ _04017_ _04021_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__o211ai_4
XFILLER_17_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13658_ _06675_ _06676_ net134 VGND VGND VPWR VPWR _06677_ sky130_fd_sc_hd__o21ai_2
XFILLER_118_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13589_ _06280_ _06329_ _06603_ _06617_ VGND VGND VPWR VPWR _06618_ sky130_fd_sc_hd__and4_1
XFILLER_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12609_ _05688_ _05689_ _05690_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__nor3b_1
Xclkbuf_leaf_11_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_117_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout407 _01346_ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_4
X_09820_ net587 net585 _02889_ VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__nand3_1
Xfanout418 _04591_ VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__buf_4
Xfanout429 _03596_ VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_4
XFILLER_98_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09751_ _02562_ _02578_ _02832_ _02830_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__o211ai_2
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08702_ _01634_ _01635_ _01632_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__o21ai_1
X_09682_ net351 _02762_ _02765_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__and3_1
X_08633_ net438 _01278_ _01718_ _01717_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__a22oi_4
XFILLER_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08564_ net2183 net1713 net1749 net2154 VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__a22oi_2
XFILLER_120_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07515_ _07103_ _00600_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__nor2_2
XFILLER_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08495_ _01572_ _01573_ _01579_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__nand3_2
X_07446_ net719 _00522_ _00528_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__nand3_1
XFILLER_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07377_ _00441_ net830 VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__nand2_1
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09116_ _02191_ _02192_ _02193_ _02189_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_94_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09047_ net2232 net1801 VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__nand2_1
XFILLER_135_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold472 multiplier_inst.man_final_r\[2\] VGND VGND VPWR VPWR net3390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold461 adder_inst.exp_b\[6\] VGND VGND VPWR VPWR net3379 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2607 adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR net2607 sky130_fd_sc_hd__buf_4
Xhold450 adder_inst.i_a\[7\] VGND VGND VPWR VPWR net3368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2618 net2619 VGND VGND VPWR VPWR net2618 sky130_fd_sc_hd__clkbuf_2
Xhold483 add_res\[26\] VGND VGND VPWR VPWR net3401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 multiplier_inst.exp_final_r\[3\] VGND VGND VPWR VPWR net3412 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout1906 net1908 VGND VGND VPWR VPWR net1906 sky130_fd_sc_hd__buf_4
XFILLER_77_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2629 net2633 VGND VGND VPWR VPWR net2629 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout941 _01181_ VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__buf_6
XFILLER_77_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout952 net955 VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__clkbuf_2
Xfanout1928 net1929 VGND VGND VPWR VPWR net1928 sky130_fd_sc_hd__buf_4
Xfanout930 net932 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__buf_4
X_09949_ _03032_ _03034_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__nand2_1
Xfanout1939 net1940 VGND VGND VPWR VPWR net1939 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1917 net1918 VGND VGND VPWR VPWR net1917 sky130_fd_sc_hd__clkbuf_2
Xfanout985 _00861_ VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__buf_2
Xfanout974 net976 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__buf_4
Xfanout963 net964 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__clkbuf_1
X_12960_ net1070 net1062 _06001_ VGND VGND VPWR VPWR _06002_ sky130_fd_sc_hd__and3_1
XFILLER_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout996 net998 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__clkbuf_4
X_12891_ net2768 net1068 _05858_ net2770 _05941_ VGND VGND VPWR VPWR _05942_ sky130_fd_sc_hd__o221a_1
XFILLER_85_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11911_ net794 _04905_ _04906_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__a21o_1
XFILLER_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11842_ _04910_ _04926_ _04911_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__a21oi_4
X_14561_ clknet_leaf_7_clk _00092_ _00383_ VGND VGND VPWR VPWR mul_res\[28\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_103_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13512_ _06540_ _06535_ VGND VGND VPWR VPWR _06541_ sky130_fd_sc_hd__nand2_4
X_11773_ net1155 net1120 _04682_ _04833_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__o22a_1
X_14492_ clknet_leaf_8_clk adder_inst.sign_sum _00314_ VGND VGND VPWR VPWR adder_inst.sign_sum_r
+ sky130_fd_sc_hd__dfrtp_1
X_10724_ net3141 _03801_ _03803_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__a21oi_4
X_13443_ net3201 _06246_ net257 net486 _06470_ VGND VGND VPWR VPWR _06472_ sky130_fd_sc_hd__o311ai_2
XFILLER_70_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10655_ _03739_ _03733_ _03738_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__nand3_1
XFILLER_139_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload17 clknet_leaf_8_clk VGND VGND VPWR VPWR clkload17/X sky130_fd_sc_hd__clkbuf_4
X_13374_ _06401_ _06402_ VGND VGND VPWR VPWR _06403_ sky130_fd_sc_hd__nand2_2
X_12325_ _05383_ _05384_ _05409_ VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_11_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10586_ _03660_ _03659_ _03670_ _03664_ VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__a2bb2oi_4
XFILLER_5_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12256_ _02477_ _02478_ _02481_ _02484_ VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__o31a_1
XFILLER_79_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11207_ net2354 net1953 VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__nand2_2
X_12187_ _05234_ _05235_ _05228_ VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__and3_1
XFILLER_68_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11138_ net205 _03871_ _03872_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__a21o_1
XFILLER_110_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_0_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
X_11069_ _04098_ _04114_ net561 VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__o21ai_1
XFILLER_76_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07300_ net2108 net1510 VGND VGND VPWR VPWR _07071_ sky130_fd_sc_hd__nand2_1
XFILLER_32_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08280_ net2327 net2353 VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__nand2_2
X_07231_ net2056 net1370 net1398 net2032 VGND VGND VPWR VPWR _07002_ sky130_fd_sc_hd__a22o_1
X_07162_ _06932_ VGND VGND VPWR VPWR _06933_ sky130_fd_sc_hd__inv_2
XFILLER_20_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout204 _03871_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_6
XFILLER_115_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_6
XFILLER_113_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout215 _06242_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout226 _06153_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__clkbuf_1
X_09803_ _02875_ _02876_ _02883_ net2976 net664 VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__a32oi_4
Xfanout259 _06151_ VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_1
X_07995_ net2039 net2017 net1948 net1974 VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__nand4_2
Xfanout248 _05067_ VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_1
X_09734_ _02817_ _02818_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__nand2_2
X_09665_ net249 _02746_ _02748_ _02668_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_120_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08616_ _01166_ _01699_ _01691_ _01696_ net686 VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__o221ai_2
XFILLER_131_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09596_ net1604 net2431 VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08547_ net1622 net2236 VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__nand2_2
X_08478_ net1445 net2442 VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__nand2_1
X_07429_ _00441_ _00443_ _00509_ _00510_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__a22oi_1
X_10440_ _03288_ _03269_ _03523_ _03519_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__o211ai_4
XFILLER_10_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10371_ net430 net389 _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_131_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13090_ net3169 net362 net341 VGND VGND VPWR VPWR _06120_ sky130_fd_sc_hd__and3_4
X_12110_ _05109_ net3129 _05120_ _05193_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__a31o_4
XTAP_TAPCELL_ROW_131_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12041_ _05024_ net446 _05036_ _05038_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2415 net2417 VGND VGND VPWR VPWR net2415 sky130_fd_sc_hd__clkbuf_2
Xfanout2426 net2427 VGND VGND VPWR VPWR net2426 sky130_fd_sc_hd__buf_4
Xfanout2404 net2409 VGND VGND VPWR VPWR net2404 sky130_fd_sc_hd__buf_1
XFILLER_104_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1714 net1717 VGND VGND VPWR VPWR net1714 sky130_fd_sc_hd__clkbuf_1
Xfanout1703 net1708 VGND VGND VPWR VPWR net1703 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2437 net2438 VGND VGND VPWR VPWR net2437 sky130_fd_sc_hd__clkbuf_1
Xfanout2448 net2449 VGND VGND VPWR VPWR net2448 sky130_fd_sc_hd__buf_2
Xfanout2459 net2461 VGND VGND VPWR VPWR net2459 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout760 net761 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__buf_1
Xfanout1747 net1748 VGND VGND VPWR VPWR net1747 sky130_fd_sc_hd__clkbuf_2
XFILLER_49_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1736 net1737 VGND VGND VPWR VPWR net1736 sky130_fd_sc_hd__clkbuf_4
Xfanout771 net772 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__buf_1
Xfanout782 _05734_ VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__buf_1
X_13992_ net2814 VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__inv_2
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1769 net1770 VGND VGND VPWR VPWR net1769 sky130_fd_sc_hd__buf_1
Xfanout793 _04917_ VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__clkbuf_2
X_12943_ net2759 net2734 net2743 VGND VGND VPWR VPWR _05987_ sky130_fd_sc_hd__or3b_1
XFILLER_92_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12874_ net2780 net2728 net1073 _05926_ VGND VGND VPWR VPWR _05927_ sky130_fd_sc_hd__o31a_1
XFILLER_61_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11825_ _04897_ _04898_ _04908_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__a21oi_1
X_14544_ clknet_leaf_0_clk _00074_ _00366_ VGND VGND VPWR VPWR mul_res\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_60_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11756_ _04840_ _04828_ _04830_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__o21ai_1
X_14475_ clknet_leaf_3_clk adder_inst.exp_larger\[1\] _00297_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_81_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10707_ _03790_ _03783_ net647 VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__o21a_1
X_13426_ net301 net339 net282 _06226_ _06413_ VGND VGND VPWR VPWR _06455_ sky130_fd_sc_hd__o221a_1
X_11687_ _04606_ net220 _04553_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__nand3_4
XFILLER_139_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10638_ _03510_ _03512_ _03489_ _03502_ net653 VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__o221a_1
X_13357_ net769 net536 net1666 VGND VGND VPWR VPWR _06386_ sky130_fd_sc_hd__a21oi_2
X_10569_ _03653_ _03651_ VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__nand2_2
X_12308_ _02467_ _02473_ _02465_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__o21a_1
X_13288_ _06311_ _06314_ net215 net522 net2194 VGND VGND VPWR VPWR _06317_ sky130_fd_sc_hd__a32o_1
X_12239_ _00948_ _00949_ _00972_ VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_58_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07780_ _00738_ _00864_ _00865_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__nand3_2
XFILLER_110_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput4 i_a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_92_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09450_ _01752_ net192 _02079_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__a21oi_2
X_08401_ _01429_ _01450_ _01451_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__nand3_4
X_09381_ _02466_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__inv_2
XFILLER_101_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08332_ _01401_ _01413_ _01414_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__nand3_2
X_08263_ net2293 net1712 net1744 net2263 VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__a22oi_1
XFILLER_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07214_ _06947_ _06980_ _06983_ _06984_ VGND VGND VPWR VPWR _06985_ sky130_fd_sc_hd__nand4_2
XFILLER_118_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08194_ net439 _01195_ _01271_ _01273_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__o2bb2ai_4
X_07145_ net2731 VGND VGND VPWR VPWR _06917_ sky130_fd_sc_hd__inv_2
XFILLER_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07978_ _01060_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__nand2_1
XFILLER_101_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09717_ net1230 net1127 VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__nor2_1
XFILLER_82_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09648_ net670 net668 _02716_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__a21oi_1
X_09579_ _02161_ _02163_ net400 VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__o21ai_1
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12590_ net121 net786 _06933_ _05652_ _06930_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__a311oi_1
XFILLER_70_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11610_ _04365_ net635 _04373_ _04375_ VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__nand4_1
X_11541_ _04624_ _04626_ _04616_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__a21bo_1
XFILLER_11_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14260_ net2891 VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__inv_2
XFILLER_137_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11472_ net236 _04556_ _04544_ _04549_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_136_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14191_ net2881 VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__inv_2
X_13211_ net3319 net3187 VGND VGND VPWR VPWR adder_inst.sum_raw\[0\] sky130_fd_sc_hd__nand2_4
X_10423_ _03505_ _03506_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__nand2_1
XFILLER_137_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13142_ net275 _06170_ _06171_ net283 VGND VGND VPWR VPWR _06172_ sky130_fd_sc_hd__o211ai_2
X_10354_ _03432_ _03434_ net3078 VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__o21ai_4
XFILLER_124_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2201 net2202 VGND VGND VPWR VPWR net2201 sky130_fd_sc_hd__buf_1
Xfanout2223 net2224 VGND VGND VPWR VPWR net2223 sky130_fd_sc_hd__buf_1
XFILLER_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2212 net2213 VGND VGND VPWR VPWR net2212 sky130_fd_sc_hd__buf_1
X_13073_ net509 _06102_ VGND VGND VPWR VPWR _06103_ sky130_fd_sc_hd__nand2_1
Xfanout2234 net2235 VGND VGND VPWR VPWR net2234 sky130_fd_sc_hd__buf_6
X_10285_ net3019 net391 _03135_ _03136_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__o2bb2a_2
Xfanout2256 net2257 VGND VGND VPWR VPWR net2256 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_111_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2245 net2246 VGND VGND VPWR VPWR net2245 sky130_fd_sc_hd__buf_1
Xfanout1511 net1512 VGND VGND VPWR VPWR net1511 sky130_fd_sc_hd__clkbuf_2
Xfanout1533 net1539 VGND VGND VPWR VPWR net1533 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1500 net1501 VGND VGND VPWR VPWR net1500 sky130_fd_sc_hd__buf_1
Xfanout2267 net2268 VGND VGND VPWR VPWR net2267 sky130_fd_sc_hd__clkbuf_1
Xfanout1522 net1523 VGND VGND VPWR VPWR net1522 sky130_fd_sc_hd__buf_1
X_12024_ _05076_ _05102_ _05075_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__nand3_2
Xfanout2278 net2279 VGND VGND VPWR VPWR net2278 sky130_fd_sc_hd__clkbuf_1
Xfanout1566 net1567 VGND VGND VPWR VPWR net1566 sky130_fd_sc_hd__buf_1
XFILLER_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1555 net1556 VGND VGND VPWR VPWR net1555 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_53_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2289 net2290 VGND VGND VPWR VPWR net2289 sky130_fd_sc_hd__clkbuf_2
Xfanout1544 net1545 VGND VGND VPWR VPWR net1544 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout590 _02055_ VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__buf_4
Xfanout1599 net1600 VGND VGND VPWR VPWR net1599 sky130_fd_sc_hd__clkbuf_2
Xfanout1588 net1589 VGND VGND VPWR VPWR net1588 sky130_fd_sc_hd__clkbuf_1
Xfanout1577 net1578 VGND VGND VPWR VPWR net1577 sky130_fd_sc_hd__clkbuf_2
XFILLER_65_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13975_ net2836 VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__inv_2
XFILLER_46_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12926_ net2693 net2753 net757 net2755 VGND VGND VPWR VPWR _05973_ sky130_fd_sc_hd__a22o_1
XFILLER_46_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12857_ net237 _05911_ _05912_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__and3_4
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_1_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11808_ net889 _04766_ _04767_ _04768_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__nand4_1
X_12788_ net708 _05834_ _05848_ _05849_ VGND VGND VPWR VPWR _05850_ sky130_fd_sc_hd__or4bb_4
X_14527_ clknet_leaf_8_clk multiplier_inst.exp_final\[4\] _00349_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_11739_ net1164 net1136 net936 net924 _04667_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__o221ai_2
X_14458_ clknet_leaf_4_clk _00043_ _00280_ VGND VGND VPWR VPWR add_res\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_128_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13409_ _06436_ net545 net779 _06437_ VGND VGND VPWR VPWR _06438_ sky130_fd_sc_hd__a31o_1
X_14389_ clknet_leaf_15_clk net3439 _00211_ VGND VGND VPWR VPWR adder_inst.man_a_r\[13\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_127_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08950_ _01848_ _01853_ _01851_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07901_ _00840_ _00842_ _00843_ VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__nand3_1
X_08881_ _01965_ _01966_ _01954_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__a21oi_1
X_07832_ _00671_ _00707_ _00788_ _00789_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__o211ai_2
Xfanout2790 net2791 VGND VGND VPWR VPWR net2790 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07763_ _00830_ _00831_ _00832_ _00846_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__a31oi_2
X_09502_ _02565_ _02568_ _02570_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__o21ai_2
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07694_ _00632_ _00633_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__nand2_1
XFILLER_64_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09433_ _02516_ _02517_ _02518_ _02370_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__o2bb2a_1
X_09364_ _02332_ _02438_ _02437_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__a21boi_4
XPHY_EDGE_ROW_56_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08315_ _01399_ _01395_ _01398_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__o21ai_1
X_09295_ net1440 net1472 net2333 net2364 VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__and4_1
XANTENNA_20 multiplier_inst.man_final_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_31 net1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_42 net1336 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_53 net1628 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_64 net2386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08246_ _01127_ _01133_ _01325_ _01327_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__o211ai_4
XANTENNA_75 net2621 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_97 net1116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08177_ _01239_ net823 net695 net609 VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__a22o_1
XFILLER_4_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_86 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07128_ net2544 VGND VGND VPWR VPWR _06900_ sky130_fd_sc_hd__inv_4
XFILLER_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10070_ _03154_ _03150_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__nand2_4
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_126_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13760_ _06273_ _06278_ _06750_ _06279_ VGND VGND VPWR VPWR _06767_ sky130_fd_sc_hd__a22o_1
X_10972_ net1789 net2477 VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__nand2_1
X_12711_ _05731_ _05732_ _05746_ _05747_ VGND VGND VPWR VPWR _05776_ sky130_fd_sc_hd__nand4_1
X_13691_ _06378_ _06701_ _06379_ VGND VGND VPWR VPWR _06706_ sky130_fd_sc_hd__o21a_1
XFILLER_46_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12642_ _05720_ _05721_ VGND VGND VPWR VPWR _05722_ sky130_fd_sc_hd__or2_1
XFILLER_12_820 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12573_ _05654_ _05655_ VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__nand2_2
XFILLER_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14312_ clknet_leaf_12_clk net19 _00134_ VGND VGND VPWR VPWR adder_inst.exp_a\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11524_ _04600_ _04565_ _04598_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__a21oi_2
XFILLER_7_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14243_ net2900 VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__inv_2
X_11455_ _04539_ _04507_ _04538_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__nand3_2
X_10406_ net2269 net1927 VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__nand2_1
XFILLER_7_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14174_ net2837 VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__inv_2
X_11386_ _04347_ _04348_ _04415_ net384 _04468_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__a32oi_4
XFILLER_140_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13125_ net313 net373 net378 VGND VGND VPWR VPWR _06155_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_55_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10337_ net3050 _03422_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__and2_1
XFILLER_112_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2031 net2036 VGND VGND VPWR VPWR net2031 sky130_fd_sc_hd__clkbuf_2
Xfanout2042 net2043 VGND VGND VPWR VPWR net2042 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2020 net2027 VGND VGND VPWR VPWR net2020 sky130_fd_sc_hd__buf_4
X_13056_ net1999 net1086 net731 net606 _06085_ VGND VGND VPWR VPWR _06086_ sky130_fd_sc_hd__o221ai_4
X_10268_ _03114_ _03113_ _03115_ _03116_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_140_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1341 net1347 VGND VGND VPWR VPWR net1341 sky130_fd_sc_hd__clkbuf_1
Xfanout2086 net2087 VGND VGND VPWR VPWR net2086 sky130_fd_sc_hd__buf_1
Xfanout2075 net2077 VGND VGND VPWR VPWR net2075 sky130_fd_sc_hd__clkbuf_2
Xfanout2053 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net2053 sky130_fd_sc_hd__buf_6
Xfanout2064 net2068 VGND VGND VPWR VPWR net2064 sky130_fd_sc_hd__buf_4
Xfanout1330 net1331 VGND VGND VPWR VPWR net1330 sky130_fd_sc_hd__clkbuf_2
X_12007_ net1917 net2627 VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__nand2_1
Xfanout1374 net1375 VGND VGND VPWR VPWR net1374 sky130_fd_sc_hd__buf_1
Xfanout2097 net2099 VGND VGND VPWR VPWR net2097 sky130_fd_sc_hd__clkbuf_1
Xfanout1352 net1353 VGND VGND VPWR VPWR net1352 sky130_fd_sc_hd__buf_1
X_10199_ net1218 net1152 _03278_ net805 VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__o211ai_2
Xfanout1363 net1378 VGND VGND VPWR VPWR net1363 sky130_fd_sc_hd__clkbuf_2
Xfanout1396 net1400 VGND VGND VPWR VPWR net1396 sky130_fd_sc_hd__buf_1
Xfanout1385 net1389 VGND VGND VPWR VPWR net1385 sky130_fd_sc_hd__clkbuf_2
X_13958_ net3470 mul_res\[22\] net2790 VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__mux2_1
X_12909_ net2764 net737 _05957_ _05955_ VGND VGND VPWR VPWR _05958_ sky130_fd_sc_hd__o211a_1
X_13889_ net122 _05584_ _05582_ VGND VGND VPWR VPWR _06843_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer409 adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR net3327 sky130_fd_sc_hd__dlygate4sd1_1
X_08100_ net942 _01185_ _01184_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__o21ai_1
X_09080_ net1699 net2314 VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__nand2_2
XFILLER_135_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08031_ net1263 net1154 net1049 net958 _01113_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__o221ai_1
Xinput40 i_b[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
Xinput51 i_b[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
Xinput62 i_b[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09982_ _03041_ _03060_ _03064_ _03066_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__o211ai_4
Xmax_cap598 _00751_ VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__buf_1
XFILLER_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08933_ _01891_ _02014_ _02015_ _01893_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__or4_1
XFILLER_123_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08864_ net1358 net1385 net2440 net2470 VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__nand4_1
X_07815_ _00884_ _00889_ _00892_ _00769_ VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__o22ai_2
X_08795_ net2045 net2071 net1806 net1837 VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__nand4_2
XFILLER_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07746_ net1245 net1228 _00720_ net991 VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__o211ai_4
XFILLER_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09416_ net675 _02498_ _02499_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__nand3b_2
X_07677_ net2050 net2023 net1719 net1755 VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__nand4_1
XFILLER_52_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09347_ _02369_ _02371_ _02432_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__nand3b_1
XFILLER_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09278_ _02357_ net464 net608 VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__a21bo_1
XFILLER_138_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08229_ _01092_ net715 _01100_ _01101_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__o2bb2ai_1
XPHY_EDGE_ROW_73_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11240_ net962 net916 net2448 net1857 _04321_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__o2111ai_4
XFILLER_107_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11171_ net1789 net1821 net2476 net2509 VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__and4_1
XFILLER_121_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10122_ _03204_ _03205_ _02951_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__a21oi_2
XFILLER_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_128_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10053_ _03138_ net393 _03094_ _03098_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__o2bb2ai_2
XPHY_EDGE_ROW_82_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13812_ multiplier_inst.is_zero_r net1318 VGND VGND VPWR VPWR _06784_ sky130_fd_sc_hd__and2b_1
XFILLER_75_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13743_ _06750_ net153 net763 _06751_ VGND VGND VPWR VPWR _06752_ sky130_fd_sc_hd__o211ai_2
XFILLER_90_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10955_ net643 _03967_ _03971_ _03973_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__nand4_1
X_13674_ _06663_ _06583_ _06690_ VGND VGND VPWR VPWR _06691_ sky130_fd_sc_hd__a21o_1
XFILLER_73_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10886_ net873 net798 _03921_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_42_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12625_ _05705_ _05706_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[5\] sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_42_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12556_ _06932_ _05641_ _05640_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[1\]
+ sky130_fd_sc_hd__mux2_4
XPHY_EDGE_ROW_91_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11507_ net418 net417 VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__nand2_1
X_12487_ _05570_ _05572_ VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__nor2_4
X_14226_ net2885 VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__inv_2
X_11438_ _04029_ _04033_ _04036_ _04025_ net641 VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__o2111ai_4
X_14157_ net2871 VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__inv_2
X_11369_ net1704 net1738 net2626 net2647 VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__nand4_1
X_13108_ net369 net365 net342 net785 VGND VGND VPWR VPWR _06138_ sky130_fd_sc_hd__nand4_4
XFILLER_3_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14088_ net2853 VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__inv_2
XFILLER_78_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13039_ _06060_ _06059_ _06068_ VGND VGND VPWR VPWR _06069_ sky130_fd_sc_hd__a21oi_4
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1171 _06895_ VGND VGND VPWR VPWR net1171 sky130_fd_sc_hd__clkbuf_2
Xfanout1182 net1186 VGND VGND VPWR VPWR net1182 sky130_fd_sc_hd__buf_1
Xfanout1160 _06897_ VGND VGND VPWR VPWR net1160 sky130_fd_sc_hd__clkbuf_2
X_07600_ _00681_ _00682_ _00601_ _00599_ _00578_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__a32o_1
X_08580_ _01662_ _01663_ net375 VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_68_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1193 net1194 VGND VGND VPWR VPWR net1193 sky130_fd_sc_hd__clkbuf_1
XFILLER_93_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07531_ net2155 net1563 VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__nand2_1
XFILLER_81_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07462_ net1478 net2187 VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07393_ _00475_ _00476_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__nand2_1
X_09201_ net329 _02279_ _02284_ _02285_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__nand4_4
X_09132_ _01422_ _01425_ net691 net690 VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_20_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer217 _02544_ VGND VGND VPWR VPWR net3135 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer206 net3123 VGND VGND VPWR VPWR net3124 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer228 _03813_ VGND VGND VPWR VPWR net3146 sky130_fd_sc_hd__buf_6
XFILLER_135_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09063_ _02144_ _02140_ _02143_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__nand3_2
Xrebuffer239 _05255_ VGND VGND VPWR VPWR net3157 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_135_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08014_ net965 net826 _01095_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__a21oi_1
XFILLER_116_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_139_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09965_ net2229 net1865 net1895 net2197 VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__a22oi_1
X_08916_ _01996_ _01997_ _01948_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__nand3_2
X_09896_ _02897_ _02901_ _02978_ _02979_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__o211a_1
XFILLER_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08847_ _01744_ _01922_ net2929 _01929_ _01930_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__a32o_1
XFILLER_85_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_123_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08778_ net680 _01860_ net3117 VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_28_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07729_ _00810_ _00813_ _00705_ _00706_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__o211a_1
XFILLER_60_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10740_ _03824_ _03825_ _03805_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_105_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10671_ _03741_ net649 _03752_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__and3_1
XFILLER_40_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12410_ _05470_ _05495_ VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__and2_1
XFILLER_138_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13390_ net2000 net1088 net730 net605 net1199 VGND VGND VPWR VPWR _06419_ sky130_fd_sc_hd__o221a_1
XFILLER_138_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12341_ _05425_ _05426_ VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__nand2b_2
XFILLER_5_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12272_ _01025_ _01026_ _01027_ _01032_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__a31o_1
X_14011_ net2807 VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__inv_2
X_11223_ _04244_ _04249_ net2479 net1855 VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__o211a_1
XFILLER_122_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11154_ _04238_ _04239_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__nand2_1
XFILLER_1_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11085_ _03802_ net2998 _03769_ net426 VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__o211ai_2
X_10105_ _02930_ net663 _02934_ _02939_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_76_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10036_ _03070_ _03075_ _03076_ _03084_ _03074_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__a32oi_2
XFILLER_75_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11987_ net247 _05068_ _05070_ _05071_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__a22o_1
X_13726_ _06318_ _06730_ _06329_ _06722_ _06320_ VGND VGND VPWR VPWR _06737_ sky130_fd_sc_hd__a221oi_4
X_10938_ _04021_ _04017_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13657_ _06442_ net170 _06441_ VGND VGND VPWR VPWR _06676_ sky130_fd_sc_hd__o21ba_1
X_10869_ _03953_ _03950_ _03952_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__o21ai_2
XFILLER_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13588_ net1570 _06240_ _06554_ _06555_ VGND VGND VPWR VPWR _06617_ sky130_fd_sc_hd__and4_1
X_12608_ _05653_ _05660_ _05659_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__o21ai_1
X_12539_ _05504_ _05624_ VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__xor2_2
XFILLER_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14209_ net2866 VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout408 _01345_ VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_2
Xfanout419 _04185_ VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__clkbuf_2
XFILLER_140_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09750_ _02830_ _02832_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__nand2_1
X_08701_ _01588_ net909 _01591_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__a21oi_1
X_09681_ _02765_ net351 VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__nand2_1
X_08632_ _01676_ net2939 _01712_ _01713_ _01674_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__o2111ai_4
XFILLER_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08563_ net2154 net1747 VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__nand2_1
XFILLER_81_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07514_ net2051 net1596 net1631 net2025 VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__a22oi_1
X_08494_ _01572_ _01573_ _01579_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__a21o_1
XFILLER_23_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07445_ net719 _00522_ _00528_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__and3_1
XFILLER_35_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07376_ _07101_ _00461_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__xor2_1
XFILLER_109_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09115_ _02191_ _02192_ _02193_ _02189_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__a31oi_4
XFILLER_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09046_ _02105_ _02122_ _02126_ _02127_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__o211ai_4
Xhold462 adder_inst.i_a\[16\] VGND VGND VPWR VPWR net3380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold440 adder_inst.i_b\[13\] VGND VGND VPWR VPWR net3358 sky130_fd_sc_hd__dlygate4sd3_1
Xhold451 adder_inst.i_b\[4\] VGND VGND VPWR VPWR net3369 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2608 net2609 VGND VGND VPWR VPWR net2608 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold495 multiplier_inst.man_final_r\[10\] VGND VGND VPWR VPWR net3413 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold484 _00018_ VGND VGND VPWR VPWR net3402 sky130_fd_sc_hd__dlygate4sd3_1
Xhold473 multiplier_inst.exp_final_r\[0\] VGND VGND VPWR VPWR net3391 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout1907 net1908 VGND VGND VPWR VPWR net1907 sky130_fd_sc_hd__buf_1
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2619 net2620 VGND VGND VPWR VPWR net2619 sky130_fd_sc_hd__clkbuf_1
XFILLER_131_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout942 _01181_ VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__clkbuf_1
Xfanout1929 net1932 VGND VGND VPWR VPWR net1929 sky130_fd_sc_hd__clkbuf_2
Xfanout931 net932 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__buf_4
X_09948_ net2205 net1926 VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__nand2_2
Xfanout1918 net1921 VGND VGND VPWR VPWR net1918 sky130_fd_sc_hd__clkbuf_1
Xfanout920 _01419_ VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__buf_1
Xfanout986 _00763_ VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__clkbuf_2
Xfanout953 net955 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__buf_1
Xfanout975 net976 VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__buf_1
Xfanout964 _01114_ VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__buf_1
Xfanout997 net998 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__buf_2
XFILLER_57_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09879_ _02962_ _02964_ _02961_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__nand3b_4
XFILLER_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12890_ net2772 net2726 net2712 net2716 _05940_ VGND VGND VPWR VPWR _05941_ sky130_fd_sc_hd__a2111o_1
XFILLER_73_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11910_ net936 net899 _04991_ _04994_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__o22a_1
X_11841_ _04897_ _04908_ _04898_ _04925_ _04923_ VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__a32oi_2
X_14560_ clknet_leaf_6_clk _00091_ _00382_ VGND VGND VPWR VPWR mul_res\[27\] sky130_fd_sc_hd__dfrtp_1
XFILLER_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11772_ _04711_ _04712_ net1195 net1106 VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_103_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13511_ _06539_ _06536_ net224 VGND VGND VPWR VPWR _06540_ sky130_fd_sc_hd__a21oi_2
X_10723_ _03792_ _03795_ _03797_ _03583_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__and4_1
X_14491_ clknet_leaf_8_clk adder_inst.is_inf_b _00313_ VGND VGND VPWR VPWR adder_inst.is_inf_b_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_139_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13442_ net3200 net257 _06246_ _06470_ VGND VGND VPWR VPWR _06471_ sky130_fd_sc_hd__o31ai_2
XFILLER_13_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10654_ _03739_ _03733_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__nand2_2
XFILLER_41_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13373_ _06400_ net305 _06399_ net414 VGND VGND VPWR VPWR _06402_ sky130_fd_sc_hd__nand4_2
X_10585_ net2974 _03662_ _03663_ _03669_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__a31oi_4
X_12324_ _05409_ _05384_ _05383_ VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__nand3_1
Xclkload18 clknet_leaf_9_clk VGND VGND VPWR VPWR clkload18/Y sky130_fd_sc_hd__inv_16
XTAP_TAPCELL_ROW_11_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12255_ _05338_ net382 VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__nand2_1
XFILLER_141_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11206_ net2393 net1934 VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__nand2_2
X_12186_ _05234_ _05235_ _05228_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__a21oi_1
XFILLER_122_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11137_ net205 net204 _03873_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__a21o_1
XFILLER_1_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11068_ net562 _04116_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__nand2_1
XFILLER_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10019_ net1671 net2436 VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__nand2_2
XFILLER_63_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13709_ _06357_ _06721_ _06590_ _06663_ VGND VGND VPWR VPWR _06722_ sky130_fd_sc_hd__a2bb2o_4
X_07230_ net2057 net2032 net1371 net1398 VGND VGND VPWR VPWR _07001_ sky130_fd_sc_hd__nand4_4
X_07161_ _06929_ _06931_ VGND VGND VPWR VPWR _06932_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_30_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout205 _03869_ VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_4
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout238 net241 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_6
XFILLER_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout216 _06242_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__clkbuf_1
Xfanout227 net228 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_2
X_09802_ _02688_ _02684_ _02887_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__a21oi_4
X_07994_ net2017 net1974 VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__nand2_1
Xfanout249 _02671_ VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_4
X_09733_ net2198 net1866 net1903 net2171 VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__a22oi_2
XFILLER_39_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09664_ _02663_ _02669_ _02670_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__nand3_1
XFILLER_28_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08615_ net2155 _01165_ net1774 _01166_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__a31o_1
XFILLER_15_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09595_ net1639 net2398 VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_120_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08546_ net1590 net2305 VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__nand2_1
X_08477_ net1443 net2410 VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__nand2_1
XFILLER_11_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07428_ _00441_ net830 _00509_ _00510_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__and4_1
XFILLER_11_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07359_ net830 _00444_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__nand2_1
XFILLER_109_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10370_ _03455_ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_131_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09029_ net818 net903 _02109_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_131_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12040_ _05024_ net446 _05037_ _05039_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__nand4_2
Xfanout2416 net2417 VGND VGND VPWR VPWR net2416 sky130_fd_sc_hd__buf_1
Xfanout2405 net2407 VGND VGND VPWR VPWR net2405 sky130_fd_sc_hd__clkbuf_2
Xfanout1715 net1716 VGND VGND VPWR VPWR net1715 sky130_fd_sc_hd__clkbuf_2
Xfanout1704 net1706 VGND VGND VPWR VPWR net1704 sky130_fd_sc_hd__clkbuf_2
Xfanout2438 net2439 VGND VGND VPWR VPWR net2438 sky130_fd_sc_hd__clkbuf_2
Xfanout2427 net2428 VGND VGND VPWR VPWR net2427 sky130_fd_sc_hd__clkbuf_2
Xfanout2449 net2450 VGND VGND VPWR VPWR net2449 sky130_fd_sc_hd__buf_1
XFILLER_131_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout750 _05816_ VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__buf_1
XFILLER_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1748 net1754 VGND VGND VPWR VPWR net1748 sky130_fd_sc_hd__buf_1
XFILLER_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1737 net1741 VGND VGND VPWR VPWR net1737 sky130_fd_sc_hd__clkbuf_1
Xfanout1726 net1728 VGND VGND VPWR VPWR net1726 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout772 net773 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__clkbuf_2
Xfanout761 net764 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__buf_1
Xfanout783 _05686_ VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__clkbuf_2
Xfanout794 _04903_ VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__buf_6
Xfanout1759 net1761 VGND VGND VPWR VPWR net1759 sky130_fd_sc_hd__clkbuf_2
X_13991_ net2829 VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__inv_2
X_12942_ net2764 net2748 net2733 net2743 VGND VGND VPWR VPWR _05986_ sky130_fd_sc_hd__or4_1
XFILLER_65_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12873_ _06913_ net2728 net2716 VGND VGND VPWR VPWR _05926_ sky130_fd_sc_hd__a21oi_1
XANTENNA_110 net1840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11824_ _04897_ _04908_ _04898_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__nand3_4
X_14543_ clknet_leaf_0_clk _00073_ _00365_ VGND VGND VPWR VPWR mul_res\[10\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_60_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11755_ _04830_ _04840_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__nand2_2
X_14474_ clknet_leaf_3_clk adder_inst.exp_larger\[0\] _00296_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10706_ _03790_ _03783_ net647 VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__o21ai_1
X_13425_ _06231_ net282 _06453_ VGND VGND VPWR VPWR _06454_ sky130_fd_sc_hd__a21boi_4
X_11686_ _04771_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__inv_2
XFILLER_139_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10637_ net650 _03721_ _03706_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13356_ net180 net488 _06380_ VGND VGND VPWR VPWR _06385_ sky130_fd_sc_hd__a21oi_1
X_10568_ _03650_ _03652_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__nor2_1
X_12307_ net1052 net915 _02468_ _02470_ VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__o22a_1
X_13287_ _06311_ _06314_ net214 net493 net1511 VGND VGND VPWR VPWR _06316_ sky130_fd_sc_hd__a32o_1
X_10499_ _03534_ _03541_ _03540_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__o21ai_1
X_12238_ net165 _05322_ _03483_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__o21bai_4
XFILLER_123_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12169_ _05254_ _05253_ _05145_ _05212_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__a31oi_4
Xinput5 i_a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08400_ _01474_ _01475_ _01480_ _01481_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__nand4_2
XFILLER_52_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09380_ _02462_ _02464_ _02461_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__nand3b_2
XFILLER_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08331_ _01415_ _01407_ _01402_ _01416_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__o211ai_2
X_08262_ net2262 net1744 VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__nand2_1
X_07213_ _06981_ _06982_ _06969_ _06972_ VGND VGND VPWR VPWR _06984_ sky130_fd_sc_hd__o211ai_2
XFILLER_20_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08193_ net439 _01195_ _01272_ _01274_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__nand4_2
XFILLER_20_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07144_ net2747 VGND VGND VPWR VPWR _06916_ sky130_fd_sc_hd__inv_2
XFILLER_118_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07977_ _01056_ _01059_ _01062_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__o21ai_1
XFILLER_87_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09716_ _02799_ _02800_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__nand2_2
XFILLER_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09647_ _02729_ _02716_ VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__nand2_1
X_09578_ net399 _02661_ net397 VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_100_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08529_ _01269_ _01609_ _01611_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__and3_1
XFILLER_42_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11540_ _04618_ _04620_ _04621_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__nand3_2
XFILLER_136_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_133_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11471_ _04473_ _04545_ _04546_ _04556_ _04551_ VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__a32oi_4
XFILLER_137_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14190_ net2882 VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__inv_2
X_13210_ net3302 net502 _06236_ _06237_ VGND VGND VPWR VPWR _06240_ sky130_fd_sc_hd__o211ai_4
X_10422_ net2295 net1866 net1896 net2269 VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__a22oi_1
XFILLER_137_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13141_ net275 _06166_ VGND VGND VPWR VPWR _06171_ sky130_fd_sc_hd__nand2_2
X_10353_ _03411_ _03423_ _03433_ net430 VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__a2bb2oi_4
X_13072_ _05683_ net3195 net860 VGND VGND VPWR VPWR _06102_ sky130_fd_sc_hd__o21ai_1
XFILLER_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2224 net2952 VGND VGND VPWR VPWR net2224 sky130_fd_sc_hd__clkbuf_2
Xfanout2213 net2217 VGND VGND VPWR VPWR net2213 sky130_fd_sc_hd__clkbuf_2
Xfanout2202 net2203 VGND VGND VPWR VPWR net2202 sky130_fd_sc_hd__clkbuf_2
Xfanout2235 net2248 VGND VGND VPWR VPWR net2235 sky130_fd_sc_hd__buf_6
X_10284_ _03328_ _03368_ net348 VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__a21boi_4
X_12023_ net3243 net618 net617 _05104_ _05106_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__o2111ai_4
XFILLER_111_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2246 net2247 VGND VGND VPWR VPWR net2246 sky130_fd_sc_hd__buf_1
Xfanout1512 net1513 VGND VGND VPWR VPWR net1512 sky130_fd_sc_hd__buf_4
Xfanout2257 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net2257 sky130_fd_sc_hd__buf_6
Xfanout1501 net1502 VGND VGND VPWR VPWR net1501 sky130_fd_sc_hd__clkbuf_1
Xfanout2268 net2270 VGND VGND VPWR VPWR net2268 sky130_fd_sc_hd__clkbuf_1
Xfanout1523 net1524 VGND VGND VPWR VPWR net1523 sky130_fd_sc_hd__buf_1
XFILLER_120_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2279 net2280 VGND VGND VPWR VPWR net2279 sky130_fd_sc_hd__buf_1
Xfanout1534 net1535 VGND VGND VPWR VPWR net1534 sky130_fd_sc_hd__clkbuf_2
Xfanout1556 net1557 VGND VGND VPWR VPWR net1556 sky130_fd_sc_hd__clkbuf_2
Xfanout1545 net1547 VGND VGND VPWR VPWR net1545 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1567 net1568 VGND VGND VPWR VPWR net1567 sky130_fd_sc_hd__clkbuf_2
Xfanout1589 net1590 VGND VGND VPWR VPWR net1589 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1578 net1579 VGND VGND VPWR VPWR net1578 sky130_fd_sc_hd__buf_1
XFILLER_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13974_ net2830 VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__inv_2
X_12925_ net2762 net1063 net747 _05971_ _05970_ VGND VGND VPWR VPWR _05972_ sky130_fd_sc_hd__o311a_1
XFILLER_18_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12856_ net1084 net2773 net2775 net751 VGND VGND VPWR VPWR _05912_ sky130_fd_sc_hd__o22a_1
XFILLER_61_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11807_ _04891_ _04892_ _04766_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__nand3_4
X_12787_ _05847_ _05842_ _05840_ net3324 net752 VGND VGND VPWR VPWR _05849_ sky130_fd_sc_hd__o32a_4
X_14526_ clknet_leaf_3_clk multiplier_inst.exp_final\[3\] _00348_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11738_ _04667_ _04668_ _04669_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__a21o_1
X_14457_ clknet_leaf_5_clk _00042_ _00279_ VGND VGND VPWR VPWR add_res\[15\] sky130_fd_sc_hd__dfrtp_1
X_11669_ _04752_ _04754_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__nand2_1
XFILLER_128_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13408_ net779 net545 net1757 VGND VGND VPWR VPWR _06437_ sky130_fd_sc_hd__a21oi_1
X_14388_ clknet_leaf_15_clk net3469 _00210_ VGND VGND VPWR VPWR adder_inst.man_a_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_115_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13339_ _06213_ net260 net280 _06332_ VGND VGND VPWR VPWR _06368_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_73_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07900_ _00984_ _00981_ _00983_ VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__o21ai_1
X_08880_ _01956_ _01963_ _01964_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__nand3b_1
XPHY_EDGE_ROW_102_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07831_ _00915_ _00822_ _00914_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__nand3_4
Xfanout2780 adder_inst.sum_raw_r\[4\] VGND VGND VPWR VPWR net2780 sky130_fd_sc_hd__buf_1
XFILLER_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2791 net2801 VGND VGND VPWR VPWR net2791 sky130_fd_sc_hd__buf_1
XFILLER_96_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07762_ _00825_ _00829_ _00831_ _00832_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_88_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09501_ _02579_ _02584_ _02583_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__nand3_4
X_07693_ _00761_ _00771_ _00777_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__a21o_1
XFILLER_37_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09432_ _02368_ _02335_ _02428_ _02427_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__o211a_1
XFILLER_37_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_111_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09363_ _02325_ _02329_ _02327_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__a21o_1
X_08314_ _01398_ _01399_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__nand2_1
X_09294_ net1472 net2333 net2364 net1440 VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__a22oi_2
XANTENNA_21 net790 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_10 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_32 net1150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_43 net1376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_54 net1667 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08245_ _01302_ _01303_ _01127_ _01133_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__o2bb2ai_2
XANTENNA_65 net2469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_98 net1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_87 net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08176_ net824 net823 net695 net609 VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__nand4_1
XANTENNA_76 net2634 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07127_ net2520 VGND VGND VPWR VPWR _06899_ sky130_fd_sc_hd__inv_2
XFILLER_137_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_120_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10971_ _04054_ _04056_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__nand2_1
X_12710_ _05667_ _05671_ _05677_ _05678_ VGND VGND VPWR VPWR _05775_ sky130_fd_sc_hd__nand4_1
X_13690_ net1812 _06705_ VGND VGND VPWR VPWR adder_inst.sum_raw\[13\] sky130_fd_sc_hd__xor2_2
XFILLER_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12641_ _05717_ _05718_ _05719_ VGND VGND VPWR VPWR _05721_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12572_ net1279 net2007 VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__xnor2_2
XFILLER_12_832 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14311_ clknet_leaf_11_clk net18 _00133_ VGND VGND VPWR VPWR adder_inst.exp_a\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_8_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11523_ _04558_ _04601_ _04602_ _04554_ net198 VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__a32o_2
X_14242_ net2869 VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__inv_2
X_11454_ _04539_ _04507_ _04538_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__and3_1
XFILLER_137_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10405_ net2269 net1933 VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__and2_1
XFILLER_125_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14173_ net2837 VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__inv_2
X_11385_ _04469_ _04414_ _04470_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__nand3_2
Xfanout2010 adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR net2010 sky130_fd_sc_hd__clkbuf_1
X_13124_ net371 net380 net311 VGND VGND VPWR VPWR _06154_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_55_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10336_ _03420_ _03421_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__nor2_2
XFILLER_140_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2032 net2035 VGND VGND VPWR VPWR net2032 sky130_fd_sc_hd__clkbuf_2
Xfanout2021 net2026 VGND VGND VPWR VPWR net2021 sky130_fd_sc_hd__dlymetal6s2s_1
X_13055_ _06925_ _05643_ _06049_ _05646_ VGND VGND VPWR VPWR _06085_ sky130_fd_sc_hd__o31a_2
Xfanout2043 net2044 VGND VGND VPWR VPWR net2043 sky130_fd_sc_hd__buf_4
X_10267_ net711 net656 _03311_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__a21oi_2
Xfanout1320 net1322 VGND VGND VPWR VPWR net1320 sky130_fd_sc_hd__buf_1
Xfanout2054 net2055 VGND VGND VPWR VPWR net2054 sky130_fd_sc_hd__clkbuf_2
Xfanout2076 net2077 VGND VGND VPWR VPWR net2076 sky130_fd_sc_hd__clkbuf_2
XFILLER_94_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2065 net2066 VGND VGND VPWR VPWR net2065 sky130_fd_sc_hd__clkbuf_2
Xfanout1331 net1336 VGND VGND VPWR VPWR net1331 sky130_fd_sc_hd__clkbuf_2
X_12006_ net1860 net2655 VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__nand2_1
Xfanout1364 net1365 VGND VGND VPWR VPWR net1364 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1342 net1346 VGND VGND VPWR VPWR net1342 sky130_fd_sc_hd__buf_1
Xfanout2098 net2099 VGND VGND VPWR VPWR net2098 sky130_fd_sc_hd__buf_1
XFILLER_94_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1375 net1376 VGND VGND VPWR VPWR net1375 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2087 adder_inst.man_a_r\[21\] VGND VGND VPWR VPWR net2087 sky130_fd_sc_hd__clkbuf_2
Xfanout1353 net1355 VGND VGND VPWR VPWR net1353 sky130_fd_sc_hd__clkbuf_1
X_10198_ _03275_ net888 net804 VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__and3_1
Xfanout1386 net1388 VGND VGND VPWR VPWR net1386 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1397 net1399 VGND VGND VPWR VPWR net1397 sky130_fd_sc_hd__buf_1
X_13957_ net3440 mul_res\[21\] net2797 VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__mux2_1
X_12908_ net2761 net1056 net841 _05956_ VGND VGND VPWR VPWR _05957_ sky130_fd_sc_hd__o211a_1
XFILLER_46_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13888_ _05577_ _06842_ VGND VGND VPWR VPWR multiplier_inst.man_final\[8\] sky130_fd_sc_hd__xor2_1
XFILLER_62_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12839_ net237 _05896_ _05897_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__and3_1
XFILLER_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14509_ clknet_leaf_0_clk multiplier_inst.man_final\[9\] _00331_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[9\] sky130_fd_sc_hd__dfrtp_1
X_08030_ _01113_ _01115_ _01109_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__a21o_1
Xinput30 i_a[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
Xinput52 i_b[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
Xinput63 i_b[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
Xinput41 i_b[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09981_ _03041_ _03060_ _03066_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__o21ai_4
XFILLER_131_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08932_ _02017_ _01891_ _01893_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__nor3_1
XFILLER_97_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08863_ net133 _01868_ _01865_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__a21boi_4
XFILLER_123_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07814_ _00885_ _00890_ _00893_ _00770_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__a22oi_1
X_08794_ net2044 net2072 net1804 net1835 VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__and4_1
XFILLER_69_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07745_ _00720_ net991 _00722_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__a21o_4
X_09415_ _00970_ _02500_ net675 VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__nand3_1
X_07676_ net2045 net1751 VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__nand2_1
XFILLER_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09346_ _02427_ _02428_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__nand2_2
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09277_ _02357_ net464 net608 VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__nand3_1
XFILLER_21_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08228_ _01102_ _01104_ _01092_ net715 VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__o211ai_1
XFILLER_21_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08159_ net2238 net1685 VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__nand2_1
X_11170_ net1814 net2476 VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__nand2_1
XFILLER_122_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10121_ _03204_ _03205_ _02950_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__and3_4
X_10052_ _03129_ _03134_ _03137_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_128_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13811_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r _06783_ net1319 VGND VGND
+ VPWR VPWR _00104_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_3_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13742_ net160 _06604_ net154 VGND VGND VPWR VPWR _06751_ sky130_fd_sc_hd__or3_4
XFILLER_90_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10954_ _03965_ _03967_ _03974_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__and3_1
XFILLER_16_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13673_ _06688_ _06689_ _06410_ VGND VGND VPWR VPWR _06690_ sky130_fd_sc_hd__a21boi_1
X_10885_ _03922_ net798 VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__nand2_1
XFILLER_16_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12624_ _05693_ _05694_ _05704_ VGND VGND VPWR VPWR _05706_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_65_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12555_ _06932_ _05531_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__xor2_1
X_11506_ _04585_ _04587_ _04588_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__nand3_1
X_12486_ net3032 _05571_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__xnor2_4
X_14225_ net2890 VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__inv_2
XFILLER_137_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11437_ net641 _04025_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__nand2_1
XFILLER_140_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14156_ net2898 VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__inv_2
X_11368_ net1739 net2626 net2652 net1704 VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__a22o_1
X_13107_ net3264 net3303 _06087_ net3188 net789 VGND VGND VPWR VPWR _06137_ sky130_fd_sc_hd__a41oi_2
XFILLER_3_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10319_ _03388_ _03389_ _03386_ _03404_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__a31oi_2
X_14087_ net2840 VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__inv_2
X_11299_ _04378_ _04380_ _04381_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__nand3_2
X_13038_ _06064_ _06063_ _05715_ VGND VGND VPWR VPWR _06068_ sky130_fd_sc_hd__o21ai_4
Xfanout1150 _06899_ VGND VGND VPWR VPWR net1150 sky130_fd_sc_hd__buf_1
XFILLER_78_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1161 net1162 VGND VGND VPWR VPWR net1161 sky130_fd_sc_hd__buf_2
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1183 net1185 VGND VGND VPWR VPWR net1183 sky130_fd_sc_hd__clkbuf_4
XFILLER_94_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1194 net1195 VGND VGND VPWR VPWR net1194 sky130_fd_sc_hd__buf_1
X_07530_ net1533 net2185 VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__nand2_1
X_07461_ _00518_ _00519_ _00545_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_81_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07392_ net2110 net2133 net1534 net1567 VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__nand4_2
X_09200_ _02282_ _02283_ _02280_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__a21oi_1
XFILLER_22_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09131_ net691 net690 _01426_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_20_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer229 _07099_ VGND VGND VPWR VPWR net3147 sky130_fd_sc_hd__dlymetal6s4s_1
Xrebuffer218 net3135 VGND VGND VPWR VPWR net3136 sky130_fd_sc_hd__dlygate4sd1_1
X_09062_ _02141_ _02145_ _02146_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__nand3_2
Xrebuffer207 _05209_ VGND VGND VPWR VPWR net3125 sky130_fd_sc_hd__buf_2
XFILLER_135_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08013_ _01096_ _01097_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__nand2_1
XFILLER_116_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09964_ net2197 net2229 net1865 net1895 VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__nand4_2
XFILLER_112_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08915_ _01996_ _01997_ _01948_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__and3_1
X_09895_ _02738_ _02977_ _02980_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__nand3_1
X_08846_ _01745_ net3028 _01925_ _01928_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_123_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08777_ _01845_ net680 VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__nand2_2
XFILLER_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07728_ _00705_ _00706_ _00810_ _00813_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_123_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07659_ _00742_ _00743_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_105_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10670_ _03741_ net649 _03752_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__a21o_1
XFILLER_139_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09329_ _02409_ _02410_ _02395_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__a21oi_2
XFILLER_43_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12340_ _05423_ _05424_ _05414_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__nand3_2
X_12271_ _01013_ net2413 net1332 _01014_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__a31o_1
X_14010_ net2807 VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__inv_2
X_11222_ net1164 net1159 net961 net923 _04245_ VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_8_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11153_ _04225_ _04229_ _04235_ net174 VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__o211ai_1
X_11084_ _04168_ _04169_ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__nand2_4
X_10104_ _02930_ net663 _02936_ _02940_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__o2bb2ai_2
X_10035_ _03113_ _03119_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__nand2_1
XFILLER_84_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11986_ _05070_ _05071_ _05069_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__a21oi_1
X_13725_ _06321_ _06736_ VGND VGND VPWR VPWR adder_inst.sum_raw\[17\] sky130_fd_sc_hd__xor2_1
X_10937_ _03950_ _03954_ _04018_ _04022_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__o211ai_2
X_13656_ net172 net170 net169 _06663_ VGND VGND VPWR VPWR _06675_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_63_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12607_ net1280 net2007 net784 VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__a21oi_1
X_10868_ _03952_ _03953_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__nand2_1
XFILLER_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13587_ _06478_ _06507_ _06613_ _06615_ VGND VGND VPWR VPWR _06616_ sky130_fd_sc_hd__nor4_1
X_10799_ _03883_ net345 VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__nand2_1
X_12538_ _05491_ _05508_ _05507_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__o21bai_1
X_12469_ _02319_ _05554_ VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__xor2_4
XFILLER_132_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14208_ net2878 VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14139_ net2905 VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__inv_2
Xfanout409 _00979_ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__clkbuf_2
XFILLER_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08700_ _01588_ _01594_ _01591_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__a21o_1
X_09680_ _02678_ _02744_ _02763_ _02261_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_104_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08631_ _01714_ _01677_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__nand2_2
X_08562_ net2183 net1718 VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__nand2_1
XFILLER_70_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07513_ net2025 net1596 _00576_ net412 VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__a22o_1
X_08493_ _01577_ _01578_ VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__nor2_1
X_07444_ net719 _00522_ _00523_ _00527_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07375_ _00438_ _00459_ _00460_ _00439_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_33_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09114_ _02197_ _02198_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__nand2_1
XFILLER_135_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09045_ _02105_ _02122_ _02127_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__o21ai_1
XFILLER_135_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold452 adder_inst.exp_b\[4\] VGND VGND VPWR VPWR net3370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold463 adder_inst.i_a\[17\] VGND VGND VPWR VPWR net3381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold441 adder_inst.i_b\[16\] VGND VGND VPWR VPWR net3359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold430 adder_inst.i_a\[9\] VGND VGND VPWR VPWR net3348 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2609 net2613 VGND VGND VPWR VPWR net2609 sky130_fd_sc_hd__buf_1
Xhold496 multiplier_inst.man_final_r\[4\] VGND VGND VPWR VPWR net3414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold474 add_res\[17\] VGND VGND VPWR VPWR net3392 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold485 multiplier_inst.exp_final_r\[2\] VGND VGND VPWR VPWR net3403 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1908 net1909 VGND VGND VPWR VPWR net1908 sky130_fd_sc_hd__clkbuf_1
Xfanout932 net933 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__clkbuf_1
X_09947_ net2204 net1925 VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__and2_1
Xfanout921 net923 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__buf_4
Xfanout910 net912 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__clkbuf_4
Xfanout943 net944 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__clkbuf_2
Xfanout1919 net1921 VGND VGND VPWR VPWR net1919 sky130_fd_sc_hd__buf_2
XFILLER_98_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout954 net955 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__clkbuf_2
Xfanout965 _01098_ VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__buf_4
Xfanout976 net982 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__clkbuf_1
Xfanout998 _00551_ VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__buf_2
Xfanout987 net988 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__buf_6
X_09878_ net1046 net912 net1405 net2608 _02719_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_107_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08829_ _01910_ _01904_ _01828_ _01825_ net3082 VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__o221ai_4
XFILLER_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11840_ _04923_ _04925_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__nand2_1
X_11771_ _04710_ _04854_ _04856_ _04853_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__a2bb2o_1
X_13510_ _06538_ _06537_ _06129_ VGND VGND VPWR VPWR _06539_ sky130_fd_sc_hd__a21oi_1
X_10722_ net568 _03804_ _03807_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__a21oi_1
X_14490_ clknet_leaf_11_clk net3366 _00312_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13441_ net222 _06337_ net253 _06469_ VGND VGND VPWR VPWR _06470_ sky130_fd_sc_hd__o211ai_2
XFILLER_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10653_ _03530_ net880 net1179 net1175 VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_136_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13372_ net297 net360 _06363_ _06364_ VGND VGND VPWR VPWR _06401_ sky130_fd_sc_hd__o211ai_4
X_10584_ net346 _03668_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__nand2b_2
XFILLER_139_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload19 clknet_leaf_20_clk VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__clkinv_4
X_12323_ _05406_ _05408_ _05407_ VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_11_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12254_ _05333_ _05334_ _05335_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__nand3_2
X_11205_ _04285_ _04288_ net795 VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__a21boi_1
X_12185_ _05260_ _05270_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__nand2_1
XFILLER_110_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11136_ _03827_ _03853_ net205 net204 net385 VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__o2111ai_2
XFILLER_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11067_ _04151_ _04152_ VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__nor2_1
X_10018_ net1698 net1730 net2376 net2405 VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__nand4_2
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13708_ _06344_ _06706_ _06720_ _06358_ VGND VGND VPWR VPWR _06721_ sky130_fd_sc_hd__and4bb_1
X_11969_ net551 _05054_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__nor2_1
X_13639_ _06660_ _06659_ net766 _06657_ VGND VGND VPWR VPWR _06661_ sky130_fd_sc_hd__a31o_1
XFILLER_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07160_ net2013 net1285 _06925_ _06927_ VGND VGND VPWR VPWR _06931_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_30_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_1
Xfanout228 _06152_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_2
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09801_ _02686_ _02684_ _02687_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__a21oi_4
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_6
XFILLER_115_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07993_ net2040 net1948 VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__nand2_1
X_09732_ net2197 net1873 VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__nand2_1
X_09663_ _02666_ _02667_ _02664_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__a21oi_1
XFILLER_131_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08614_ net1263 net1254 net952 _01163_ _01164_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__o32a_1
X_09594_ _02674_ _02679_ _02678_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__o21ai_2
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08545_ _01172_ _01174_ _01171_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__a21boi_4
XFILLER_43_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08476_ net1418 net2472 VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__nand2_1
X_07427_ _00463_ _00509_ _00510_ _00512_ VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__a31o_1
XFILLER_11_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07358_ net1346 net2255 _00441_ _00442_ VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_118_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07289_ _07052_ _07055_ _07058_ _07059_ VGND VGND VPWR VPWR _07060_ sky130_fd_sc_hd__o211ai_2
XFILLER_136_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09028_ net2119 net2142 net1874 net1904 VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_131_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2417 net2418 VGND VGND VPWR VPWR net2417 sky130_fd_sc_hd__buf_1
Xfanout2406 net2407 VGND VGND VPWR VPWR net2406 sky130_fd_sc_hd__buf_1
Xfanout1705 net1706 VGND VGND VPWR VPWR net1705 sky130_fd_sc_hd__buf_1
Xfanout2439 net2444 VGND VGND VPWR VPWR net2439 sky130_fd_sc_hd__clkbuf_2
Xfanout2428 adder_inst.man_a_r\[9\] VGND VGND VPWR VPWR net2428 sky130_fd_sc_hd__buf_6
XFILLER_131_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout740 _05860_ VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__buf_1
Xfanout751 net753 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__buf_1
Xfanout1716 net1717 VGND VGND VPWR VPWR net1716 sky130_fd_sc_hd__clkbuf_1
Xfanout1749 net1753 VGND VGND VPWR VPWR net1749 sky130_fd_sc_hd__buf_2
Xfanout1738 net1740 VGND VGND VPWR VPWR net1738 sky130_fd_sc_hd__clkbuf_2
Xfanout1727 net1728 VGND VGND VPWR VPWR net1727 sky130_fd_sc_hd__clkbuf_1
XFILLER_93_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout762 net764 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__clkbuf_2
Xfanout773 net782 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__clkbuf_1
Xfanout784 _05686_ VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__clkbuf_1
X_13990_ net2828 VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__inv_2
X_12941_ _05984_ _05985_ net243 VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__o21a_1
Xfanout795 _04286_ VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__buf_4
XFILLER_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12872_ _05924_ _05925_ net240 VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__o21a_1
XFILLER_65_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_100 net1224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_111 net1910 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11823_ net794 _04906_ _04905_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__a21boi_1
X_14542_ clknet_leaf_0_clk _00103_ _00364_ VGND VGND VPWR VPWR mul_res\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_121_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11754_ _04838_ _04836_ _04837_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__a21oi_2
X_14473_ clknet_leaf_8_clk _00060_ _00295_ VGND VGND VPWR VPWR add_res\[31\] sky130_fd_sc_hd__dfrtp_1
X_11685_ net198 _04606_ _04553_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__a21o_1
X_10705_ _03786_ _03787_ net647 VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__o21a_1
X_13424_ net275 _06170_ _06171_ net290 VGND VGND VPWR VPWR _06453_ sky130_fd_sc_hd__o211ai_2
X_10636_ _03715_ _03717_ net650 VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__o21a_4
XFILLER_139_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13355_ _06382_ _06383_ VGND VGND VPWR VPWR _06384_ sky130_fd_sc_hd__nand2_1
XFILLER_6_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10567_ _03644_ _03647_ net571 _03611_ net427 VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__o2111ai_2
X_12306_ _05349_ _05344_ _05389_ _05386_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__o211ai_1
X_13286_ _06311_ _06314_ VGND VGND VPWR VPWR _06315_ sky130_fd_sc_hd__nand2_4
Xrebuffer390 _06521_ VGND VGND VPWR VPWR net3308 sky130_fd_sc_hd__buf_6
X_10498_ _03572_ _03574_ _03580_ _03571_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__o31a_1
X_12237_ _05322_ net165 _03483_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_75_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12168_ net3155 _05136_ _05248_ net3151 _05143_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__o221ai_2
XFILLER_77_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11119_ _03817_ _03820_ _03862_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__o21ai_2
X_12099_ _05182_ _05181_ _05180_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__a21o_1
XFILLER_83_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput6 i_a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_64_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08330_ _01412_ _01403_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__nand2_1
X_08261_ net2290 net1712 VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__nand2_1
X_07212_ net1041 _06972_ _06981_ _06982_ VGND VGND VPWR VPWR _06983_ sky130_fd_sc_hd__a211o_1
X_08192_ _01195_ _01272_ _01274_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__nand3_4
X_07143_ net2762 VGND VGND VPWR VPWR _06915_ sky130_fd_sc_hd__inv_2
XFILLER_118_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07976_ _01046_ _01050_ _01049_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__a21boi_2
X_09715_ net2149 net1946 net1976 net2129 VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__a22oi_4
XFILLER_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09646_ net671 net668 _02714_ net811 VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__a211oi_4
XFILLER_83_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09577_ _02619_ _02661_ _02620_ _02613_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08528_ net471 net470 _01582_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__a21o_1
X_08459_ _01544_ _01492_ _01543_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_13_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_133_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11470_ _04452_ _04555_ _04553_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__a21o_1
XFILLER_137_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10421_ net2269 net2295 net1866 net1896 VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__nand4_1
XFILLER_136_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13140_ net1840 net499 _06168_ VGND VGND VPWR VPWR _06170_ sky130_fd_sc_hd__o21ai_1
X_10352_ net389 VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__inv_2
X_13071_ net860 net706 _05683_ VGND VGND VPWR VPWR _06101_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2214 net2217 VGND VGND VPWR VPWR net2214 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_57_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2203 net2210 VGND VGND VPWR VPWR net2203 sky130_fd_sc_hd__buf_1
XFILLER_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10283_ net3037 _03324_ _03325_ net348 _03367_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__a32oi_4
X_12022_ net3243 net618 net617 _05106_ VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__o211ai_4
Xfanout2247 net2248 VGND VGND VPWR VPWR net2247 sky130_fd_sc_hd__buf_1
Xfanout2236 net2238 VGND VGND VPWR VPWR net2236 sky130_fd_sc_hd__clkbuf_2
Xfanout1502 net1506 VGND VGND VPWR VPWR net1502 sky130_fd_sc_hd__buf_1
Xfanout1513 net1514 VGND VGND VPWR VPWR net1513 sky130_fd_sc_hd__clkbuf_2
Xfanout1524 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net1524 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1535 net1538 VGND VGND VPWR VPWR net1535 sky130_fd_sc_hd__buf_1
Xfanout1557 net1562 VGND VGND VPWR VPWR net1557 sky130_fd_sc_hd__buf_1
Xfanout2269 net2270 VGND VGND VPWR VPWR net2269 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1546 net1547 VGND VGND VPWR VPWR net1546 sky130_fd_sc_hd__buf_1
Xfanout1568 net1569 VGND VGND VPWR VPWR net1568 sky130_fd_sc_hd__clkbuf_2
Xfanout592 _01382_ VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__buf_4
XFILLER_65_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13973_ net2830 VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__inv_2
Xfanout1579 net1586 VGND VGND VPWR VPWR net1579 sky130_fd_sc_hd__clkbuf_2
Xfanout581 _03131_ VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__buf_4
Xfanout570 _03729_ VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__buf_6
X_12924_ net1059 adder_inst.sum_raw_r\[14\] net2758 net739 net844 VGND VGND VPWR VPWR
+ _05971_ sky130_fd_sc_hd__o221a_1
XFILLER_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12855_ net2778 net2702 net835 _05910_ VGND VGND VPWR VPWR _05911_ sky130_fd_sc_hd__a211o_1
X_12786_ _05792_ _05797_ net2686 VGND VGND VPWR VPWR _05848_ sky130_fd_sc_hd__o21ai_1
XFILLER_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11806_ _04764_ _04762_ _04765_ VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__a21o_1
XFILLER_15_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14525_ clknet_leaf_3_clk multiplier_inst.exp_final\[2\] _00347_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
X_11737_ _04817_ _04821_ _04818_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__a21oi_2
XFILLER_30_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14456_ clknet_leaf_4_clk _00041_ _00278_ VGND VGND VPWR VPWR add_res\[14\] sky130_fd_sc_hd__dfrtp_1
X_11668_ _04740_ net449 net553 VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__nand3_1
X_13407_ net370 _06315_ net227 _06435_ VGND VGND VPWR VPWR _06436_ sky130_fd_sc_hd__o31a_1
X_10619_ _03700_ _03704_ _03702_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__nand3_2
X_11599_ net1891 net2516 net1919 net2482 VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__a22oi_4
X_14387_ clknet_leaf_18_clk net3340 _00209_ VGND VGND VPWR VPWR adder_inst.man_a_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_128_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13338_ net297 net360 _06330_ _06331_ VGND VGND VPWR VPWR _06367_ sky130_fd_sc_hd__o211ai_1
XFILLER_115_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13269_ net379 net310 net225 net193 VGND VGND VPWR VPWR _06298_ sky130_fd_sc_hd__or4_2
XFILLER_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07830_ _00915_ _00822_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__nand2_1
Xfanout2770 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR net2770 sky130_fd_sc_hd__buf_1
Xfanout2781 adder_inst.sum_raw_r\[3\] VGND VGND VPWR VPWR net2781 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2792 net2793 VGND VGND VPWR VPWR net2792 sky130_fd_sc_hd__clkbuf_2
X_07761_ _00825_ _00829_ _00833_ _00834_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09500_ _02105_ _02123_ _02581_ _02580_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__o211ai_4
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07692_ _00761_ _00771_ _00777_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__a21oi_4
XFILLER_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09431_ _02493_ _02495_ net328 _02514_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__o2bb2ai_4
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09362_ _02325_ _02329_ _02327_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__a21oi_2
XFILLER_80_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08313_ net1577 net2402 VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__nand2_1
XFILLER_33_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09293_ net1414 net2382 VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__nand2_1
XANTENNA_11 adder_inst.man_a_r\[20\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_22 net899 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_44 net1377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08244_ _01329_ _01324_ _01328_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__nand3_2
XANTENNA_55 net1692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_33 net1154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_66 net2488 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_99 net1203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08175_ net824 net823 net695 net609 VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__and4_1
XANTENNA_77 net2635 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_88 adder_inst.man_a_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07126_ net1887 VGND VGND VPWR VPWR _06898_ sky130_fd_sc_hd__inv_2
XFILLER_134_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07959_ _00913_ _00916_ _01042_ _01044_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__o211ai_2
XFILLER_75_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10970_ _04050_ _04051_ _04053_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__nand3_2
X_09629_ _02713_ net2663 net1330 _02711_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__and4_1
XFILLER_43_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12640_ _05717_ _05718_ _05719_ VGND VGND VPWR VPWR _05720_ sky130_fd_sc_hd__and3_1
XFILLER_12_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12571_ net2007 net1279 VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__nand2b_4
X_14310_ clknet_leaf_11_clk net17 _00132_ VGND VGND VPWR VPWR adder_inst.exp_a\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_12_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11522_ _04558_ _04601_ _04602_ net198 _04554_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__a32oi_2
X_14241_ net2859 VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__inv_2
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11453_ _04534_ _04521_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__nand2_2
XFILLER_109_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14172_ net2842 VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__inv_2
X_10404_ net2208 net2250 net1945 net1970 VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__nand4_2
X_13123_ net313 _06082_ net377 VGND VGND VPWR VPWR _06153_ sky130_fd_sc_hd__and3_1
X_11384_ _04280_ _04281_ _04343_ net451 VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__a22o_1
Xfanout2000 net3208 VGND VGND VPWR VPWR net2000 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_55_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10335_ _03416_ _03417_ net885 VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__a21oi_2
XFILLER_140_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2022 net2026 VGND VGND VPWR VPWR net2022 sky130_fd_sc_hd__clkbuf_1
Xfanout2033 net2034 VGND VGND VPWR VPWR net2033 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_87_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2011 adder_inst.exp_a_r\[1\] VGND VGND VPWR VPWR net2011 sky130_fd_sc_hd__clkbuf_2
X_13054_ net506 _06083_ VGND VGND VPWR VPWR _06084_ sky130_fd_sc_hd__nand2_1
X_10266_ net711 net656 _03311_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__a21o_1
Xfanout1332 net1334 VGND VGND VPWR VPWR net1332 sky130_fd_sc_hd__clkbuf_2
Xfanout1310 net3323 VGND VGND VPWR VPWR net1310 sky130_fd_sc_hd__buf_1
Xfanout1321 net1323 VGND VGND VPWR VPWR net1321 sky130_fd_sc_hd__buf_1
Xfanout2077 net2078 VGND VGND VPWR VPWR net2077 sky130_fd_sc_hd__buf_2
Xfanout2055 net2060 VGND VGND VPWR VPWR net2055 sky130_fd_sc_hd__clkbuf_2
XFILLER_87_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2066 net2068 VGND VGND VPWR VPWR net2066 sky130_fd_sc_hd__clkbuf_2
Xfanout2044 net2053 VGND VGND VPWR VPWR net2044 sky130_fd_sc_hd__buf_4
X_12005_ _05086_ _05087_ _05084_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__nand3_1
XFILLER_120_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1365 net1366 VGND VGND VPWR VPWR net1365 sky130_fd_sc_hd__buf_1
Xfanout1343 net1345 VGND VGND VPWR VPWR net1343 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2099 net2103 VGND VGND VPWR VPWR net2099 sky130_fd_sc_hd__buf_1
X_10197_ net888 net805 _03275_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__a21o_1
Xfanout1354 net1355 VGND VGND VPWR VPWR net1354 sky130_fd_sc_hd__clkbuf_2
Xfanout1387 net1388 VGND VGND VPWR VPWR net1387 sky130_fd_sc_hd__buf_1
Xfanout1398 net1399 VGND VGND VPWR VPWR net1398 sky130_fd_sc_hd__clkbuf_2
Xfanout1376 net1377 VGND VGND VPWR VPWR net1376 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13956_ add_res\[20\] net3416 net2799 VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__mux2_1
XFILLER_93_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13887_ _05584_ net131 _05578_ VGND VGND VPWR VPWR _06842_ sky130_fd_sc_hd__o21ai_2
X_12907_ net2765 net2712 net2703 net1064 VGND VGND VPWR VPWR _05956_ sky130_fd_sc_hd__or4_1
X_12838_ net1083 net2779 net2781 net751 VGND VGND VPWR VPWR _05897_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_83_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12769_ net1287 _05817_ net838 adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR _05831_
+ sky130_fd_sc_hd__a211oi_1
X_14508_ clknet_leaf_0_clk multiplier_inst.man_final\[8\] _00330_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[8\] sky130_fd_sc_hd__dfrtp_1
X_14439_ clknet_leaf_7_clk net3334 _00261_ VGND VGND VPWR VPWR adder_inst.sign_b_r
+ sky130_fd_sc_hd__dfrtp_1
Xinput20 i_a[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 i_a[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
Xinput53 i_b[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
Xinput42 i_b[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
Xinput64 i_b[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
X_09980_ _02815_ net667 _02826_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__a21o_1
XFILLER_131_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08931_ net712 _02013_ _02016_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__o21ai_1
X_08862_ net2957 _01947_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__nand2_1
X_07813_ net1014 net1001 net2155 net1594 _00711_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__o2111ai_4
XFILLER_84_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08793_ _01876_ _01877_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__nand2_2
X_07744_ _00828_ _00825_ _00827_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__o21a_1
XFILLER_84_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07675_ _00663_ _00760_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__nor2_4
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09414_ _02497_ _00968_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__nand2_1
X_09345_ _02423_ _02430_ _02429_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_23_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09276_ _02357_ net464 net608 VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_23_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08227_ _01092_ net715 _01102_ _01104_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_119_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08158_ net1229 net1214 VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__nor2_1
XFILLER_107_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08089_ _01171_ _01172_ _01173_ _01143_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__o2bb2ai_4
X_07109_ net2129 VGND VGND VPWR VPWR _06881_ sky130_fd_sc_hd__inv_2
X_10120_ _03204_ _03205_ _02950_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__a21oi_2
XFILLER_121_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10051_ net581 _03130_ _03120_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__a21o_1
XFILLER_130_782 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13810_ multiplier_inst.is_zero_r multiplier_inst.overflow_calc_r VGND VGND VPWR
+ VPWR _06783_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_3_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_763 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13741_ _06291_ _06744_ _06737_ _06602_ _06292_ VGND VGND VPWR VPWR _06750_ sky130_fd_sc_hd__o221ai_4
X_10953_ net641 _04037_ _04025_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__a21boi_2
XFILLER_29_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13672_ _06409_ _06682_ VGND VGND VPWR VPWR _06689_ sky130_fd_sc_hd__nor2_1
X_10884_ net874 net798 _03921_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__and3_1
X_12623_ _05702_ net444 _05701_ _05696_ VGND VGND VPWR VPWR _05705_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_65_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12554_ _05533_ net110 net103 net108 VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__nand4b_4
XFILLER_129_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11505_ _04586_ _04589_ _04590_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__nand3_4
XFILLER_8_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14224_ net2890 VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__inv_2
X_12485_ _02319_ _05554_ net3103 VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__o21ai_2
XFILLER_125_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11436_ _04329_ _04335_ _04327_ _04334_ VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__a2bb2oi_2
X_14155_ net2898 VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__inv_2
X_11367_ net1738 net2626 net2646 net1704 VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__a22oi_4
XFILLER_140_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14086_ net2866 VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__inv_2
X_13106_ net378 net374 net365 net3204 net415 VGND VGND VPWR VPWR _06136_ sky130_fd_sc_hd__o2111ai_4
X_10318_ net1110 net1102 net1015 _03397_ _03401_ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__o32a_4
XFILLER_112_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13037_ _06063_ _06064_ _06060_ _06059_ VGND VGND VPWR VPWR _06067_ sky130_fd_sc_hd__a2bb2o_1
X_11298_ _04378_ _04381_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__nand2_1
XFILLER_78_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10249_ net1696 net1728 net2405 net2435 VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__nand4_4
XFILLER_121_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1162 net1166 VGND VGND VPWR VPWR net1162 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1173 net1178 VGND VGND VPWR VPWR net1173 sky130_fd_sc_hd__clkbuf_4
Xfanout1151 net1153 VGND VGND VPWR VPWR net1151 sky130_fd_sc_hd__clkbuf_2
Xfanout1195 net1196 VGND VGND VPWR VPWR net1195 sky130_fd_sc_hd__clkbuf_2
Xfanout1184 net1185 VGND VGND VPWR VPWR net1184 sky130_fd_sc_hd__buf_1
XFILLER_94_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13939_ add_res\[3\] net3448 net2792 VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__mux2_1
X_07460_ _00520_ _00530_ _00544_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__nand3_2
X_07391_ net2110 net2132 net1033 VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__and3_1
X_09130_ net691 net690 _01426_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__nand3_1
Xclkbuf_leaf_14_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_20_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09061_ _02143_ _02144_ net2959 VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__a21oi_1
Xrebuffer219 _03428_ VGND VGND VPWR VPWR net3137 sky130_fd_sc_hd__buf_6
Xrebuffer208 _05098_ VGND VGND VPWR VPWR net3126 sky130_fd_sc_hd__buf_1
X_08012_ net2065 net2093 net1876 net1906 VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_7_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09963_ net2259 net1842 VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08914_ _01998_ _01949_ _01999_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__nand3_4
XFILLER_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09894_ _02708_ _02709_ _02734_ _02736_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08845_ _01745_ _01924_ _01925_ _01928_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__a31oi_2
X_08776_ net680 _01844_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__nand2_1
XFILLER_73_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07727_ _00811_ _00812_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__nor2_1
XFILLER_85_699 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07658_ _00743_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__inv_2
X_07589_ _00566_ _00567_ _00673_ VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_105_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09328_ _01976_ _02406_ _02405_ _02403_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__o211ai_1
XFILLER_9_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_138_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09259_ net1203 _00952_ net2122 _00955_ net1684 VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__o2111ai_2
XFILLER_138_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12270_ _01043_ _05351_ _05352_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__nand3_1
XFILLER_111_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11221_ _04299_ _04301_ _04290_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__nand3_1
XFILLER_107_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11152_ net173 net3036 _04230_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_8_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10103_ _02934_ _02939_ _02930_ net663 VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__o211ai_2
XFILLER_49_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11083_ _03765_ _03768_ _03770_ _03810_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__o211ai_4
XFILLER_103_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10034_ _03113_ _03119_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__and2_4
XFILLER_91_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11985_ _04981_ _04982_ net552 VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__nand3_1
X_13724_ _06732_ net761 _06733_ _06735_ VGND VGND VPWR VPWR _06736_ sky130_fd_sc_hd__a31o_1
X_10936_ _03951_ _03952_ _03953_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__a21o_1
X_13655_ _06580_ _06674_ VGND VGND VPWR VPWR adder_inst.sum_raw\[9\] sky130_fd_sc_hd__xor2_2
X_10867_ net2326 net1934 VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__nand2_1
X_12606_ net783 net2008 net1279 VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__and3_1
XFILLER_31_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13586_ _06534_ _06560_ VGND VGND VPWR VPWR _06615_ sky130_fd_sc_hd__nand2_4
X_10798_ _03675_ _03678_ _03682_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__o21ai_4
XFILLER_40_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12537_ _05491_ _05509_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__xnor2_2
X_12468_ _02791_ _03477_ _05547_ _03024_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14207_ net2910 VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11419_ _04500_ _04501_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__nand2_1
X_14138_ net2892 VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__inv_2
XFILLER_125_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12399_ _05482_ _05484_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__nor2_1
XFILLER_140_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_3_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_91_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14069_ net2825 VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__inv_2
XFILLER_79_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08630_ _01672_ _01673_ _01712_ net469 VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__a22o_2
XFILLER_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08561_ net2211 net1685 VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__nand2_1
XFILLER_54_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07512_ _00596_ _00597_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__nand2_1
XFILLER_120_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08492_ _01576_ net2562 net1331 _01575_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__and4_1
X_07443_ net719 _00522_ _00528_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__a21oi_1
X_07374_ _00454_ _00456_ _00445_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__o21ai_1
X_09113_ _02198_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__inv_2
XFILLER_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09044_ _02129_ _02124_ _02128_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__nand3_2
XFILLER_135_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold420 adder_inst.i_b\[10\] VGND VGND VPWR VPWR net3338 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold453 adder_inst.exp_b\[2\] VGND VGND VPWR VPWR net3371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold431 adder_inst.i_a\[3\] VGND VGND VPWR VPWR net3349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold442 adder_inst.i_b\[20\] VGND VGND VPWR VPWR net3360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold486 multiplier_inst.man_final_r\[0\] VGND VGND VPWR VPWR net3404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold475 _00008_ VGND VGND VPWR VPWR net3393 sky130_fd_sc_hd__dlygate4sd3_1
Xhold464 adder_inst.exp_a\[2\] VGND VGND VPWR VPWR net3382 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout900 _02697_ VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_4
Xhold497 multiplier_inst.man_final_r\[17\] VGND VGND VPWR VPWR net3415 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1909 net1910 VGND VGND VPWR VPWR net1909 sky130_fd_sc_hd__buf_4
Xfanout922 net923 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__buf_1
Xfanout933 net934 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__buf_6
X_09946_ net2141 net2177 net1944 net1969 VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__nand4_2
Xfanout911 net912 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__buf_1
Xfanout966 _01098_ VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__buf_1
Xfanout955 net956 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__buf_1
Xfanout977 net979 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__buf_6
Xfanout944 net947 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__clkbuf_2
Xfanout988 net989 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__buf_4
Xfanout999 net1004 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__clkbuf_2
X_09877_ net1046 net912 net1405 net2608 _02719_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__o2111a_1
XFILLER_38_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08828_ _01826_ net1066 _01912_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08759_ _01837_ _01842_ _01840_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__a21oi_2
XFILLER_26_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11770_ net1765 net2653 VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__and2_1
XFILLER_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10721_ _03792_ net568 VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__nor2_1
X_13440_ net373 net303 net232 _06403_ _06468_ VGND VGND VPWR VPWR _06469_ sky130_fd_sc_hd__o221ai_2
X_10652_ _03530_ net880 net1762 net2418 VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__nand4_1
X_13371_ net263 _06208_ VGND VGND VPWR VPWR _06400_ sky130_fd_sc_hd__nand2_1
X_10583_ net346 _03668_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__and2b_1
X_12322_ _05393_ _05398_ _05396_ VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12253_ _05336_ _05337_ _05332_ VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__a21oi_1
XFILLER_135_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11204_ _04286_ _04289_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__nand2_1
XFILLER_123_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12184_ _05267_ net2679 net1919 _05268_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__a31o_1
XFILLER_122_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11135_ _04217_ net3043 VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__nand2_4
XFILLER_135_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11066_ _03839_ _03840_ _04150_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10017_ _03100_ _03101_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__nand2_1
XFILLER_76_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13707_ _06396_ _06690_ VGND VGND VPWR VPWR _06720_ sky130_fd_sc_hd__nand2_1
XFILLER_17_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11968_ net1203 net1096 _05052_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__o21a_1
X_11899_ _04890_ _04981_ _04983_ _04984_ VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__nand4_2
X_10919_ _04003_ net425 VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__nand2_1
XFILLER_32_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13638_ _06571_ _06658_ _06574_ net138 VGND VGND VPWR VPWR _06660_ sky130_fd_sc_hd__a211o_1
XFILLER_13_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13569_ net2167 net494 _06300_ VGND VGND VPWR VPWR _06598_ sky130_fd_sc_hd__o21ai_2
XFILLER_74_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout218 net219 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_1
XFILLER_86_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout229 net231 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_4
X_07992_ net2041 net1973 VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__nand2_4
X_09800_ _02684_ _02686_ _02687_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__and3_1
X_09731_ net2171 net1903 VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__nand2_1
XFILLER_140_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09662_ _02612_ _02618_ _02662_ _02670_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__o211ai_2
XFILLER_131_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08613_ _01165_ net1774 net2145 VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__and3_1
X_09593_ _02630_ _02659_ _02675_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_120_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08544_ _01171_ _01629_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08475_ _01495_ _01498_ _01497_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__o21ai_2
XFILLER_23_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07426_ _00511_ _00462_ VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__nand2_1
X_07357_ _00442_ net2255 net1339 _00441_ VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__nand4_1
XFILLER_136_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07288_ _07020_ _07057_ VGND VGND VPWR VPWR _07059_ sky130_fd_sc_hd__nand2_1
XFILLER_108_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09027_ _02110_ _02111_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_131_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2407 net2408 VGND VGND VPWR VPWR net2407 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1706 net1707 VGND VGND VPWR VPWR net1706 sky130_fd_sc_hd__clkbuf_1
Xfanout2418 net2427 VGND VGND VPWR VPWR net2418 sky130_fd_sc_hd__clkbuf_2
Xfanout741 _05859_ VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1717 net1722 VGND VGND VPWR VPWR net1717 sky130_fd_sc_hd__buf_1
Xfanout730 _06072_ VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1739 net1740 VGND VGND VPWR VPWR net1739 sky130_fd_sc_hd__clkbuf_1
Xfanout1728 net1734 VGND VGND VPWR VPWR net1728 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout752 net753 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__clkbuf_1
XFILLER_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout763 net764 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__clkbuf_1
Xfanout774 net778 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlymetal6s2s_1
X_09929_ net182 _03012_ net181 VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__a21boi_1
Xfanout785 _05530_ VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__buf_2
X_12940_ net2692 net2743 net758 net2749 VGND VGND VPWR VPWR _05985_ sky130_fd_sc_hd__a22o_1
Xfanout796 _04105_ VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlymetal6s2s_1
X_12871_ net2689 net2767 net2769 net754 VGND VGND VPWR VPWR _05925_ sky130_fd_sc_hd__a22o_1
XFILLER_105_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_101 net1268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_112 net1959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11822_ _04906_ net794 _04816_ _04904_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__o2bb2ai_2
X_14541_ clknet_leaf_0_clk _00102_ _00363_ VGND VGND VPWR VPWR mul_res\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_121_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11753_ _04836_ net2569 net1858 _04834_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__and4_1
X_14472_ clknet_leaf_7_clk _00059_ _00294_ VGND VGND VPWR VPWR add_res\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_81_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11684_ _04606_ net198 VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__nand2_1
XFILLER_14_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10704_ _03788_ _03789_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__nor2_1
X_13423_ net211 net227 net371 VGND VGND VPWR VPWR _06452_ sky130_fd_sc_hd__and3_1
X_10635_ _03716_ _03718_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__nand2_1
XFILLER_41_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13354_ net370 _06258_ net255 VGND VGND VPWR VPWR _06383_ sky130_fd_sc_hd__o21a_1
X_12305_ _05390_ _05385_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__nand2_1
XFILLER_10_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10566_ _03611_ net428 _03649_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__and3_1
XFILLER_142_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13285_ net3189 net339 _06244_ net288 _06313_ VGND VGND VPWR VPWR _06314_ sky130_fd_sc_hd__o221ai_4
Xrebuffer380 net3297 VGND VGND VPWR VPWR net3298 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer391 net274 VGND VGND VPWR VPWR net3309 sky130_fd_sc_hd__buf_6
X_10497_ _03566_ _03569_ _03577_ _03581_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__o211ai_2
XFILLER_142_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12236_ _02320_ _02545_ _03023_ _05321_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_75_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12167_ _05252_ _05249_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__nand2_1
XFILLER_123_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11118_ _04190_ _04191_ _04170_ net2958 VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__a22oi_1
XFILLER_96_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12098_ _05181_ _05182_ _05180_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__a21oi_2
XFILLER_77_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput7 i_a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_11049_ _04006_ _04007_ _04132_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08260_ net472 _01339_ _01341_ _01342_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__nand4_4
XFILLER_20_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07211_ net2058 net1423 net1454 net2034 VGND VGND VPWR VPWR _06982_ sky130_fd_sc_hd__a22oi_2
X_08191_ _01232_ _01265_ net474 VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__and3_1
X_07142_ net2763 VGND VGND VPWR VPWR _06914_ sky130_fd_sc_hd__inv_2
XFILLER_133_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07975_ net2985 _01055_ _01057_ _01058_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__nand4_2
XFILLER_87_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09714_ net2149 net1946 VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__nand2_1
XFILLER_67_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09645_ _02714_ net811 net670 net669 VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__o211ai_1
XFILLER_27_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09576_ _02658_ _02660_ net397 VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__o21ai_1
X_08527_ net471 net470 _01582_ VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__a21oi_4
XFILLER_23_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08458_ _01513_ _01514_ _01541_ _01542_ VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_13_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07409_ _00493_ _00488_ _00452_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_133_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08389_ _01458_ _01460_ _01470_ _01471_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__nand4_2
X_10420_ net2295 net1866 VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__nand2_1
XFILLER_136_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10351_ _03436_ _03433_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__nand2_2
X_13070_ _06095_ _06096_ _05716_ VGND VGND VPWR VPWR _06100_ sky130_fd_sc_hd__nand3_4
X_10282_ _03359_ _03362_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__nand2_2
Xfanout2215 net2216 VGND VGND VPWR VPWR net2215 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_57_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2204 net2205 VGND VGND VPWR VPWR net2204 sky130_fd_sc_hd__buf_6
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12021_ _05074_ _05015_ net617 VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__a21boi_1
Xfanout2237 net2238 VGND VGND VPWR VPWR net2237 sky130_fd_sc_hd__buf_1
Xfanout1503 net1505 VGND VGND VPWR VPWR net1503 sky130_fd_sc_hd__buf_1
Xfanout1514 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net1514 sky130_fd_sc_hd__clkbuf_2
Xfanout2259 net2261 VGND VGND VPWR VPWR net2259 sky130_fd_sc_hd__clkbuf_2
Xfanout2248 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net2248 sky130_fd_sc_hd__buf_6
XFILLER_116_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1536 net1538 VGND VGND VPWR VPWR net1536 sky130_fd_sc_hd__clkbuf_2
Xfanout1525 net1526 VGND VGND VPWR VPWR net1525 sky130_fd_sc_hd__buf_4
Xfanout560 _04124_ VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__buf_1
Xfanout1547 net1548 VGND VGND VPWR VPWR net1547 sky130_fd_sc_hd__buf_6
Xfanout1558 net1559 VGND VGND VPWR VPWR net1558 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_70_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout593 _01382_ VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1569 net2962 VGND VGND VPWR VPWR net1569 sky130_fd_sc_hd__buf_1
X_13972_ net2836 VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__inv_2
Xfanout571 _03645_ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__buf_6
Xfanout582 _03131_ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__clkbuf_1
X_12923_ net2764 net2733 _05969_ _05968_ net834 VGND VGND VPWR VPWR _05970_ sky130_fd_sc_hd__a221o_1
XFILLER_19_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12854_ net2779 net741 _05908_ _05845_ _05909_ VGND VGND VPWR VPWR _05910_ sky130_fd_sc_hd__a221o_1
XFILLER_15_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12785_ net2724 net1310 _05845_ net836 VGND VGND VPWR VPWR _05847_ sky130_fd_sc_hd__a31o_1
X_11805_ _04889_ _04890_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__nand2_2
X_14524_ clknet_leaf_9_clk multiplier_inst.exp_final\[1\] _00346_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_11736_ _04817_ _04821_ _04818_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__a21o_1
XFILLER_30_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14455_ clknet_leaf_4_clk _00040_ _00277_ VGND VGND VPWR VPWR add_res\[13\] sky130_fd_sc_hd__dfrtp_1
X_11667_ _04740_ net448 net554 VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__and3_1
X_13406_ _06433_ _06434_ _06156_ VGND VGND VPWR VPWR _06435_ sky130_fd_sc_hd__a21o_1
X_10618_ net994 net926 net2266 net1927 _03487_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__o2111ai_1
X_11598_ net2481 net1885 net2519 net1914 VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__nand4_1
X_14386_ clknet_leaf_18_clk net3357 _00208_ VGND VGND VPWR VPWR adder_inst.man_a_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_13337_ _06364_ net305 _06363_ net413 VGND VGND VPWR VPWR _06366_ sky130_fd_sc_hd__nand4_1
X_10549_ _03616_ _03613_ net879 _03632_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__o211ai_2
XFILLER_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13268_ net295 _06295_ _06296_ VGND VGND VPWR VPWR _06297_ sky130_fd_sc_hd__o21a_1
XFILLER_130_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13199_ net1771 net2454 net484 VGND VGND VPWR VPWR _06229_ sky130_fd_sc_hd__mux2_1
X_12219_ _04895_ _05304_ VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__xnor2_2
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2771 net2772 VGND VGND VPWR VPWR net2771 sky130_fd_sc_hd__buf_1
Xfanout2793 net2796 VGND VGND VPWR VPWR net2793 sky130_fd_sc_hd__buf_1
Xfanout2782 adder_inst.sum_raw_r\[3\] VGND VGND VPWR VPWR net2782 sky130_fd_sc_hd__buf_1
X_07760_ net1030 _00643_ _00843_ _00839_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_88_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_16_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09430_ _02493_ _02495_ _02513_ _02515_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__nand4_4
X_07691_ _00775_ _00776_ _00772_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__and3_1
XFILLER_64_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09361_ net191 _02446_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__nand2_1
XFILLER_52_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09292_ _02376_ net815 VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__nand2_1
X_08312_ net1616 net1651 net2347 net2373 VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__nand4_4
XANTENNA_12 adder_inst.man_b_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08243_ _01127_ _01130_ _01132_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_23 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_45 net1390 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_34 net1160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_56 net1811 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08174_ net610 _01256_ _01241_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__a21o_1
XANTENNA_89 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_78 net2645 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_67 net2490 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07125_ net1863 VGND VGND VPWR VPWR _06897_ sky130_fd_sc_hd__inv_2
XFILLER_88_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_110_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07958_ _00822_ _00911_ _00912_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__nand3b_4
XFILLER_102_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07889_ _00874_ _00875_ net596 _00857_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__o211ai_1
XFILLER_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09628_ net1330 net2663 _02711_ _02713_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__a22oi_4
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09559_ _02633_ _02634_ _02643_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__nand3_1
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12570_ net1279 net2007 VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__nand2b_4
XFILLER_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11521_ _04557_ _04605_ _04603_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__nand3_2
X_14240_ net2911 VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__inv_2
XFILLER_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11452_ _04519_ _04520_ net558 _04533_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__o211ai_4
X_14171_ net2841 VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_59_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10403_ net2205 net2249 net1945 net1970 VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__and4_1
X_11383_ _04278_ _04279_ _04343_ net451 VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__o211ai_1
XFILLER_109_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13122_ net3179 net3184 net310 VGND VGND VPWR VPWR _06152_ sky130_fd_sc_hd__a21o_1
X_10334_ _03416_ _03417_ net885 VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__and3_1
Xfanout2001 net2002 VGND VGND VPWR VPWR net2001 sky130_fd_sc_hd__buf_1
XFILLER_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2034 net2035 VGND VGND VPWR VPWR net2034 sky130_fd_sc_hd__clkbuf_2
Xfanout2023 net2025 VGND VGND VPWR VPWR net2023 sky130_fd_sc_hd__clkbuf_2
Xfanout2012 adder_inst.exp_a_r\[1\] VGND VGND VPWR VPWR net2012 sky130_fd_sc_hd__clkbuf_1
X_13053_ _05645_ _06056_ _05644_ VGND VGND VPWR VPWR _06083_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_52_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10265_ net655 _03349_ net654 VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__a21boi_2
XFILLER_133_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1322 net1323 VGND VGND VPWR VPWR net1322 sky130_fd_sc_hd__clkbuf_1
Xfanout1300 net1301 VGND VGND VPWR VPWR net1300 sky130_fd_sc_hd__buf_1
Xfanout2056 net2059 VGND VGND VPWR VPWR net2056 sky130_fd_sc_hd__buf_1
Xfanout2045 net2047 VGND VGND VPWR VPWR net2045 sky130_fd_sc_hd__buf_1
Xfanout2067 net2068 VGND VGND VPWR VPWR net2067 sky130_fd_sc_hd__buf_1
X_10196_ net888 net804 _03275_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__a21oi_2
X_12004_ _05088_ _05089_ _05085_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__a21oi_4
XFILLER_120_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1333 net1334 VGND VGND VPWR VPWR net1333 sky130_fd_sc_hd__buf_1
Xfanout1366 net1376 VGND VGND VPWR VPWR net1366 sky130_fd_sc_hd__clkbuf_2
Xfanout1344 net1345 VGND VGND VPWR VPWR net1344 sky130_fd_sc_hd__buf_1
Xfanout2078 adder_inst.man_a_r\[21\] VGND VGND VPWR VPWR net2078 sky130_fd_sc_hd__clkbuf_2
Xfanout2089 net2091 VGND VGND VPWR VPWR net2089 sky130_fd_sc_hd__buf_6
Xfanout1355 net1356 VGND VGND VPWR VPWR net1355 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_120_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1388 net1389 VGND VGND VPWR VPWR net1388 sky130_fd_sc_hd__buf_1
Xfanout1399 net1400 VGND VGND VPWR VPWR net1399 sky130_fd_sc_hd__clkbuf_1
Xfanout1377 net1378 VGND VGND VPWR VPWR net1377 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13955_ net3396 mul_res\[19\] net2799 VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__mux2_1
X_13886_ _05564_ _05574_ _05561_ _06841_ VGND VGND VPWR VPWR multiplier_inst.man_final\[7\]
+ sky130_fd_sc_hd__o31a_1
X_12906_ net2768 net2729 net833 _05954_ VGND VGND VPWR VPWR _05955_ sky130_fd_sc_hd__a211o_1
XFILLER_19_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12837_ net2787 net2714 _05843_ _05895_ VGND VGND VPWR VPWR _05896_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_83_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12768_ _06922_ _05815_ _05829_ VGND VGND VPWR VPWR _05830_ sky130_fd_sc_hd__a21o_1
X_14507_ clknet_leaf_20_clk multiplier_inst.man_final\[7\] _00329_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
X_12699_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] adder_inst.exp_b\[3\] adder_inst.exp_b\[2\]
+ VGND VGND VPWR VPWR _05769_ sky130_fd_sc_hd__and4_1
X_11719_ net2991 _04803_ _04801_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__o21ai_1
X_14438_ clknet_leaf_7_clk _00068_ _00260_ VGND VGND VPWR VPWR add_ovf sky130_fd_sc_hd__dfrtp_1
Xinput21 i_a[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput10 i_a[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput54 i_b[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput32 i_a[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xinput43 i_b[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput65 i_vld VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_14369_ clknet_leaf_2_clk adder_inst.sum_raw\[18\] _00191_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08930_ _01878_ _01875_ _02012_ net712 net906 VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__o221ai_1
X_08861_ _01866_ _01868_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__nand2_1
XFILLER_97_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07812_ net2156 net1594 _00711_ _00712_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__a22o_1
XFILLER_84_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2590 net2591 VGND VGND VPWR VPWR net2590 sky130_fd_sc_hd__clkbuf_2
XFILLER_96_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08792_ net2070 net1806 net1837 net2045 VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__a22oi_1
X_07743_ net2188 net1592 _00823_ _00824_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__o2bb2a_1
X_07674_ net2049 net1687 net1720 net2023 VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_125_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09413_ _00964_ _00965_ _00968_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__nand3_1
XFILLER_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09344_ _02425_ _02426_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09275_ _02033_ _02035_ _02034_ _02047_ _02038_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_23_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08226_ _01092_ net715 _01103_ _01105_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__nand4_1
X_08157_ _01196_ _01204_ _01199_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__a21o_1
XFILLER_134_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07108_ net2106 VGND VGND VPWR VPWR _06880_ sky130_fd_sc_hd__inv_2
XFILLER_134_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08088_ _01138_ _01143_ net825 VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__o21a_1
XFILLER_121_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10050_ net455 net581 _03120_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__a21oi_2
XFILLER_130_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_141_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13740_ _06601_ _06749_ VGND VGND VPWR VPWR adder_inst.sum_raw\[19\] sky130_fd_sc_hd__xnor2_2
X_10952_ _04037_ net642 _04020_ _04024_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_29_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13671_ _06676_ _06427_ VGND VGND VPWR VPWR _06688_ sky130_fd_sc_hd__nand2_1
X_10883_ net799 net1846 net2391 net874 VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__and4_1
X_12622_ _05702_ net445 _05700_ VGND VGND VPWR VPWR _05704_ sky130_fd_sc_hd__o21bai_4
XTAP_TAPCELL_ROW_65_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12553_ net115 _05610_ net114 net109 VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__nand4b_4
XFILLER_129_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11504_ net564 _04047_ _04066_ _04067_ VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__o2bb2ai_1
X_14223_ net2885 VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__inv_2
X_12484_ net3135 _05566_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__xnor2_2
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11435_ _04519_ _04520_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__nor2_4
XFILLER_137_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14154_ net2869 VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__inv_2
XFILLER_98_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_60_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11366_ _04394_ _04417_ _04447_ _04448_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__o211ai_2
X_13105_ net2936 net3225 net415 net366 VGND VGND VPWR VPWR _06135_ sky130_fd_sc_hd__and4_1
X_14085_ net2846 VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__inv_2
X_10317_ _03401_ _03397_ _03400_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__o21ai_1
X_11297_ _04298_ _04306_ _04308_ _04309_ net636 VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__o221ai_2
X_13036_ _06063_ _06064_ _06061_ net3195 VGND VGND VPWR VPWR _06066_ sky130_fd_sc_hd__o22a_2
X_10248_ net1727 net2438 VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__nand2_1
Xfanout1130 net1131 VGND VGND VPWR VPWR net1130 sky130_fd_sc_hd__buf_6
Xfanout1141 net1142 VGND VGND VPWR VPWR net1141 sky130_fd_sc_hd__buf_4
XFILLER_121_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1174 net1178 VGND VGND VPWR VPWR net1174 sky130_fd_sc_hd__clkbuf_1
XFILLER_66_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10179_ _03262_ _03258_ net890 VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__o21a_1
Xfanout1152 net1153 VGND VGND VPWR VPWR net1152 sky130_fd_sc_hd__buf_1
Xfanout1163 net1165 VGND VGND VPWR VPWR net1163 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1196 _06893_ VGND VGND VPWR VPWR net1196 sky130_fd_sc_hd__buf_1
Xfanout1185 net1186 VGND VGND VPWR VPWR net1185 sky130_fd_sc_hd__clkbuf_1
X_13938_ add_res\[2\] net3486 net2793 VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__mux2_1
XFILLER_93_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13869_ _05558_ _05555_ net122 VGND VGND VPWR VPWR _06829_ sky130_fd_sc_hd__mux2_1
X_07390_ net2132 net1534 VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__nand2_1
XFILLER_62_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09060_ net997 net949 net2234 net1776 _01321_ VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__o2111ai_2
XTAP_TAPCELL_ROW_20_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer209 net3126 VGND VGND VPWR VPWR net3127 sky130_fd_sc_hd__dlygate4sd1_1
X_08011_ net2093 net1876 VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__nand2_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09962_ _03037_ _03044_ _03045_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__nand3_4
X_08913_ _01967_ _01968_ _01995_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__o21ai_2
XFILLER_69_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09893_ _02708_ _02709_ _02730_ _02732_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_97_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08844_ _01745_ _01924_ _01925_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_108_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08775_ net680 _01860_ _01844_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__a21o_1
XFILLER_73_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07726_ _00797_ _00800_ _00801_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_0_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07657_ _00650_ _00739_ _00740_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__nand3_4
XFILLER_25_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07588_ _00521_ _00546_ _00547_ _00568_ VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_105_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09327_ _02403_ _02405_ _02407_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__a21o_1
XFILLER_139_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_117_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09258_ _00953_ _00955_ net1252 net1213 VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__o2bb2ai_2
X_08209_ _01292_ _01084_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__nand2_2
X_09189_ _02266_ _02272_ _02273_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__and3b_1
XFILLER_104_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11220_ _04296_ _04300_ _04290_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__o21ai_4
XFILLER_134_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11151_ net173 _04235_ _04229_ _04225_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_107_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10102_ net659 _03186_ _03162_ _03175_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_103_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11082_ _03769_ net426 _03802_ net2998 VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_130_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10033_ _03117_ _03118_ _03114_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__o21ai_4
XFILLER_124_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11984_ _04981_ _04982_ net552 VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__a21o_1
XFILLER_17_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13723_ _06322_ _06325_ _06734_ _06727_ net850 VGND VGND VPWR VPWR _06735_ sky130_fd_sc_hd__o221a_1
XFILLER_90_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10935_ _03951_ _03952_ net1205 net1132 VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13654_ net852 _06672_ _06673_ _06671_ VGND VGND VPWR VPWR _06674_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_80_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10866_ net2267 net2298 net1955 net1981 VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__nand4_2
XFILLER_16_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12605_ net783 VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__inv_2
XFILLER_129_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13585_ _06613_ VGND VGND VPWR VPWR _06614_ sky130_fd_sc_hd__inv_6
X_10797_ net1217 _03680_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__nand2_4
XFILLER_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12536_ net1080 _05620_ net126 VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__o21ai_4
X_12467_ net140 net314 _05548_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__nand3_4
X_14206_ net2903 VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11418_ _04502_ _04503_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__nand2_2
X_14137_ net2892 VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__inv_2
X_12398_ _00592_ _05483_ VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_78_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11349_ net1736 net2566 net2592 net1707 VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_91_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14068_ net2825 VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__inv_2
XFILLER_140_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13019_ _06926_ net1054 _06048_ VGND VGND VPWR VPWR _06049_ sky130_fd_sc_hd__and3_1
X_08560_ net2211 net1685 VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__and2_1
X_07511_ _00586_ _00582_ _00579_ _00589_ _00588_ VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__o2111ai_1
XFILLER_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08491_ net1331 net2562 _01575_ _01576_ VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__a22oi_1
X_07442_ net1048 net1002 _00526_ _00523_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__o22ai_2
X_07373_ net830 _00444_ _00455_ _00457_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__nand4_2
X_09112_ _02191_ _02192_ _02193_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__nand3_2
XFILLER_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09043_ _01306_ _01307_ _01308_ _01297_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__o22ai_1
XFILLER_135_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold454 adder_inst.exp_a\[5\] VGND VGND VPWR VPWR net3372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold443 adder_inst.i_b\[5\] VGND VGND VPWR VPWR net3361 sky130_fd_sc_hd__dlygate4sd3_1
Xhold432 adder_inst.i_b\[21\] VGND VGND VPWR VPWR net3350 sky130_fd_sc_hd__dlygate4sd3_1
Xhold421 adder_inst.i_b\[19\] VGND VGND VPWR VPWR net3339 sky130_fd_sc_hd__dlygate4sd3_1
Xhold476 multiplier_inst.man_final_r\[6\] VGND VGND VPWR VPWR net3394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold465 adder_inst.exp_a\[0\] VGND VGND VPWR VPWR net3383 sky130_fd_sc_hd__dlygate4sd3_1
Xhold487 adder_inst.i_b\[1\] VGND VGND VPWR VPWR net3405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold498 mul_res\[20\] VGND VGND VPWR VPWR net3416 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout934 net935 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__buf_6
Xfanout901 _02597_ VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__buf_6
X_09945_ _03028_ _03029_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__nand2_2
Xfanout923 _01411_ VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__buf_6
Xfanout912 _01476_ VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__buf_4
Xfanout956 _01129_ VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__clkbuf_1
Xfanout945 net946 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__buf_6
XFILLER_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout967 net968 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__clkbuf_2
X_09876_ net1405 net2609 _02719_ _02720_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__a22oi_2
XFILLER_85_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout978 net979 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__buf_4
X_08827_ _01826_ net1066 _01912_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__and3_1
Xfanout989 net990 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_107_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08758_ _01841_ _01843_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__nand2_1
X_07709_ _00684_ _00793_ _00792_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__o21ai_1
X_08689_ _01772_ _01773_ _01770_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__a21o_1
XFILLER_72_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10720_ net568 _03804_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__nand2_1
XFILLER_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10651_ _03530_ net880 net1762 net2418 VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__and4_1
X_13370_ net358 net362 net341 _06221_ VGND VGND VPWR VPWR _06399_ sky130_fd_sc_hd__nand4_2
X_10582_ net884 _03418_ net427 _03665_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__a22o_1
XFILLER_127_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12321_ _05403_ _05404_ _05405_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__nand3_1
X_12252_ _05336_ _05337_ _05332_ VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__nand3_2
X_11203_ net865 _04288_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__nand2_1
XFILLER_107_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12183_ _05261_ _05264_ _05265_ _05266_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__or4bb_1
XFILLER_122_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11134_ _04212_ net2970 net203 VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__a21boi_1
XFILLER_49_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11065_ _03623_ _03841_ _04144_ _04145_ _04149_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__o221a_1
XFILLER_135_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10016_ net1729 net2376 net2406 net1697 VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__a22oi_2
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11967_ _04734_ _05052_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__nor2_1
X_13706_ _06360_ _06719_ VGND VGND VPWR VPWR adder_inst.sum_raw\[15\] sky130_fd_sc_hd__xnor2_2
XFILLER_60_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10918_ net425 _04001_ net424 VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__nand3b_1
XFILLER_32_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11898_ _04888_ _04889_ _04879_ VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__a21bo_1
X_13637_ net156 _06619_ _06652_ _06574_ _06658_ VGND VGND VPWR VPWR _06659_ sky130_fd_sc_hd__o221ai_1
X_10849_ net1183 net1163 _03929_ _03931_ _03744_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__o32a_4
XFILLER_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13568_ _06592_ _06321_ _06328_ _06596_ VGND VGND VPWR VPWR _06597_ sky130_fd_sc_hd__a31o_4
X_12519_ _00939_ _05604_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__xnor2_2
XFILLER_117_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13499_ _06414_ _06415_ net376 net254 VGND VGND VPWR VPWR _06528_ sky130_fd_sc_hd__nand4_4
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout219 _06156_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_1
XFILLER_87_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07991_ net2018 net1947 VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__nand2_1
Xfanout208 _03451_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_6
X_09730_ net2230 net1842 VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__nand2_1
XFILLER_82_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09661_ _02741_ _02742_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__nand2_1
XFILLER_94_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08612_ _01694_ _01695_ _01683_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__nand3_1
X_09592_ _02677_ _02672_ _02676_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__nand3_4
XFILLER_36_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08543_ _01143_ _01173_ _01172_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__o21ai_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08474_ net333 _01557_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__nand2_1
XFILLER_11_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07425_ _00509_ _00510_ _00463_ VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__a21o_1
XFILLER_10_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07356_ net1394 net2191 net2222 net1367 VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__a22o_1
XFILLER_109_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_135_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07287_ _07020_ _07057_ VGND VGND VPWR VPWR _07058_ sky130_fd_sc_hd__or2_1
XFILLER_109_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09026_ net2143 net1874 net1904 net2120 VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__a22oi_1
XFILLER_136_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2408 net2409 VGND VGND VPWR VPWR net2408 sky130_fd_sc_hd__buf_1
XFILLER_49_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2419 net2421 VGND VGND VPWR VPWR net2419 sky130_fd_sc_hd__clkbuf_2
Xfanout742 _05859_ VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__clkbuf_1
Xfanout720 _00481_ VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__clkbuf_1
Xfanout1718 net1722 VGND VGND VPWR VPWR net1718 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout731 _06072_ VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__buf_4
X_09928_ net182 _03012_ net181 VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__a21bo_1
Xfanout1707 net1708 VGND VGND VPWR VPWR net1707 sky130_fd_sc_hd__clkbuf_2
Xfanout1729 net1733 VGND VGND VPWR VPWR net1729 sky130_fd_sc_hd__buf_6
Xfanout753 _05783_ VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__buf_1
Xfanout764 net767 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__buf_1
Xfanout775 net778 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__clkbuf_1
Xfanout786 _05530_ VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__clkbuf_1
Xfanout797 _03935_ VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__buf_4
X_09859_ _02693_ _02695_ _02701_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__o21ai_1
X_12870_ net2777 net1064 net746 _05923_ _05922_ VGND VGND VPWR VPWR _05924_ sky130_fd_sc_hd__o311a_1
XFILLER_100_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_102 net1348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_113 net1959 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11821_ net2544 net1937 VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__nand2_1
XFILLER_45_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14540_ clknet_leaf_20_clk _00101_ _00362_ VGND VGND VPWR VPWR mul_res\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_121_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11752_ _04834_ net2569 net1858 VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__and3_1
X_14471_ clknet_leaf_7_clk _00057_ _00293_ VGND VGND VPWR VPWR add_res\[29\] sky130_fd_sc_hd__dfrtp_1
X_11683_ net748 _04766_ _04767_ _04768_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__a22oi_2
XFILLER_14_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10703_ _03614_ _03615_ _03616_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__a21oi_1
X_13422_ _06441_ net172 _06442_ VGND VGND VPWR VPWR _06451_ sky130_fd_sc_hd__o21ba_1
X_10634_ net800 net877 _03709_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__and3_1
X_13353_ net1943 _06190_ _06381_ net221 VGND VGND VPWR VPWR _06382_ sky130_fd_sc_hd__o211ai_1
XFILLER_127_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12304_ _05344_ _05349_ _05389_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__o21ai_2
X_10565_ _03611_ net428 _03649_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__a21o_1
XFILLER_142_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer370 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR net2168 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13284_ net269 _06198_ net3169 _06312_ VGND VGND VPWR VPWR _06313_ sky130_fd_sc_hd__o211ai_2
X_10496_ _03566_ _03569_ _03577_ _03581_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__o211a_4
XTAP_TAPCELL_ROW_75_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12235_ _03253_ _03254_ _03255_ _03475_ _05319_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__o2111a_4
XFILLER_122_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12166_ _05136_ net3154 _05142_ _05141_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__o211ai_1
X_11117_ _04164_ _04193_ _04195_ net212 _04201_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__a32o_1
XFILLER_1_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12097_ _05180_ _05181_ _05182_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__nand3_1
XFILLER_110_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11048_ _04006_ _04007_ _04132_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__nand3_4
Xinput8 i_a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_76_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12999_ net1316 net1299 net849 net1293 net2701 VGND VGND VPWR VPWR _06034_ sky130_fd_sc_hd__o311a_1
XFILLER_51_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07210_ net2058 net2034 net1423 net1455 VGND VGND VPWR VPWR _06981_ sky130_fd_sc_hd__and4_1
X_08190_ _01219_ _01230_ _01265_ net474 VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__a2bb2o_1
X_07141_ net2776 VGND VGND VPWR VPWR _06913_ sky130_fd_sc_hd__inv_2
XFILLER_133_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07974_ _01059_ _01056_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__nand2_2
XFILLER_101_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09713_ net2129 net1969 VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__nand2_1
X_09644_ _02714_ net811 net671 net669 VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__o211a_1
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09575_ _02655_ _02657_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__nand2_2
X_08526_ _01582_ net471 net470 VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__nand3_1
XFILLER_70_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08457_ _01513_ _01514_ _01541_ _01542_ VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__nand4_2
XFILLER_51_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07408_ _00452_ _00488_ _00493_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__a21o_1
XFILLER_51_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08388_ _01473_ _01461_ _01472_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__nand3_1
XFILLER_7_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07339_ net2066 net2100 VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__nand2_1
X_10350_ _03427_ _03428_ _03431_ _03424_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__a31oi_4
XFILLER_136_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09009_ net2089 net1949 VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__nand2_2
X_10281_ _03364_ _03366_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__nand2_1
Xfanout2216 net2217 VGND VGND VPWR VPWR net2216 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_57_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2205 net2206 VGND VGND VPWR VPWR net2205 sky130_fd_sc_hd__buf_6
X_12020_ net627 net623 _05011_ _05014_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_104_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1504 net1505 VGND VGND VPWR VPWR net1504 sky130_fd_sc_hd__buf_1
Xfanout2238 net2241 VGND VGND VPWR VPWR net2238 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2227 net2228 VGND VGND VPWR VPWR net2227 sky130_fd_sc_hd__clkbuf_2
Xfanout2249 net2250 VGND VGND VPWR VPWR net2249 sky130_fd_sc_hd__buf_4
Xfanout1537 net1538 VGND VGND VPWR VPWR net1537 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1526 net1527 VGND VGND VPWR VPWR net1526 sky130_fd_sc_hd__buf_1
Xfanout1548 net1553 VGND VGND VPWR VPWR net1548 sky130_fd_sc_hd__buf_6
X_13971_ net2901 VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__inv_2
Xfanout1559 net1560 VGND VGND VPWR VPWR net1559 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_70_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout572 _03645_ VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__clkbuf_1
Xfanout561 _04124_ VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__buf_1
Xfanout583 _02973_ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__buf_6
X_12922_ net1074 net3330 net2768 net744 net1078 VGND VGND VPWR VPWR _05969_ sky130_fd_sc_hd__o221a_1
Xfanout594 _01375_ VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12853_ net2781 net2714 _05843_ VGND VGND VPWR VPWR _05909_ sky130_fd_sc_hd__and3_1
X_12784_ net2710 net2720 net2705 VGND VGND VPWR VPWR _05846_ sky130_fd_sc_hd__or3_1
X_11804_ _04879_ _04888_ _04889_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__nand3b_4
X_14523_ clknet_leaf_9_clk multiplier_inst.exp_final\[0\] _00345_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
X_11735_ net2516 net1941 VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__nand2_1
XFILLER_25_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14454_ clknet_leaf_4_clk _00039_ _00276_ VGND VGND VPWR VPWR add_res\[12\] sky130_fd_sc_hd__dfrtp_1
X_13405_ net338 net297 _06367_ _06366_ VGND VGND VPWR VPWR _06434_ sky130_fd_sc_hd__o211ai_2
X_11666_ net449 net554 _04740_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__a21o_1
X_10617_ net994 net926 _03491_ _03487_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__o211a_4
X_11597_ net2482 net1885 net2516 net1914 VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__and4_1
X_14385_ clknet_leaf_18_clk net3348 _00207_ VGND VGND VPWR VPWR adder_inst.man_a_r\[9\]
+ sky130_fd_sc_hd__dfrtp_2
X_13336_ net262 _06216_ VGND VGND VPWR VPWR _06365_ sky130_fd_sc_hd__nand2_1
X_10548_ _03398_ _03400_ _03401_ VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__a21o_1
XFILLER_142_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13267_ net270 _06195_ _06196_ net295 net288 VGND VGND VPWR VPWR _06296_ sky130_fd_sc_hd__o2111ai_1
XFILLER_6_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12218_ _04985_ net189 _04893_ VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__o21ai_1
X_10479_ net918 net971 _03563_ _03560_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__o22a_1
XFILLER_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13198_ net1203 net1175 net485 VGND VGND VPWR VPWR _06228_ sky130_fd_sc_hd__mux2_1
Xfanout2750 net2168 VGND VGND VPWR VPWR net2750 sky130_fd_sc_hd__buf_1
Xfanout2761 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR net2761 sky130_fd_sc_hd__clkbuf_2
Xfanout2772 net2773 VGND VGND VPWR VPWR net2772 sky130_fd_sc_hd__buf_1
X_12149_ _05231_ _05233_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__nand2_1
Xfanout2794 net2795 VGND VGND VPWR VPWR net2794 sky130_fd_sc_hd__clkbuf_2
Xfanout2783 net2784 VGND VGND VPWR VPWR net2783 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07690_ _00663_ _00760_ _00763_ _00770_ VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__o211ai_1
X_09360_ _02323_ _02441_ _02442_ _02445_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__a31o_1
X_09291_ _02375_ net2471 net1335 _02374_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__nand4_1
X_08311_ net2348 net2379 VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__nand2_2
XFILLER_33_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08242_ net1010 net952 net2201 net1773 _01128_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__o2111ai_1
XANTENNA_13 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_46 net1402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 net1166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_57 net1840 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 net912 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_68 net2507 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08173_ _01241_ net695 net610 VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__nand3_2
XANTENNA_79 net2667 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07124_ net2489 VGND VGND VPWR VPWR _06896_ sky130_fd_sc_hd__inv_2
XFILLER_9_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07957_ _00941_ _01040_ _01041_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_110_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07888_ _00972_ _00949_ _00947_ net613 VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_28_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09627_ net1382 net2616 net2638 net1354 VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__a22o_1
XFILLER_102_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09558_ _02166_ _02640_ _02642_ _02638_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__o22a_1
X_08509_ _01592_ net909 _01588_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__a21o_1
XFILLER_70_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09489_ net813 _02570_ net2207 net1848 VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__and4_1
X_11520_ _04558_ _04601_ _04602_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__nand3_4
XFILLER_23_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11451_ net476 _04520_ _04534_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__o21ai_4
X_14170_ net2854 VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__inv_2
X_10402_ net2251 net1976 VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__nand2_1
X_11382_ _04466_ _04467_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__nand2_2
X_13121_ net3204 net365 net378 VGND VGND VPWR VPWR _06151_ sky130_fd_sc_hd__and3_1
X_10333_ net884 _03418_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__nand2_1
XFILLER_105_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2024 net2025 VGND VGND VPWR VPWR net2024 sky130_fd_sc_hd__buf_1
Xfanout2013 adder_inst.exp_a_r\[0\] VGND VGND VPWR VPWR net2013 sky130_fd_sc_hd__clkbuf_2
X_13052_ net3198 net3303 VGND VGND VPWR VPWR _06082_ sky130_fd_sc_hd__nand2_4
Xfanout2002 adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR net2002 sky130_fd_sc_hd__clkbuf_1
X_10264_ net655 _03349_ net654 VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__a21bo_1
Xfanout1323 adder_inst.i_vld_r2 VGND VGND VPWR VPWR net1323 sky130_fd_sc_hd__buf_1
Xfanout1301 net1302 VGND VGND VPWR VPWR net1301 sky130_fd_sc_hd__clkbuf_1
Xfanout1312 net1314 VGND VGND VPWR VPWR net1312 sky130_fd_sc_hd__buf_6
Xfanout2057 net2058 VGND VGND VPWR VPWR net2057 sky130_fd_sc_hd__clkbuf_2
Xfanout2046 net2047 VGND VGND VPWR VPWR net2046 sky130_fd_sc_hd__buf_1
Xfanout2035 net2036 VGND VGND VPWR VPWR net2035 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2068 net2069 VGND VGND VPWR VPWR net2068 sky130_fd_sc_hd__clkbuf_2
X_10195_ net804 net1843 net2287 net888 VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__and4_1
X_12003_ _04992_ _04993_ _04994_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__a21o_1
Xfanout1334 net1335 VGND VGND VPWR VPWR net1334 sky130_fd_sc_hd__buf_1
Xfanout1345 net1346 VGND VGND VPWR VPWR net1345 sky130_fd_sc_hd__buf_1
Xfanout2079 net2081 VGND VGND VPWR VPWR net2079 sky130_fd_sc_hd__clkbuf_2
XFILLER_94_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1356 net1363 VGND VGND VPWR VPWR net1356 sky130_fd_sc_hd__buf_1
Xfanout1389 net1390 VGND VGND VPWR VPWR net1389 sky130_fd_sc_hd__clkbuf_2
Xfanout1367 net1368 VGND VGND VPWR VPWR net1367 sky130_fd_sc_hd__clkbuf_2
Xfanout1378 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR net1378 sky130_fd_sc_hd__clkbuf_4
Xfanout380 _06081_ VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_1
XFILLER_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout391 _03099_ VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__buf_6
X_13954_ net3479 mul_res\[18\] net2797 VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__mux2_1
XFILLER_46_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13885_ _05569_ _06831_ _06834_ _06837_ _06840_ VGND VGND VPWR VPWR _06841_ sky130_fd_sc_hd__a41o_1
X_12905_ net1073 net2770 net1079 _05952_ _05953_ VGND VGND VPWR VPWR _05954_ sky130_fd_sc_hd__o2111a_1
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12836_ net2784 net2699 net741 net2786 net835 VGND VGND VPWR VPWR _05895_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_83_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14506_ clknet_leaf_20_clk multiplier_inst.man_final\[6\] _00328_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_12767_ _06922_ _05815_ net838 VGND VGND VPWR VPWR _05829_ sky130_fd_sc_hd__o21ai_1
X_12698_ net766 adder_inst.is_inf_a_r adder_inst.is_inf_b_r net3481 adder_inst.is_nan_a_r
+ VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__a311o_1
X_11718_ _04659_ _04796_ _04800_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_25_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 i_a[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_14437_ clknet_leaf_11_clk adder_inst.is_nan_a _00259_ VGND VGND VPWR VPWR adder_inst.is_nan_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_11649_ net1704 net1739 net2652 net2668 VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__and4_1
XFILLER_30_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput11 i_a[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_14368_ clknet_leaf_3_clk adder_inst.sum_raw\[17\] _00190_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput55 i_b[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput44 i_b[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput33 i_b[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput66 opcode VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
X_13319_ net286 _06188_ _06346_ net336 net305 VGND VGND VPWR VPWR _06348_ sky130_fd_sc_hd__o2111ai_2
XFILLER_115_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14299_ clknet_leaf_17_clk net5 _00121_ VGND VGND VPWR VPWR adder_inst.i_a\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_131_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08860_ _01779_ _01781_ _01813_ _01812_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__a31o_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_07811_ _00711_ _00712_ _00713_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__a21oi_1
Xfanout2580 adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR net2580 sky130_fd_sc_hd__buf_4
XFILLER_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08791_ net2071 net1806 VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__nand2_1
XFILLER_84_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2591 net2607 VGND VGND VPWR VPWR net2591 sky130_fd_sc_hd__clkbuf_4
XFILLER_38_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07742_ net2188 net1592 VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__nand2_1
Xfanout1890 net1891 VGND VGND VPWR VPWR net1890 sky130_fd_sc_hd__dlymetal6s2s_1
X_07673_ net716 _00758_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_125_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09412_ _00964_ _00965_ _00966_ _00967_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__o2bb2ai_1
X_09343_ _02424_ _02425_ _02426_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__a21o_1
XFILLER_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09274_ _02359_ _02014_ _02358_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_23_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08225_ _01306_ _01307_ _01298_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__o21ai_1
X_08156_ _01197_ _01198_ _01196_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07107_ net1413 VGND VGND VPWR VPWR _06879_ sky130_fd_sc_hd__inv_2
X_08087_ net825 net1775 net2185 VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__and3_1
XFILLER_134_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08989_ _02074_ _01942_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__nand2_1
XFILLER_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10951_ _04029_ _04033_ _04036_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__o21ai_2
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13670_ _06428_ _06687_ VGND VGND VPWR VPWR adder_inst.sum_raw\[11\] sky130_fd_sc_hd__xnor2_2
XFILLER_73_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12621_ net445 _05702_ VGND VGND VPWR VPWR _05703_ sky130_fd_sc_hd__nor2_4
X_10882_ net873 net799 net1199 net1153 VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_16_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12552_ net107 net110 net102 VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__and3_1
X_12483_ net3136 net3065 VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__xor2_4
X_11503_ _04040_ _04046_ _04073_ _04045_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__o211ai_2
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14222_ net2884 VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__inv_2
X_11434_ net866 _04261_ _04516_ _04518_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__o211a_4
XFILLER_137_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14153_ net2868 VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__inv_2
X_11365_ _04395_ _04412_ _04449_ _04450_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__nand4_2
X_13104_ net413 VGND VGND VPWR VPWR _06134_ sky130_fd_sc_hd__inv_2
X_14084_ net2825 VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__inv_2
XFILLER_3_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10316_ net1110 net1102 net1015 net1101 net1236 VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__o32a_4
X_11296_ net636 _04307_ _04310_ _04312_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_140_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13035_ net2003 net860 _06063_ VGND VGND VPWR VPWR _06065_ sky130_fd_sc_hd__a21oi_1
X_10247_ _03330_ _03331_ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__nand2_2
XFILLER_121_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1131 net1132 VGND VGND VPWR VPWR net1131 sky130_fd_sc_hd__clkbuf_2
Xfanout1120 net1121 VGND VGND VPWR VPWR net1120 sky130_fd_sc_hd__buf_2
XFILLER_121_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1164 net1165 VGND VGND VPWR VPWR net1164 sky130_fd_sc_hd__clkbuf_2
X_10178_ _03262_ _03258_ net890 VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__o21ai_2
Xfanout1153 net1154 VGND VGND VPWR VPWR net1153 sky130_fd_sc_hd__clkbuf_2
Xfanout1142 _06900_ VGND VGND VPWR VPWR net1142 sky130_fd_sc_hd__buf_6
Xfanout1175 net1177 VGND VGND VPWR VPWR net1175 sky130_fd_sc_hd__buf_2
Xfanout1186 net1191 VGND VGND VPWR VPWR net1186 sky130_fd_sc_hd__clkbuf_2
X_13937_ add_res\[1\] net3483 net2792 VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__mux2_1
XFILLER_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13868_ _06827_ _06828_ VGND VGND VPWR VPWR multiplier_inst.man_final\[2\] sky130_fd_sc_hd__nor2_1
X_13799_ net3420 net727 VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__and2_1
X_12819_ net1298 net848 _05795_ VGND VGND VPWR VPWR _05881_ sky130_fd_sc_hd__a21o_1
XFILLER_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08010_ net2065 net1906 VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_96_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09961_ net3038 net2178 net1925 _03036_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__a31o_1
X_08912_ _01991_ _01993_ _01992_ _01969_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__o211ai_2
XFILLER_134_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09892_ _02708_ _02709_ _02731_ _02733_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_127_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08843_ _01548_ _01734_ _01735_ _01740_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__a31o_1
X_08774_ _01856_ _01857_ _01847_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__nand3_1
XFILLER_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07725_ _00807_ _00808_ _00806_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__a21oi_1
XFILLER_72_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07656_ _00650_ _00740_ _00739_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__a21o_1
X_07587_ _00521_ _00546_ _00547_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_105_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09326_ _02403_ _02407_ _02404_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__a21o_1
X_09257_ net1203 _00952_ _00955_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_138_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08208_ _01077_ _01078_ _01084_ net828 VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__o211ai_2
XFILLER_135_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09188_ _02272_ _02273_ _02266_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__a21boi_1
X_08139_ net1587 net2346 _01222_ _01224_ VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__a22oi_4
XFILLER_108_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11150_ net173 _04221_ _04227_ _04235_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__nand4_4
XFILLER_122_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10101_ _03175_ _03162_ _03186_ net659 VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11081_ net425 net424 _04000_ _03995_ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_102_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10032_ _02919_ _02921_ net1574 net2501 VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__and4_1
XFILLER_75_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13722_ _06328_ _06728_ VGND VGND VPWR VPWR _06734_ sky130_fd_sc_hd__or2_1
XFILLER_90_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11983_ net247 _05068_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__and2_1
X_10934_ _03951_ _03952_ net2326 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR _04020_
+ sky130_fd_sc_hd__and4_1
XFILLER_44_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13653_ net511 net2457 _06447_ _06445_ VGND VGND VPWR VPWR _06673_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_80_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10865_ _03948_ _03949_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__nand2_1
XFILLER_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13584_ net3316 net171 VGND VGND VPWR VPWR _06613_ sky130_fd_sc_hd__nand2_8
X_12604_ _05684_ _05685_ VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__nand2_1
XFILLER_129_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12535_ _07067_ _05513_ VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__or2_4
XFILLER_12_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10796_ _03880_ _03874_ _03879_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__nand3_4
XFILLER_8_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12466_ _05546_ _05543_ _05549_ VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__nor3_4
XFILLER_125_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14205_ net2879 VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__inv_2
X_12397_ _00591_ _00593_ VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_78_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11417_ _04495_ _04496_ _04499_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__nand3_2
X_14136_ net2892 VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11348_ net1707 net1736 net2566 net2592 VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__nand4_2
XFILLER_140_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14067_ net2832 VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__inv_2
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11279_ _04360_ _04361_ _04357_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__nand3_2
XFILLER_140_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13018_ net3207 net3206 VGND VGND VPWR VPWR _06048_ sky130_fd_sc_hd__nand2b_4
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07510_ _00587_ _00588_ _00589_ _00579_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__a22o_1
X_08490_ net1384 net2504 net2535 net1357 VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__a22o_1
X_07441_ net2100 net1595 net1047 net1001 VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__o2bb2a_1
X_07372_ net830 _00444_ _00455_ _00457_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__and4_1
X_09111_ _02195_ _02194_ _02190_ VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_33_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09042_ _01304_ _01305_ _01309_ _01298_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__o211ai_1
XFILLER_132_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold433 adder_inst.i_b\[9\] VGND VGND VPWR VPWR net3351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold444 adder_inst.i_b\[12\] VGND VGND VPWR VPWR net3362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold422 adder_inst.i_a\[11\] VGND VGND VPWR VPWR net3340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold477 multiplier_inst.exp_final_r\[7\] VGND VGND VPWR VPWR net3395 sky130_fd_sc_hd__dlygate4sd3_1
Xhold455 adder_inst.exp_b\[3\] VGND VGND VPWR VPWR net3373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold466 adder_inst.i_a\[19\] VGND VGND VPWR VPWR net3384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold488 multiplier_inst.man_final_r\[21\] VGND VGND VPWR VPWR net3406 sky130_fd_sc_hd__dlygate4sd3_1
Xhold499 _00012_ VGND VGND VPWR VPWR net3417 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_98_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09944_ net2178 net1944 net1969 net2141 VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__a22oi_2
Xfanout902 _02597_ VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__buf_1
Xfanout913 net915 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__clkbuf_2
Xfanout924 _01411_ VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__buf_1
Xfanout946 net947 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__clkbuf_2
Xfanout968 _01022_ VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__clkbuf_4
Xfanout935 _01286_ VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__buf_6
X_09875_ _02960_ _02957_ _02959_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__o21ai_2
XFILLER_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08826_ _01904_ _01910_ _01909_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__o21ai_2
Xfanout979 net980 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08757_ _01633_ _01835_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__o21ai_1
X_07708_ _00681_ _00682_ _00601_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__a21o_1
X_08688_ _01770_ _01771_ _01773_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_49_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07639_ net705 _00723_ net704 VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__a21boi_1
XFILLER_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10650_ net1179 net1175 _03530_ net880 VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__o211ai_1
X_09309_ _01983_ _01979_ _01972_ _01987_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__a2bb2oi_2
XTAP_TAPCELL_ROW_62_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10581_ _03665_ _03418_ net884 net427 VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__and4_1
X_12320_ _05404_ _05405_ _05403_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__a21o_1
XFILLER_126_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12251_ _01030_ _01032_ _01011_ _01012_ VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__o211ai_4
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11202_ net2422 net1935 VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__nand2_1
XFILLER_122_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12182_ _05261_ _05264_ _05265_ _05266_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__and4bb_1
X_11133_ _04216_ _04217_ _04202_ VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__nand3_4
XFILLER_88_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11064_ _04145_ _04144_ _03843_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__o21ai_1
X_10015_ net1698 net2406 VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__nand2_1
XFILLER_76_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11966_ net619 net863 net621 VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__a21boi_4
X_13705_ net760 _06716_ _06715_ _06718_ VGND VGND VPWR VPWR _06719_ sky130_fd_sc_hd__a31o_1
X_10917_ net404 net424 VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__nand2_1
X_13636_ _06572_ _06573_ VGND VGND VPWR VPWR _06658_ sky130_fd_sc_hd__nand2_1
X_11897_ _04978_ _04976_ _04977_ net552 VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__a31o_1
X_10848_ net1763 net2476 VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__nand2_1
X_13567_ _06320_ _06595_ _06318_ VGND VGND VPWR VPWR _06596_ sky130_fd_sc_hd__o21ai_1
X_10779_ _03604_ _03606_ _03655_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__and3_1
X_12518_ _01070_ _05588_ _01069_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__a21boi_1
X_13498_ net232 _06454_ _06526_ _06155_ VGND VGND VPWR VPWR _06527_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_30_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12449_ net167 net2954 net2933 net2928 VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__nand4_1
XFILLER_132_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_136_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07990_ _00816_ _00703_ _01075_ _00819_ net185 VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__o221a_1
XFILLER_113_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14119_ net2840 VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__inv_2
Xfanout209 _02758_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_4
XFILLER_140_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09660_ _02743_ _02745_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__nand2_1
XFILLER_39_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08611_ net941 _01178_ _01180_ _01692_ _01693_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__o2111ai_4
XFILLER_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09591_ _02673_ _02264_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_120_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08542_ _01278_ net438 VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__nand2_4
X_08473_ net331 _01558_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_18_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07424_ _00457_ _00459_ _00508_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_102_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07355_ net1367 net1394 net2191 net2221 VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__nand4_2
XFILLER_50_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_135_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07286_ _07056_ _07021_ _07055_ VGND VGND VPWR VPWR _07057_ sky130_fd_sc_hd__or3_1
XFILLER_109_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09025_ net2141 net1874 VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__nand2_1
XFILLER_117_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2409 net2414 VGND VGND VPWR VPWR net2409 sky130_fd_sc_hd__buf_1
Xfanout1719 net1721 VGND VGND VPWR VPWR net1719 sky130_fd_sc_hd__buf_2
Xfanout721 net722 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__buf_1
XFILLER_77_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout732 net734 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__buf_6
X_09927_ _02995_ _02997_ _02999_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__a21oi_1
Xfanout1708 net1709 VGND VGND VPWR VPWR net1708 sky130_fd_sc_hd__buf_1
Xfanout710 _04739_ VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout754 net756 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__buf_1
Xfanout743 net744 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout765 net766 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__clkbuf_2
Xfanout776 net777 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout787 net788 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__buf_1
Xfanout798 _03920_ VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__clkbuf_2
X_09858_ _02923_ _02928_ _02929_ _02931_ _02942_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__a32o_1
X_08809_ _01688_ _01872_ _01889_ _01890_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__o211a_1
XFILLER_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09789_ _02639_ _02641_ _02642_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__a21o_1
XANTENNA_103 net1361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_114 net2414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11820_ net2545 net1937 VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__and2_1
X_11751_ net1155 net1120 _04834_ _04836_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_81_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10702_ net1142 net1119 net999 _03614_ _03616_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__o311a_1
XFILLER_41_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14470_ clknet_leaf_6_clk _00056_ _00292_ VGND VGND VPWR VPWR add_res\[28\] sky130_fd_sc_hd__dfrtp_1
X_11682_ _04544_ _04549_ net2964 _04556_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__o211ai_2
X_13421_ _06448_ _06446_ VGND VGND VPWR VPWR _06450_ sky130_fd_sc_hd__nand2_1
X_10633_ net878 net800 _03709_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__a21oi_2
X_13352_ _06212_ _06219_ net294 VGND VGND VPWR VPWR _06381_ sky130_fd_sc_hd__a21o_1
XFILLER_6_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10564_ _03611_ net427 _03649_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__a21oi_1
X_12303_ _05331_ _05387_ _05388_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__nand3_1
Xrebuffer360 net2115 VGND VGND VPWR VPWR net1894 sky130_fd_sc_hd__buf_6
Xrebuffer382 _06088_ VGND VGND VPWR VPWR net3300 sky130_fd_sc_hd__buf_6
X_13283_ net785 _06195_ net363 net340 net414 VGND VGND VPWR VPWR _06312_ sky130_fd_sc_hd__o2111a_1
X_10495_ _03565_ _03578_ _03579_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__nand3_4
XFILLER_135_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12234_ _03475_ _05319_ VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__nand2_2
Xfanout2910 net2912 VGND VGND VPWR VPWR net2910 sky130_fd_sc_hd__clkbuf_2
X_12165_ net245 _05141_ _05142_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__and3_1
XFILLER_123_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11116_ _04164_ _04193_ _04195_ net212 _04201_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__a32oi_2
XFILLER_122_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12096_ net618 net617 _05091_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__nand3_2
XFILLER_77_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11047_ _04080_ _04131_ _04082_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__a21boi_1
Xinput9 i_a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XFILLER_91_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12998_ _06030_ _06031_ _06032_ VGND VGND VPWR VPWR _06033_ sky130_fd_sc_hd__and3_1
XFILLER_55_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11949_ _05029_ _05032_ _05033_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_15_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13619_ _06497_ net177 _06518_ _06520_ VGND VGND VPWR VPWR _06643_ sky130_fd_sc_hd__a22o_1
X_07140_ net2781 VGND VGND VPWR VPWR _06912_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_117_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_130_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07973_ _01057_ _01058_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__nand2_1
X_09712_ _02668_ _02748_ _02742_ _02741_ net250 VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__o2111ai_1
XFILLER_142_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09643_ net670 net668 VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__nand2_1
X_09574_ _02631_ net589 _02652_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__and3_1
X_08525_ _01580_ _01581_ _01606_ _01608_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_46_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08456_ _01538_ _01535_ _01517_ _01539_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__o211ai_4
X_07407_ _00490_ net2218 net1419 _00492_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__a31o_1
XFILLER_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08387_ net1409 net2530 _01465_ _01468_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__a22o_1
X_07338_ net2107 net1536 VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__nand2_1
XFILLER_136_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07269_ _07035_ _07037_ _07038_ _06966_ VGND VGND VPWR VPWR _07040_ sky130_fd_sc_hd__a211o_4
XFILLER_136_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09008_ net2063 net1973 VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__nand2_2
X_10280_ _03351_ _03357_ net577 VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__nand3_1
Xfanout2217 net2952 VGND VGND VPWR VPWR net2217 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_57_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2206 net2207 VGND VGND VPWR VPWR net2206 sky130_fd_sc_hd__buf_6
XFILLER_3_748 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1505 net1506 VGND VGND VPWR VPWR net1505 sky130_fd_sc_hd__clkbuf_2
Xfanout2239 net2241 VGND VGND VPWR VPWR net2239 sky130_fd_sc_hd__clkbuf_2
Xfanout2228 net2235 VGND VGND VPWR VPWR net2228 sky130_fd_sc_hd__buf_1
XFILLER_116_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1538 net1539 VGND VGND VPWR VPWR net1538 sky130_fd_sc_hd__clkbuf_2
Xfanout1527 net1532 VGND VGND VPWR VPWR net1527 sky130_fd_sc_hd__buf_2
Xfanout540 net3178 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__clkbuf_1
Xfanout1516 net1518 VGND VGND VPWR VPWR net1516 sky130_fd_sc_hd__buf_2
Xfanout551 _05053_ VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__buf_1
X_13970_ net2868 VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__inv_2
XFILLER_76_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1549 net1551 VGND VGND VPWR VPWR net1549 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout562 net563 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout573 _03526_ VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__buf_6
Xfanout584 _02949_ VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__buf_2
X_12921_ net2770 net2750 net2741 VGND VGND VPWR VPWR _05968_ sky130_fd_sc_hd__or3_1
Xfanout595 _01317_ VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__buf_4
XFILLER_19_638 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12852_ net2784 net2724 _05804_ net2786 _05907_ VGND VGND VPWR VPWR _05908_ sky130_fd_sc_hd__a221o_1
XFILLER_74_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12783_ net1067 net1062 net1061 VGND VGND VPWR VPWR _05845_ sky130_fd_sc_hd__and3_1
X_11803_ _04763_ _04884_ _04885_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__nand3_4
X_14522_ clknet_leaf_1_clk multiplier_inst.man_final\[22\] _00344_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[22\] sky130_fd_sc_hd__dfrtp_1
X_11734_ net2516 net1937 VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__and2_1
X_14453_ clknet_leaf_4_clk _00038_ _00275_ VGND VGND VPWR VPWR add_res\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11665_ net448 net553 _04740_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__a21oi_1
XFILLER_25_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13404_ _06431_ _06432_ net232 VGND VGND VPWR VPWR _06433_ sky130_fd_sc_hd__nand3_2
X_10616_ _03487_ _03490_ net1224 net1126 VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_128_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14384_ clknet_leaf_18_clk net3363 _00206_ VGND VGND VPWR VPWR adder_inst.man_a_r\[8\]
+ sky130_fd_sc_hd__dfrtp_1
X_11596_ net2515 net1913 VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__nand2_2
X_13335_ net263 _06215_ VGND VGND VPWR VPWR _06364_ sky130_fd_sc_hd__nand2_1
XFILLER_10_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10547_ _03398_ _03400_ _03401_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__a21oi_1
XFILLER_115_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13266_ _06294_ _06178_ net280 _06203_ VGND VGND VPWR VPWR _06295_ sky130_fd_sc_hd__a2bb2oi_2
Xrebuffer190 net3112 VGND VGND VPWR VPWR net3108 sky130_fd_sc_hd__dlymetal6s2s_1
X_10478_ net918 net970 _03563_ _03560_ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__o22ai_4
XFILLER_142_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12217_ _05302_ _05299_ _05152_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__o21bai_4
X_13197_ net301 net361 _06226_ VGND VGND VPWR VPWR _06227_ sky130_fd_sc_hd__o21ai_4
Xfanout2762 net3331 VGND VGND VPWR VPWR net2762 sky130_fd_sc_hd__buf_1
XFILLER_2_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12148_ _05231_ _05233_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__or2_2
Xfanout2795 net2796 VGND VGND VPWR VPWR net2795 sky130_fd_sc_hd__buf_1
XFILLER_110_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2773 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR net2773 sky130_fd_sc_hd__buf_1
Xfanout2784 adder_inst.sum_raw_r\[2\] VGND VGND VPWR VPWR net2784 sky130_fd_sc_hd__buf_1
X_12079_ _05164_ _05161_ _05163_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09290_ net1335 net2471 _02374_ _02375_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__a22o_1
X_08310_ net1651 net2347 net2373 net1616 VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__a22o_2
XTAP_TAPCELL_ROW_119_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08241_ _01128_ _01131_ _01132_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__a21o_1
XANTENNA_14 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_47 net1426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 net1166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_25 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08172_ net609 VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__inv_2
XANTENNA_58 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_69 net2521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07123_ net2451 VGND VGND VPWR VPWR _06895_ sky130_fd_sc_hd__inv_4
XFILLER_118_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07956_ _01039_ _01038_ _00941_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_110_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07887_ net613 _00947_ _00972_ _00949_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__a2bb2oi_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09626_ net1356 net2639 VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__nand2_1
X_09557_ _02642_ _02638_ _02641_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__o21ai_1
XFILLER_15_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08508_ net1525 net1554 net2331 net2361 VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__nand4_1
X_09488_ net2207 net1848 net813 _02570_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__a22o_1
XFILLER_24_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08439_ _01436_ _01522_ VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__nand2_1
XFILLER_127_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11450_ _04525_ _04531_ net558 _04521_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__o211ai_2
X_10401_ _03484_ _03485_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__nand2_2
X_11381_ _04451_ _04452_ _04465_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__nand3_2
XFILLER_125_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13120_ _06145_ _06149_ net233 VGND VGND VPWR VPWR _06150_ sky130_fd_sc_hd__o21ai_4
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10332_ _03416_ _03417_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__nand2_1
XFILLER_127_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13051_ net3179 net3184 VGND VGND VPWR VPWR _06081_ sky130_fd_sc_hd__and2_4
XFILLER_124_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2025 net2026 VGND VGND VPWR VPWR net2025 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2003 adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR net2003 sky130_fd_sc_hd__buf_1
X_10263_ _03347_ _03348_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__nor2_1
X_12002_ net1137 net1120 net937 net899 _04992_ VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__o221ai_4
XFILLER_120_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2058 net2059 VGND VGND VPWR VPWR net2058 sky130_fd_sc_hd__clkbuf_2
XFILLER_105_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1302 adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR net1302 sky130_fd_sc_hd__buf_1
Xfanout1313 net3326 VGND VGND VPWR VPWR net1313 sky130_fd_sc_hd__buf_1
Xfanout2047 net2048 VGND VGND VPWR VPWR net2047 sky130_fd_sc_hd__clkbuf_2
Xfanout2036 net2037 VGND VGND VPWR VPWR net2036 sky130_fd_sc_hd__buf_1
X_10194_ net888 net805 net1218 net1152 VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__o2bb2a_2
Xfanout1335 net1336 VGND VGND VPWR VPWR net1335 sky130_fd_sc_hd__clkbuf_2
Xfanout1346 net1347 VGND VGND VPWR VPWR net1346 sky130_fd_sc_hd__buf_1
Xfanout1324 net1326 VGND VGND VPWR VPWR net1324 sky130_fd_sc_hd__buf_1
Xfanout1357 net1362 VGND VGND VPWR VPWR net1357 sky130_fd_sc_hd__clkbuf_2
Xfanout2069 net2078 VGND VGND VPWR VPWR net2069 sky130_fd_sc_hd__clkbuf_2
Xfanout1368 net1369 VGND VGND VPWR VPWR net1368 sky130_fd_sc_hd__clkbuf_1
Xfanout370 net372 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1379 net1381 VGND VGND VPWR VPWR net1379 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_6_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13953_ net3392 mul_res\[17\] net2798 VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__mux2_1
XFILLER_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13884_ net123 _05568_ _05564_ VGND VGND VPWR VPWR _06840_ sky130_fd_sc_hd__o21ba_1
X_12904_ adder_inst.sum_raw_r\[6\] net2750 net2744 VGND VGND VPWR VPWR _05953_ sky130_fd_sc_hd__or3_1
XFILLER_34_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12835_ net237 _05893_ _05894_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_83_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14505_ clknet_leaf_0_clk multiplier_inst.man_final\[5\] _00327_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_12766_ net1288 net838 _05817_ _05827_ VGND VGND VPWR VPWR _05828_ sky130_fd_sc_hd__o31a_1
XFILLER_70_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12697_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r net1327 VGND VGND VPWR VPWR _00033_
+ sky130_fd_sc_hd__o21ba_1
X_11717_ _04659_ _04800_ VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14436_ clknet_leaf_6_clk net3332 _00258_ VGND VGND VPWR VPWR adder_inst.i_vld_r2
+ sky130_fd_sc_hd__dfrtp_1
Xinput12 i_a[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
X_11648_ net1738 net2673 VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__nand2_1
X_14367_ clknet_leaf_20_clk adder_inst.sum_raw\[16\] _00189_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_11579_ net2452 net1959 VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__nand2_1
Xinput23 i_a[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput34 i_b[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 i_b[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput56 i_b[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
X_13318_ _06185_ net260 net280 _06187_ VGND VGND VPWR VPWR _06347_ sky130_fd_sc_hd__o211ai_1
XFILLER_6_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput67 rst VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_1
XFILLER_115_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14298_ clknet_leaf_17_clk net4 _00120_ VGND VGND VPWR VPWR adder_inst.i_a\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_131_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13249_ _06270_ _06271_ net187 VGND VGND VPWR VPWR _06278_ sky130_fd_sc_hd__o21ai_1
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07810_ net1260 net1252 net1001 _00711_ _00713_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__o311a_1
X_08790_ net2045 net1837 VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__nand2_1
Xfanout2581 net2583 VGND VGND VPWR VPWR net2581 sky130_fd_sc_hd__clkbuf_2
Xfanout2570 net2574 VGND VGND VPWR VPWR net2570 sky130_fd_sc_hd__clkbuf_1
X_07741_ net2122 net2158 net1627 net1661 VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__nand4_2
Xfanout2592 net2594 VGND VGND VPWR VPWR net2592 sky130_fd_sc_hd__clkbuf_2
Xfanout1880 net1881 VGND VGND VPWR VPWR net1880 sky130_fd_sc_hd__buf_2
Xfanout1891 net1892 VGND VGND VPWR VPWR net1891 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07672_ net2024 net1688 _00664_ _00665_ _00666_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__a311oi_4
XFILLER_37_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09411_ _00964_ _00965_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__nand2_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09342_ _02426_ _02425_ net435 VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__nand3b_1
Xclkbuf_leaf_17_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_138_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09273_ _02346_ _02349_ _02351_ _02352_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__o2bb2ai_1
X_08224_ _01304_ _01305_ _01309_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08155_ net824 _01240_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__nand2_1
X_07106_ net2087 VGND VGND VPWR VPWR _06878_ sky130_fd_sc_hd__inv_2
X_08086_ _01169_ _01170_ _01161_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__nand3_4
XFILLER_121_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08988_ _02072_ net213 VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__nand2_1
XFILLER_88_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07939_ _01021_ net1415 net2365 _01023_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__a31o_1
XFILLER_56_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10950_ _04030_ _04031_ net872 VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__a21o_1
XFILLER_16_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10881_ _03956_ _03959_ _03960_ VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__nand3_2
XFILLER_43_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09609_ _02685_ _02689_ _02691_ _02692_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__o211a_1
X_12620_ net102 net110 net107 _05668_ VGND VGND VPWR VPWR _05702_ sky130_fd_sc_hd__nand4_4
XFILLER_73_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_65_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12551_ _05631_ _05636_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__nor2_1
X_12482_ _05567_ net184 VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__xnor2_4
X_11502_ net564 _04047_ _04068_ _04071_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__o2bb2ai_1
X_14221_ net2881 VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__inv_2
XFILLER_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11433_ _04257_ _04509_ _04518_ _04516_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__a2bb2oi_4
XFILLER_137_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14152_ net2898 VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__inv_2
XFILLER_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11364_ _04446_ _04422_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__nand2_1
X_13103_ _06130_ _06131_ _06132_ VGND VGND VPWR VPWR _06133_ sky130_fd_sc_hd__o21ai_4
X_14083_ net2825 VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__inv_2
X_10315_ net1495 net2637 VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__nand2_2
X_11295_ _04298_ _04306_ _04310_ _04312_ net636 VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__o221ai_4
X_13034_ net860 net2003 VGND VGND VPWR VPWR _06064_ sky130_fd_sc_hd__and2_1
X_10246_ net1728 net2405 net2435 net1696 VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__a22oi_1
XFILLER_94_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1132 _06901_ VGND VGND VPWR VPWR net1132 sky130_fd_sc_hd__buf_6
Xfanout1110 net1111 VGND VGND VPWR VPWR net1110 sky130_fd_sc_hd__clkbuf_1
Xfanout1121 net1122 VGND VGND VPWR VPWR net1121 sky130_fd_sc_hd__clkbuf_4
XFILLER_78_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1154 net1160 VGND VGND VPWR VPWR net1154 sky130_fd_sc_hd__buf_2
Xfanout1165 net1166 VGND VGND VPWR VPWR net1165 sky130_fd_sc_hd__buf_1
X_10177_ net890 _03262_ VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__nand2_1
Xfanout1143 net1145 VGND VGND VPWR VPWR net1143 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1187 net1190 VGND VGND VPWR VPWR net1187 sky130_fd_sc_hd__buf_2
Xfanout1176 net1177 VGND VGND VPWR VPWR net1176 sky130_fd_sc_hd__buf_1
Xfanout1198 _06892_ VGND VGND VPWR VPWR net1198 sky130_fd_sc_hd__clkbuf_4
X_13936_ net3442 mul_res\[0\] net2792 VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__mux2_1
XFILLER_35_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13867_ _05550_ _05551_ _06826_ VGND VGND VPWR VPWR _06828_ sky130_fd_sc_hd__and3_1
XFILLER_22_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13798_ net3421 net726 VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__and2_1
X_12818_ _05879_ net2725 net2715 _05878_ net2708 VGND VGND VPWR VPWR _05880_ sky130_fd_sc_hd__a2111o_1
X_12749_ _05810_ _05793_ net1290 VGND VGND VPWR VPWR _05811_ sky130_fd_sc_hd__a21oi_2
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14419_ clknet_leaf_17_clk net3351 _00241_ VGND VGND VPWR VPWR adder_inst.man_b_r\[9\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_96_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_6_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
X_09960_ net808 _03035_ _03038_ _02803_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__a22oi_1
X_08911_ _01995_ _01969_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__nand2_2
X_09891_ _02890_ net586 _02897_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_127_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08842_ _01732_ _01738_ _01736_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__o21a_1
XFILLER_69_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08773_ _01856_ _01857_ _01847_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__and3_2
X_07724_ _00806_ _00807_ _00808_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_0_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07655_ _00650_ _00740_ _00739_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__a21oi_1
X_07586_ _00663_ net716 _00670_ VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_105_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09325_ _02397_ _02399_ _02400_ _02408_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__a31oi_2
X_09256_ _02025_ _02030_ _02028_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_138_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08207_ _01081_ _01083_ net1269 net1128 VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_119_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09187_ _02267_ _02199_ _01488_ _02268_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__o22ai_4
XFILLER_135_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08138_ net1619 net1654 net2291 net2315 VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__nand4_4
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08069_ _01128_ _01133_ net701 net699 VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_8_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10100_ net1118 net1109 net1015 _03179_ _03183_ VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__o32a_4
X_11080_ _03994_ net518 _03997_ net424 net425 VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__a32oi_4
XFILLER_108_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10031_ _02918_ _02920_ _02922_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__o21a_1
XFILLER_103_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13721_ _06591_ _06730_ net149 _06595_ VGND VGND VPWR VPWR _06733_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_67_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11982_ _05065_ _05061_ _05064_ net551 VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__a31o_1
XFILLER_16_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10933_ net2266 net2297 net1955 net1981 _03953_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__a41o_1
X_13652_ net172 net170 _06665_ _06666_ VGND VGND VPWR VPWR _06672_ sky130_fd_sc_hd__a2bb2o_4
XTAP_TAPCELL_ROW_80_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10864_ net2297 net1953 net1981 net2266 VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__a22oi_4
X_13583_ _06554_ _06555_ VGND VGND VPWR VPWR _06612_ sky130_fd_sc_hd__nand2_1
X_12603_ net2005 net1277 VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__nand2b_1
X_10795_ _03880_ _03874_ _03879_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__and3_4
X_12534_ _07066_ _05511_ _05512_ VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__and3_1
XFILLER_129_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12465_ net130 _05546_ _05549_ VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__a21oi_1
XFILLER_126_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_49_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14204_ net2889 VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__inv_2
X_12396_ _05480_ _05481_ VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__or2_1
X_11416_ _04495_ _04496_ _04498_ _04445_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__o2bb2ai_2
X_14135_ net2890 VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11347_ net1676 net2623 VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__nand2_1
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11278_ _04362_ _04363_ _04358_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__a21oi_1
X_14066_ net2830 VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__inv_2
XFILLER_79_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13017_ net2013 net1285 VGND VGND VPWR VPWR _06047_ sky130_fd_sc_hd__and2b_1
X_10229_ _03298_ _03301_ _03313_ net802 VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__o211a_1
X_13919_ net125 _05625_ VGND VGND VPWR VPWR _06864_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_122_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07440_ net2102 net1594 VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__nand2_1
XFILLER_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07371_ _07091_ _00446_ _00453_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__nand3_1
XFILLER_50_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09110_ _02194_ _02195_ _02190_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__and3_4
XFILLER_31_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09041_ _01304_ _01305_ _01308_ _01297_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__o22ai_2
XFILLER_116_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold423 adder_inst.i_b\[3\] VGND VGND VPWR VPWR net3341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold434 adder_inst.i_b\[7\] VGND VGND VPWR VPWR net3352 sky130_fd_sc_hd__dlygate4sd3_1
Xhold445 adder_inst.i_a\[8\] VGND VGND VPWR VPWR net3363 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold478 add_res\[19\] VGND VGND VPWR VPWR net3396 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold467 adder_inst.exp_a\[1\] VGND VGND VPWR VPWR net3385 sky130_fd_sc_hd__dlygate4sd3_1
Xhold456 adder_inst.i_a\[5\] VGND VGND VPWR VPWR net3374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold489 multiplier_inst.man_final_r\[7\] VGND VGND VPWR VPWR net3407 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout903 net904 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__clkbuf_4
Xfanout925 net934 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__clkbuf_2
X_09943_ net2177 net1944 VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__nand2_1
Xfanout914 net915 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout958 net959 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__buf_2
Xfanout947 net948 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__clkbuf_2
Xfanout936 net938 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__clkbuf_2
X_09874_ net1405 net2636 VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__nand2_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout969 _00983_ VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__clkbuf_2
X_08825_ _01900_ _01903_ _01905_ _01831_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_107_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08756_ _01835_ _01633_ _01834_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__a21oi_4
XFILLER_72_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07707_ _00681_ _00682_ _00601_ VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__a21oi_1
X_08687_ net1357 net1384 net2470 net2505 VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__nand4_4
XFILLER_72_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07638_ net705 _00723_ net704 VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__a21bo_1
XFILLER_41_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07569_ _00651_ _00652_ _00653_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_62_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09308_ _02385_ _02386_ _02388_ _02377_ _02376_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_62_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10580_ net427 _03665_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__nand2_1
X_09239_ _01950_ _01952_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__nand2_1
XFILLER_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12250_ _01011_ net477 _01034_ _01035_ VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_5_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12181_ _05261_ _05264_ _05265_ _05266_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__a2bb2o_1
X_11201_ net1176 net1133 VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__nor2_1
XFILLER_135_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11132_ net2973 _04217_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__nand2_1
XFILLER_134_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11063_ _03839_ _03840_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__nand2_1
XFILLER_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10014_ net1730 net2378 VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__nand2_1
XFILLER_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11965_ _05046_ _05047_ _05048_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__nand3_1
X_13704_ _06359_ _06711_ _06717_ net760 VGND VGND VPWR VPWR _06718_ sky130_fd_sc_hd__a211oi_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10916_ _03998_ _03993_ _03999_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__nand3_2
X_13635_ _06459_ _06462_ net856 _06655_ VGND VGND VPWR VPWR _06657_ sky130_fd_sc_hd__o211a_1
X_11896_ _04978_ _04976_ _04977_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__nand3_1
XFILLER_13_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10847_ net1793 net2415 net1813 net2445 VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__nand4_2
X_13566_ net771 net538 _06322_ _06323_ _06594_ VGND VGND VPWR VPWR _06595_ sky130_fd_sc_hd__a311o_1
XPHY_EDGE_ROW_57_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10778_ _03859_ net390 _03861_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__a21oi_4
X_12517_ _00817_ _05596_ VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__xor2_2
X_13497_ net291 _06163_ _06525_ net335 net307 VGND VGND VPWR VPWR _06526_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_30_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12448_ net165 _05320_ VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_10_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12379_ _07040_ _07045_ _07047_ _05442_ _05443_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__a2111o_1
XFILLER_140_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14118_ net2819 VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__inv_2
XFILLER_140_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14049_ net2880 VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__inv_2
X_08610_ net941 _01682_ _01693_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__o21ai_2
XFILLER_55_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09590_ _02244_ _02262_ _02263_ _02265_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__nand4_1
X_08541_ _01622_ _01623_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__nand2_4
XFILLER_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08472_ net332 _01550_ _01552_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__nand3_1
X_07423_ _00505_ _00506_ _00507_ _00458_ _00456_ VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_102_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07354_ _00434_ _00437_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_135_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07285_ net1342 _06955_ net2163 _06953_ _07054_ VGND VGND VPWR VPWR _07056_ sky130_fd_sc_hd__a311oi_2
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09024_ net2119 net1904 VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__nand2_1
XFILLER_129_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout700 _01149_ VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__clkbuf_1
XFILLER_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout722 _00104_ VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__buf_1
Xfanout733 net734 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__clkbuf_2
X_09926_ _02710_ net812 _02999_ _02997_ VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__o31a_1
Xfanout1709 adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR net1709 sky130_fd_sc_hd__clkbuf_2
Xfanout711 _03302_ VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__clkbuf_2
Xfanout755 net756 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__buf_1
Xfanout744 net745 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_86_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout766 net767 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout788 net789 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__clkbuf_1
Xfanout777 net778 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_2
Xfanout799 _03920_ VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__clkbuf_1
X_09857_ _02923_ _02928_ _02929_ net663 _02942_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__a32oi_2
X_08808_ _01891_ _01892_ net2020 net1851 VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__nand4b_2
XFILLER_73_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09788_ _02166_ _02640_ net1672 net2377 _02639_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__o2111ai_1
X_08739_ _01820_ _01822_ _01823_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__a21oi_2
XFILLER_65_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_115 net2564 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_104 net1439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11750_ _04682_ _04833_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_37_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10701_ _03614_ net879 net1580 net2591 VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__and4_1
XFILLER_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11681_ _04550_ _04551_ _04556_ VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__a21o_1
X_13420_ net511 _06445_ _06446_ _06447_ VGND VGND VPWR VPWR _06449_ sky130_fd_sc_hd__o211a_1
X_10632_ net800 net1845 net2351 net877 VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__nand4_1
X_13351_ net2000 net1088 net730 net605 net1205 VGND VGND VPWR VPWR _06380_ sky130_fd_sc_hd__o221a_1
X_10563_ _03638_ _03639_ _03640_ net571 _03647_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__a32o_1
X_12302_ _05338_ net382 _05343_ VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__a21o_1
Xrebuffer350 net378 VGND VGND VPWR VPWR net1668 sky130_fd_sc_hd__buf_2
XFILLER_108_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13282_ _06307_ _06305_ net231 net3228 VGND VGND VPWR VPWR _06311_ sky130_fd_sc_hd__o211ai_4
Xrebuffer361 _06058_ VGND VGND VPWR VPWR net1924 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer383 net3294 VGND VGND VPWR VPWR net3301 sky130_fd_sc_hd__buf_6
XFILLER_6_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10494_ _03567_ _03568_ _03564_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_75_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12233_ _03473_ _03474_ _03472_ VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__a21o_1
XFILLER_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2911 net2912 VGND VGND VPWR VPWR net2911 sky130_fd_sc_hd__clkbuf_2
XFILLER_122_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2900 net2904 VGND VGND VPWR VPWR net2900 sky130_fd_sc_hd__buf_1
X_12164_ _05216_ _05244_ _05246_ _05240_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__or4_4
XFILLER_122_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11115_ _04200_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__inv_2
X_12095_ net617 _05091_ net618 VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__a21o_4
X_11046_ _04131_ net423 _04078_ _04081_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_92_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12997_ net1061 _05791_ net1293 _05795_ _05796_ VGND VGND VPWR VPWR _06032_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_35_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11948_ _05031_ _05029_ _05030_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_15_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11879_ _04963_ _04849_ _04958_ _04964_ VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__o211ai_4
X_13618_ _06506_ _06642_ VGND VGND VPWR VPWR adder_inst.sum_raw\[4\] sky130_fd_sc_hd__xnor2_1
X_13549_ net172 net170 VGND VGND VPWR VPWR _06578_ sky130_fd_sc_hd__nor2_1
XFILLER_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07972_ _00928_ _00920_ _00919_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__nand3_1
X_09711_ _02747_ _02794_ VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__nand2_1
XFILLER_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09642_ net668 VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__inv_2
XFILLER_27_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09573_ _02628_ _02629_ _02622_ _02653_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__a31oi_1
X_08524_ _01583_ _01604_ _01605_ _01582_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_46_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08455_ _01537_ _01516_ _01536_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__nand3_2
X_07406_ net1446 net1478 net2161 net2193 VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__and4_1
XFILLER_51_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08386_ _01453_ _01463_ net1410 net2528 _01468_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__o2111ai_1
X_07337_ net2075 net1565 VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__nand2_1
XFILLER_109_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07268_ _06961_ _07033_ _07038_ net3034 _07037_ VGND VGND VPWR VPWR _07039_ sky130_fd_sc_hd__o221ai_4
XFILLER_124_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07199_ _06934_ _06968_ VGND VGND VPWR VPWR _06970_ sky130_fd_sc_hd__nand2_1
X_09007_ net929 net1049 net2090 net1928 _01285_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__o2111ai_4
XFILLER_105_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2207 net2208 VGND VGND VPWR VPWR net2207 sky130_fd_sc_hd__buf_6
Xfanout2218 net2220 VGND VGND VPWR VPWR net2218 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1506 net1514 VGND VGND VPWR VPWR net1506 sky130_fd_sc_hd__clkbuf_2
Xfanout2229 net2231 VGND VGND VPWR VPWR net2229 sky130_fd_sc_hd__buf_6
XFILLER_116_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1528 net1531 VGND VGND VPWR VPWR net1528 sky130_fd_sc_hd__clkbuf_2
Xfanout530 net531 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__clkbuf_1
Xfanout1539 net1540 VGND VGND VPWR VPWR net1539 sky130_fd_sc_hd__clkbuf_2
Xfanout541 net544 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1517 net1518 VGND VGND VPWR VPWR net1517 sky130_fd_sc_hd__buf_1
XFILLER_116_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09909_ _02713_ net2663 net1330 _02710_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__a31o_1
Xfanout552 _04971_ VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout563 _04123_ VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__clkbuf_2
X_12920_ _05966_ _05967_ net242 VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__o21a_1
Xfanout596 _00856_ VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout585 net586 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__clkbuf_2
XFILLER_132_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12851_ net1076 net1072 net2787 net2746 VGND VGND VPWR VPWR _05907_ sky130_fd_sc_hd__and4_1
XFILLER_132_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11802_ _04869_ _04876_ _04883_ _04886_ _04887_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__o2111ai_2
X_12782_ net1071 net1058 VGND VGND VPWR VPWR _05844_ sky130_fd_sc_hd__nand2_2
XFILLER_73_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer90 _05125_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlymetal6s2s_1
X_14521_ clknet_leaf_5_clk multiplier_inst.man_final\[21\] _00343_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[21\] sky130_fd_sc_hd__dfrtp_1
X_11733_ _04815_ _04816_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__nand2_2
X_14452_ clknet_leaf_1_clk _00037_ _00274_ VGND VGND VPWR VPWR add_res\[10\] sky130_fd_sc_hd__dfrtp_1
X_11664_ net448 net553 net710 VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__and3_1
X_13403_ net361 net297 _06399_ _06400_ VGND VGND VPWR VPWR _06432_ sky130_fd_sc_hd__o211ai_4
X_10615_ _03487_ _03490_ _03491_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__a21oi_2
X_14383_ clknet_leaf_15_clk net3368 _00205_ VGND VGND VPWR VPWR adder_inst.man_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_11595_ net1857 net2547 VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__nand2_1
XFILLER_128_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13334_ net358 net362 net340 _06209_ VGND VGND VPWR VPWR _06363_ sky130_fd_sc_hd__nand4_2
X_10546_ _03398_ _03400_ _03401_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__nand3_1
Xrebuffer180 _02309_ VGND VGND VPWR VPWR net3098 sky130_fd_sc_hd__dlymetal6s2s_1
X_13265_ net790 _06180_ net413 net3169 net312 VGND VGND VPWR VPWR _06294_ sky130_fd_sc_hd__o2111ai_1
Xrebuffer191 net3108 VGND VGND VPWR VPWR net3109 sky130_fd_sc_hd__dlymetal6s2s_1
X_10477_ net1670 net2501 VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__nand2_1
XFILLER_142_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12216_ _05151_ _05153_ _05300_ _04988_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__nand4b_4
XFILLER_6_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2730 net2736 VGND VGND VPWR VPWR net2730 sky130_fd_sc_hd__buf_4
X_13196_ net272 _06224_ _06225_ VGND VGND VPWR VPWR _06226_ sky130_fd_sc_hd__o21ai_2
Xfanout2741 net2744 VGND VGND VPWR VPWR net2741 sky130_fd_sc_hd__buf_1
Xfanout2752 net2753 VGND VGND VPWR VPWR net2752 sky130_fd_sc_hd__buf_1
Xfanout2763 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR net2763 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12147_ _05168_ _05179_ _05232_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__o21ai_1
Xfanout2796 net2800 VGND VGND VPWR VPWR net2796 sky130_fd_sc_hd__buf_1
Xfanout2774 net2775 VGND VGND VPWR VPWR net2774 sky130_fd_sc_hd__buf_1
Xfanout2785 net2786 VGND VGND VPWR VPWR net2785 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12078_ net1939 net2630 VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__nand2_1
XFILLER_110_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11029_ _04106_ _04107_ _04113_ net640 VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__o211ai_4
XFILLER_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08240_ _01128_ _01131_ _01132_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__a21oi_2
XFILLER_21_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_48 net1428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_15 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08171_ _01243_ _01251_ _01252_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__nand3_2
XANTENNA_37 net1178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_26 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_59 net2087 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07122_ net2428 VGND VGND VPWR VPWR _06894_ sky130_fd_sc_hd__inv_2
XFILLER_118_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net100 VGND VGND VPWR VPWR o_res_vld sky130_fd_sc_hd__buf_2
XFILLER_133_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07955_ net409 _00980_ _01037_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_110_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07886_ _00971_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__inv_2
X_09625_ net1355 net1382 net2616 net2638 VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__nand4_2
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09556_ net1674 net2377 VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__nand2_1
X_08507_ net2331 net2361 net1034 VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__and3_1
XFILLER_62_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09487_ net2207 net1848 net813 _02570_ VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__a22oi_2
X_08438_ net1555 net2345 net2371 net1525 VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__a22oi_2
XFILLER_24_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08369_ net1468 net2497 net2527 net1435 VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__a22o_1
XFILLER_109_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10400_ net2249 net1952 net1970 net2208 VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_12_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11380_ _04451_ _04452_ _04465_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__a21o_1
XFILLER_125_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10331_ net1264 net1093 _03196_ _03197_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__o211ai_1
XFILLER_3_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_791 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13050_ net706 net505 _05687_ _06077_ VGND VGND VPWR VPWR _06080_ sky130_fd_sc_hd__o211ai_4
X_10262_ _03168_ _03170_ net1572 net2532 VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__and4_1
XFILLER_105_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2015 net2016 VGND VGND VPWR VPWR net2015 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2004 adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR net2004 sky130_fd_sc_hd__buf_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12001_ _04992_ _04993_ net1939 net2572 VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__nand4_1
Xfanout1314 adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR net1314 sky130_fd_sc_hd__clkbuf_2
Xfanout1303 adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR net1303 sky130_fd_sc_hd__buf_1
Xfanout2026 net2027 VGND VGND VPWR VPWR net2026 sky130_fd_sc_hd__clkbuf_2
Xfanout2048 net2052 VGND VGND VPWR VPWR net2048 sky130_fd_sc_hd__buf_1
Xfanout2059 net2060 VGND VGND VPWR VPWR net2059 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_78_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2037 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR net2037 sky130_fd_sc_hd__clkbuf_2
X_10193_ _03276_ _03277_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__nand2_1
Xfanout1325 net1327 VGND VGND VPWR VPWR net1325 sky130_fd_sc_hd__buf_1
Xfanout1347 net1348 VGND VGND VPWR VPWR net1347 sky130_fd_sc_hd__buf_1
Xfanout1336 net1350 VGND VGND VPWR VPWR net1336 sky130_fd_sc_hd__clkbuf_2
X_13952_ net3454 mul_res\[16\] net2797 VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__mux2_1
XFILLER_120_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout382 _05340_ VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__buf_4
Xfanout1369 net1374 VGND VGND VPWR VPWR net1369 sky130_fd_sc_hd__buf_1
Xfanout1358 net1362 VGND VGND VPWR VPWR net1358 sky130_fd_sc_hd__clkbuf_2
Xfanout371 net372 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_1
Xfanout360 net361 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_6_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout393 _03097_ VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__buf_6
X_12903_ net2771 net2741 net1082 VGND VGND VPWR VPWR _05952_ sky130_fd_sc_hd__or3_1
XFILLER_59_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_21_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13883_ _05569_ _06831_ _06834_ _06837_ _06839_ VGND VGND VPWR VPWR multiplier_inst.man_final\[6\]
+ sky130_fd_sc_hd__a41oi_1
X_12834_ net1084 net2782 net2783 net751 VGND VGND VPWR VPWR _05894_ sky130_fd_sc_hd__o22a_1
XFILLER_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12765_ net1287 _05817_ net707 VGND VGND VPWR VPWR _05827_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_83_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14504_ clknet_leaf_20_clk multiplier_inst.man_final\[4\] _00326_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_11716_ _04790_ net2987 _04660_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12696_ adder_inst.is_zero_b_r adder_inst.is_zero_a_r VGND VGND VPWR VPWR _00035_
+ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_25_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14435_ clknet_leaf_6_clk net3333 _00257_ VGND VGND VPWR VPWR adder_inst.i_vld_r
+ sky130_fd_sc_hd__dfrtp_1
Xinput13 i_a[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_11647_ _04724_ _04725_ _04726_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_30_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14366_ clknet_leaf_1_clk adder_inst.sum_raw\[15\] _00188_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[15\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput24 i_a[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
X_11578_ net2422 net1984 VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__nand2_1
XFILLER_7_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 i_b[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput46 i_b[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_114_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput57 i_b[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
X_13317_ net262 _06216_ _06217_ net2140 VGND VGND VPWR VPWR _06346_ sky130_fd_sc_hd__o211ai_2
X_10529_ net1603 net1638 net2532 net2558 VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__nand4_1
XFILLER_115_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14297_ clknet_leaf_18_clk net3 _00119_ VGND VGND VPWR VPWR adder_inst.i_a\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_124_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13248_ _06276_ VGND VGND VPWR VPWR _06277_ sky130_fd_sc_hd__inv_2
XFILLER_123_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13179_ net1614 net2298 net483 VGND VGND VPWR VPWR _06209_ sky130_fd_sc_hd__mux2_1
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2571 net2572 VGND VGND VPWR VPWR net2571 sky130_fd_sc_hd__clkbuf_2
Xfanout2560 net2564 VGND VGND VPWR VPWR net2560 sky130_fd_sc_hd__buf_4
X_07740_ _00823_ _00824_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__nand2_1
XFILLER_96_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1870 net1871 VGND VGND VPWR VPWR net1870 sky130_fd_sc_hd__buf_1
Xfanout2593 net2595 VGND VGND VPWR VPWR net2593 sky130_fd_sc_hd__buf_1
Xfanout2582 net2583 VGND VGND VPWR VPWR net2582 sky130_fd_sc_hd__buf_1
XFILLER_38_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1881 net1882 VGND VGND VPWR VPWR net1881 sky130_fd_sc_hd__buf_4
Xfanout1892 net1893 VGND VGND VPWR VPWR net1892 sky130_fd_sc_hd__buf_1
X_07671_ net599 _00756_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_125_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09410_ _00942_ net1779 net2022 VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__and3_1
XFILLER_52_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09341_ net435 _02425_ _02426_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__a21bo_1
XFILLER_139_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09272_ _02346_ _02349_ _02353_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__nand3_1
XFILLER_60_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08223_ _01291_ _01295_ _01296_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__nand3_4
XFILLER_21_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08154_ _01236_ _01238_ _01235_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__a21o_1
XFILLER_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08085_ _01164_ _01168_ _01162_ _01167_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__o211ai_4
X_07105_ net1403 VGND VGND VPWR VPWR _06877_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08987_ _01944_ _02069_ _02070_ VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__nand3_2
XFILLER_75_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07938_ net1441 net1473 net2303 net2333 VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_3_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07869_ _00950_ _00951_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__nand2_2
X_10880_ _03951_ _03954_ _03957_ _03697_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__a22o_1
X_09608_ _02683_ _02688_ _02691_ _02692_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__a2bb2o_4
X_09539_ _02183_ _02185_ net676 VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_42_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12550_ _05632_ _05635_ VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_65_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12481_ net3135 _05566_ net2925 VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_22_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11501_ net564 _04047_ _04069_ _04072_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__nand4_1
X_14220_ net2882 VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__inv_2
XFILLER_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11432_ _04059_ _04063_ _04512_ _04515_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__o211ai_4
X_14151_ net2871 VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__inv_2
XFILLER_137_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13102_ _06049_ _06130_ net787 net507 VGND VGND VPWR VPWR _06132_ sky130_fd_sc_hd__a2bb2o_1
X_11363_ _04438_ _04443_ _04442_ _04423_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__o211ai_1
XFILLER_125_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14082_ net2822 VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__inv_2
X_10314_ net1520 net1547 net2585 net2611 VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__nand4_4
X_11294_ net636 _04307_ _04308_ _04309_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_105_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13033_ net2003 net860 adder_inst.exp_b_r\[5\] VGND VGND VPWR VPWR _06063_ sky130_fd_sc_hd__o21ba_2
X_10245_ net1696 net2438 VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__nand2_1
XFILLER_121_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1111 net1115 VGND VGND VPWR VPWR net1111 sky130_fd_sc_hd__buf_2
Xfanout1100 net1101 VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__buf_8
X_10176_ net2249 net1925 VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__nand2_1
Xfanout1122 _06903_ VGND VGND VPWR VPWR net1122 sky130_fd_sc_hd__clkbuf_2
Xfanout1133 net1135 VGND VGND VPWR VPWR net1133 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1155 net1157 VGND VGND VPWR VPWR net1155 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1144 net1145 VGND VGND VPWR VPWR net1144 sky130_fd_sc_hd__buf_4
Xfanout1188 net1190 VGND VGND VPWR VPWR net1188 sky130_fd_sc_hd__clkbuf_2
Xfanout1177 net1178 VGND VGND VPWR VPWR net1177 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1166 _06896_ VGND VGND VPWR VPWR net1166 sky130_fd_sc_hd__clkbuf_4
Xfanout1199 _06892_ VGND VGND VPWR VPWR net1199 sky130_fd_sc_hd__clkbuf_2
Xfanout190 _03470_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_6
X_13935_ add_ovf net3463 net2789 VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__mux2_1
X_13866_ _05550_ _05551_ _06826_ VGND VGND VPWR VPWR _06827_ sky130_fd_sc_hd__a21oi_1
XFILLER_35_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12817_ net1304 net1296 VGND VGND VPWR VPWR _05879_ sky130_fd_sc_hd__xnor2_1
X_13797_ net3399 net726 VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__and2_1
X_12748_ _05809_ net1069 net1294 _05794_ net2701 VGND VGND VPWR VPWR _05810_ sky130_fd_sc_hd__a2111o_1
XFILLER_15_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12679_ adder_inst.i_b\[1\] adder_inst.i_b\[0\] adder_inst.i_b\[3\] adder_inst.i_b\[2\]
+ VGND VGND VPWR VPWR _05754_ sky130_fd_sc_hd__or4_1
XFILLER_129_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14418_ clknet_leaf_17_clk net3337 _00240_ VGND VGND VPWR VPWR adder_inst.man_b_r\[8\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire591 _02018_ VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__buf_1
X_14349_ clknet_leaf_7_clk net57 _00171_ VGND VGND VPWR VPWR adder_inst.i_b\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_7_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08910_ _01967_ _01968_ _01992_ _01994_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__o211ai_2
X_09890_ net457 VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__inv_2
X_08841_ _01923_ _01922_ _01744_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__nand3_4
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08772_ _01650_ _01846_ _01854_ _01855_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__o211ai_2
Xfanout2390 net2394 VGND VGND VPWR VPWR net2390 sky130_fd_sc_hd__clkbuf_2
X_07723_ _00796_ _00805_ _00808_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_0_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07654_ net1267 net1225 _00648_ _00649_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_0_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07585_ _00663_ net716 _00670_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_105_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09324_ _02403_ _02405_ _02408_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__nand3_1
XFILLER_80_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09255_ _02025_ net905 _02028_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_138_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08206_ _01077_ _01078_ net828 VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09186_ _02196_ _02201_ _02269_ _01489_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__o211ai_4
XFILLER_107_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08137_ net1651 net2315 VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__nand2_1
XFILLER_134_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08068_ net700 net698 net714 VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__and3_1
XFILLER_134_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10030_ _02918_ _02920_ net1574 net2501 VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__o211a_1
XFILLER_124_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11981_ _05050_ _05060_ _05062_ _05063_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__o211ai_1
XFILLER_29_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13720_ net149 net158 _06731_ _06595_ VGND VGND VPWR VPWR _06732_ sky130_fd_sc_hd__a22o_1
XFILLER_84_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10932_ _04011_ _04016_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__nand2_1
XFILLER_44_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13651_ net172 _06669_ net134 net762 _06670_ VGND VGND VPWR VPWR _06671_ sky130_fd_sc_hd__o311a_4
XTAP_TAPCELL_ROW_80_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10863_ net2267 net1981 VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__nand2_1
XFILLER_44_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13582_ net155 VGND VGND VPWR VPWR _06611_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_80_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12602_ net1277 net2005 VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__nand2b_1
X_10794_ _03670_ _03876_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__nand2_2
XFILLER_129_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12533_ _05613_ _05618_ VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__nand2_2
XFILLER_129_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14203_ net2905 VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__inv_2
X_12464_ _05545_ net130 _05534_ _05542_ VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__o211a_1
X_12395_ _05457_ _05458_ _05459_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__and3_1
X_11415_ _04423_ _04445_ _04495_ _04496_ _04442_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__o2111ai_4
X_14134_ net2907 VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__inv_2
XFILLER_137_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11346_ _04430_ _04426_ _04429_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__o21ai_1
X_14065_ net2835 VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_91_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13016_ _05644_ _05646_ _05654_ _05655_ VGND VGND VPWR VPWR _06046_ sky130_fd_sc_hd__nand4_2
X_11277_ net795 net1935 net2422 net865 VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__nand4_2
XFILLER_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10228_ net711 _03313_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__nor2_1
XFILLER_39_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10159_ _03026_ _03027_ net2993 _03240_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__nand4_2
XFILLER_75_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13918_ _06863_ _06862_ VGND VGND VPWR VPWR multiplier_inst.man_final\[17\] sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_122_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13849_ _06798_ _06796_ _06795_ _06811_ _06809_ VGND VGND VPWR VPWR _06812_ sky130_fd_sc_hd__a2111o_4
X_07370_ _07091_ _00446_ _00453_ VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__and3_1
XFILLER_16_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09040_ _01306_ _01307_ _01309_ _01298_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__o211ai_2
XFILLER_117_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold424 adder_inst.i_a\[2\] VGND VGND VPWR VPWR net3342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold435 adder_inst.i_b\[15\] VGND VGND VPWR VPWR net3353 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold446 adder_inst.exp_b\[0\] VGND VGND VPWR VPWR net3364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold468 adder_inst.exp_a\[3\] VGND VGND VPWR VPWR net3386 sky130_fd_sc_hd__dlygate4sd3_1
Xhold457 adder_inst.exp_a\[7\] VGND VGND VPWR VPWR net3375 sky130_fd_sc_hd__dlygate4sd3_1
X_09942_ net2149 net1969 VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__nand2_1
Xhold479 _00010_ VGND VGND VPWR VPWR net3397 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout904 _02114_ VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__clkbuf_2
Xfanout915 net916 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout948 _01129_ VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__buf_6
Xfanout926 net934 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__clkbuf_1
X_09873_ net1430 net1460 net2582 net2608 VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__nand4_4
Xfanout937 net938 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlymetal6s2s_1
X_08824_ _01871_ _01902_ _01831_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__o21ai_4
Xfanout959 net960 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__clkbuf_2
X_08755_ net1591 net2274 _01837_ _01839_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__a22o_1
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07706_ _00791_ _00708_ _00790_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_107_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08686_ net1384 net2470 net2504 net1357 VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__a22o_1
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07637_ _00722_ _00719_ net991 VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__o21ai_2
X_07568_ _00652_ _00653_ _00651_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__a21o_1
XFILLER_110_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09307_ _02376_ net815 _02388_ _02389_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__a22oi_2
XFILLER_70_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07499_ _00584_ _00572_ _00570_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__nand3_1
X_09238_ net1168 net1162 net1052 _01952_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_32_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09169_ _02251_ _02254_ _02253_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__a21bo_1
XFILLER_135_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12180_ net1137 net1099 _05218_ _05220_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__or4b_1
X_11200_ _04283_ _04284_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__nand2_1
XFILLER_102_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11131_ net2969 net3073 _04212_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__nand3_4
XFILLER_103_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11062_ _04143_ _04146_ _04147_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__nor3_1
X_10013_ _03090_ _03095_ _03096_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__nand3_2
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11964_ _05023_ _05043_ _05047_ _05048_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__o211a_1
X_13703_ net519 net1224 _06351_ net186 VGND VGND VPWR VPWR _06717_ sky130_fd_sc_hd__a211oi_2
X_11895_ _04976_ _04979_ _04980_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__nand3b_4
X_10915_ _03994_ _03996_ _03997_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__nand3_4
X_13634_ _06459_ _06462_ net1783 _06651_ VGND VGND VPWR VPWR _06656_ sky130_fd_sc_hd__o211ai_2
XFILLER_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10846_ net1789 net2416 net1821 net2445 VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__and4_1
X_13565_ net490 _06322_ _06324_ VGND VGND VPWR VPWR _06594_ sky130_fd_sc_hd__a21oi_2
XFILLER_9_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10777_ _03859_ _03821_ _03861_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__a21o_1
X_12516_ net143 net317 _05589_ VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__nand3_1
X_13496_ net290 _06144_ VGND VGND VPWR VPWR _06525_ sky130_fd_sc_hd__nand2_4
X_12447_ _05531_ _05532_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12378_ _07042_ _07044_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__nand2_1
X_14117_ net2810 VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__inv_2
XFILLER_4_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11329_ _04413_ net559 _04384_ _04379_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__o2bb2ai_4
X_14048_ net2879 VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__inv_2
XFILLER_86_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08540_ _01615_ _01625_ _01624_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__o21ai_1
XFILLER_47_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08471_ _01394_ _01553_ _01555_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__nand3_1
X_07422_ _00505_ _00506_ _00507_ VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_18_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07353_ _00422_ _00433_ _00435_ _00436_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_135_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07284_ _06953_ _06957_ _07054_ VGND VGND VPWR VPWR _07055_ sky130_fd_sc_hd__o21a_1
X_09023_ net2170 net1849 VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__nand2_1
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout723 net725 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__buf_1
Xfanout712 _02010_ VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout701 _01149_ VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__buf_1
X_09925_ _03004_ _03006_ _03007_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__nand3_2
Xfanout756 net759 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__buf_1
Xfanout745 _05854_ VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout767 multiplier_inst.sign_res VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__buf_1
Xfanout734 _06071_ VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__buf_6
X_09856_ _02937_ net2581 net1494 _02934_ VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__a31o_1
XFILLER_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08807_ _01890_ _01873_ _01889_ _01678_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__a31o_1
Xfanout778 net781 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__clkbuf_2
Xfanout789 net790 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__clkbuf_2
XFILLER_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09787_ net1671 net2377 _02639_ _02641_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__a22o_1
X_08738_ _01607_ _01610_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__nor2_1
XFILLER_26_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_116 net2574 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_105 net1470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08669_ _01751_ net821 _01752_ _01749_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_37_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10700_ net1580 net2591 _03614_ net879 VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__a22oi_2
X_11680_ _04762_ _04764_ _04765_ VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__nand3_4
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10631_ _03714_ _03708_ net877 VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__and3_4
X_13350_ net521 _06373_ _06375_ _06377_ VGND VGND VPWR VPWR _06379_ sky130_fd_sc_hd__o211ai_2
XFILLER_10_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10562_ net884 _03646_ net571 VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__o21a_1
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12301_ _02483_ _02479_ _02482_ _05338_ net382 VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__o2111ai_1
X_13281_ net338 net299 _06267_ _06266_ VGND VGND VPWR VPWR _06310_ sky130_fd_sc_hd__o211ai_1
Xrebuffer340 net1571 VGND VGND VPWR VPWR net1542 sky130_fd_sc_hd__buf_6
Xrebuffer351 net295 VGND VGND VPWR VPWR net1693 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer384 _06235_ VGND VGND VPWR VPWR net3302 sky130_fd_sc_hd__clkbuf_2
Xrebuffer362 _06128_ VGND VGND VPWR VPWR net1943 sky130_fd_sc_hd__dlygate4sd1_1
X_12232_ _03253_ _03254_ _03255_ VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__o21ai_4
XFILLER_6_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10493_ _03333_ _03335_ _03336_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__a21o_1
XFILLER_135_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2912 net2914 VGND VGND VPWR VPWR net2912 sky130_fd_sc_hd__buf_2
XFILLER_123_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2901 net2903 VGND VGND VPWR VPWR net2901 sky130_fd_sc_hd__clkbuf_2
X_12163_ net3124 _05211_ _05248_ VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__a21oi_1
XFILLER_123_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11114_ _04148_ _04157_ _04156_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__a21bo_1
X_12094_ _05169_ _05179_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__nand2_2
XFILLER_122_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11045_ _04128_ _04130_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__nand2_1
XFILLER_1_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12996_ net2709 _05808_ net2715 net1294 VGND VGND VPWR VPWR _06031_ sky130_fd_sc_hd__or4b_1
XFILLER_92_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11947_ _04938_ _04939_ _04940_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_86_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11878_ _04959_ _04867_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__nand2_1
X_13617_ net765 _06640_ _06641_ _06639_ VGND VGND VPWR VPWR _06642_ sky130_fd_sc_hd__o31a_1
XFILLER_20_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10829_ net1183 net1169 _03746_ _03748_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__o211ai_4
X_13548_ _06446_ _06448_ VGND VGND VPWR VPWR _06577_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_117_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13479_ net1089 net1273 net602 net3298 net1113 VGND VGND VPWR VPWR _06508_ sky130_fd_sc_hd__a221o_1
XFILLER_65_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07971_ _00919_ _00920_ _00928_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__a21o_1
XFILLER_102_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09710_ net250 _02747_ _02750_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__nand3_2
XFILLER_83_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09641_ _02725_ _02722_ _02724_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__nand3b_4
X_09572_ net461 net589 _02652_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__a21oi_1
X_08523_ _01580_ _01581_ net471 net470 VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_46_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08454_ _01537_ _01516_ _01536_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__and3_1
X_07405_ net2148 net2180 VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__nand2_2
X_08385_ _01469_ net2528 net1409 VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__nand3_1
X_07336_ _00421_ _07103_ _00420_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__nand3_2
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07267_ _06963_ _06964_ _06965_ VGND VGND VPWR VPWR _07038_ sky130_fd_sc_hd__a21oi_2
X_09006_ _01285_ _01287_ _01288_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__a21o_1
X_07198_ net2058 net2035 net1454 net1488 VGND VGND VPWR VPWR _06969_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_76_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2208 net2209 VGND VGND VPWR VPWR net2208 sky130_fd_sc_hd__buf_6
XFILLER_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2219 net2220 VGND VGND VPWR VPWR net2219 sky130_fd_sc_hd__buf_1
XFILLER_132_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1507 net1508 VGND VGND VPWR VPWR net1507 sky130_fd_sc_hd__buf_1
Xfanout1529 net1530 VGND VGND VPWR VPWR net1529 sky130_fd_sc_hd__buf_2
Xfanout531 net532 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout520 net523 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__clkbuf_1
Xfanout542 net544 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__clkbuf_1
Xfanout1518 net1520 VGND VGND VPWR VPWR net1518 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09908_ _02912_ _02916_ _02991_ _02796_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__o211ai_4
Xfanout564 _04045_ VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__buf_6
Xfanout553 _04748_ VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__buf_1
Xfanout575 _03525_ VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__buf_4
Xfanout597 _00856_ VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__buf_1
Xfanout586 _02899_ VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__buf_1
X_09839_ _02236_ _02697_ net898 net1016 VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_132_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12850_ net237 _05902_ _05906_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__and3_1
XFILLER_46_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_85_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11801_ _04732_ _04733_ _04751_ _04753_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_27_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14520_ clknet_leaf_5_clk multiplier_inst.man_final\[20\] _00342_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[20\] sky130_fd_sc_hd__dfrtp_1
X_12781_ net2709 net2699 VGND VGND VPWR VPWR _05843_ sky130_fd_sc_hd__nor2_1
Xrebuffer91 _04607_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_1
XFILLER_15_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer80 _03803_ VGND VGND VPWR VPWR net2998 sky130_fd_sc_hd__buf_2
X_11732_ net2484 net1960 net1986 net2451 VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__a22oi_2
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14451_ clknet_leaf_1_clk _00067_ _00273_ VGND VGND VPWR VPWR add_res\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11663_ net448 net553 net710 VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__a21oi_1
X_13402_ _06228_ net3309 net414 net307 _06430_ VGND VGND VPWR VPWR _06431_ sky130_fd_sc_hd__o2111ai_4
X_10614_ net987 net930 _03698_ _03695_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__o22ai_1
X_14382_ clknet_leaf_10_clk net3377 _00204_ VGND VGND VPWR VPWR adder_inst.man_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_13333_ net225 _06268_ VGND VGND VPWR VPWR _06362_ sky130_fd_sc_hd__nand2_1
X_11594_ _04671_ _04673_ _04674_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__nand3_2
XFILLER_127_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10545_ _03624_ _03627_ _03625_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__a21oi_1
XFILLER_41_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13264_ net2000 net1088 net730 net605 net1251 VGND VGND VPWR VPWR _06293_ sky130_fd_sc_hd__o221a_1
Xrebuffer192 _02107_ VGND VGND VPWR VPWR net3110 sky130_fd_sc_hd__buf_4
Xrebuffer170 _02584_ VGND VGND VPWR VPWR net3088 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer181 _04613_ VGND VGND VPWR VPWR net3099 sky130_fd_sc_hd__dlygate4sd1_1
X_10476_ net1695 net1726 net2438 net2467 VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__nand4_1
XFILLER_136_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13195_ net272 _06221_ VGND VGND VPWR VPWR _06225_ sky130_fd_sc_hd__nand2_2
X_12215_ _05146_ net196 net200 _05151_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__a31o_1
Xfanout2720 net2721 VGND VGND VPWR VPWR net2720 sky130_fd_sc_hd__buf_1
X_12146_ _05169_ _05172_ _05178_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__a21o_1
Xfanout2742 net2744 VGND VGND VPWR VPWR net2742 sky130_fd_sc_hd__buf_1
Xfanout2753 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR net2753 sky130_fd_sc_hd__clkbuf_2
Xfanout2731 net2735 VGND VGND VPWR VPWR net2731 sky130_fd_sc_hd__buf_6
XFILLER_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2797 net2800 VGND VGND VPWR VPWR net2797 sky130_fd_sc_hd__clkbuf_2
Xfanout2764 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR net2764 sky130_fd_sc_hd__buf_1
Xfanout2775 adder_inst.sum_raw_r\[6\] VGND VGND VPWR VPWR net2775 sky130_fd_sc_hd__buf_1
Xfanout2786 adder_inst.sum_raw_r\[1\] VGND VGND VPWR VPWR net2786 sky130_fd_sc_hd__buf_1
X_12077_ net1962 net2571 net1989 net2601 VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__nand4_1
XFILLER_1_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11028_ _04106_ _04107_ _04113_ net640 VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__o211a_1
X_12979_ net744 net2752 net2739 _06003_ VGND VGND VPWR VPWR _06019_ sky130_fd_sc_hd__o22a_1
XFILLER_33_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_16 adder_inst.sum_raw\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08170_ _01203_ _01242_ _01253_ _01254_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__o211ai_2
XANTENNA_38 net1178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_27 net923 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_49 net1429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07121_ net1771 VGND VGND VPWR VPWR _06893_ sky130_fd_sc_hd__inv_2
XFILLER_119_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput101 net101 VGND VGND VPWR VPWR overflow sky130_fd_sc_hd__buf_2
XFILLER_133_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07954_ net409 _00980_ _01037_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_110_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07885_ _00964_ _00969_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09624_ net1354 net1382 net2615 net2638 VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__and4_1
X_09555_ net1699 net2314 net1731 net2340 VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__nand4_2
XFILLER_36_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08506_ _01589_ _01590_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__nand2_1
X_09486_ net813 _02570_ _02565_ VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__a21oi_1
X_08437_ net1525 net1554 net2345 net2371 VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__nand4_4
XFILLER_62_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08368_ net1435 net2527 VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__nand2_1
XFILLER_109_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07319_ _07033_ _07087_ VGND VGND VPWR VPWR _07090_ sky130_fd_sc_hd__nand2_1
X_08299_ _01361_ _01373_ net593 _01383_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__o211ai_2
XFILLER_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10330_ _03196_ _03197_ net1264 net1093 VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__a211o_1
XFILLER_124_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10261_ net1572 net2532 net807 net892 VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__a22oi_1
Xfanout2016 adder_inst.is_zero_r VGND VGND VPWR VPWR net2016 sky130_fd_sc_hd__buf_1
Xfanout2005 adder_inst.exp_a_r\[4\] VGND VGND VPWR VPWR net2005 sky130_fd_sc_hd__buf_1
XFILLER_3_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12000_ net1939 net2572 _04992_ _04993_ VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__a22o_1
Xfanout1304 adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR net1304 sky130_fd_sc_hd__buf_1
Xfanout2049 net2050 VGND VGND VPWR VPWR net2049 sky130_fd_sc_hd__clkbuf_2
XFILLER_79_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2027 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR net2027 sky130_fd_sc_hd__clkbuf_2
X_10192_ net2229 net2259 net1865 net1895 VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__nand4_2
Xfanout1337 net1338 VGND VGND VPWR VPWR net1337 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1326 net1327 VGND VGND VPWR VPWR net1326 sky130_fd_sc_hd__clkbuf_1
Xfanout1315 adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR net1315 sky130_fd_sc_hd__buf_6
Xfanout1348 net1349 VGND VGND VPWR VPWR net1348 sky130_fd_sc_hd__buf_1
XFILLER_78_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout350 _03230_ VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkbuf_2
X_13951_ net3451 mul_res\[15\] net2798 VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__mux2_1
Xfanout1359 net1361 VGND VGND VPWR VPWR net1359 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout361 _06134_ VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__buf_2
Xfanout372 _06090_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkbuf_2
Xfanout383 _05125_ VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__buf_8
X_12902_ _05950_ _05951_ net239 VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__o21a_1
XFILLER_101_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout394 _02872_ VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_6_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13882_ _06838_ _06836_ VGND VGND VPWR VPWR _06839_ sky130_fd_sc_hd__nor2_1
X_12833_ net2785 net2702 net741 net2788 net835 VGND VGND VPWR VPWR _05893_ sky130_fd_sc_hd__a221o_1
X_12764_ net1291 net1289 net1287 net750 VGND VGND VPWR VPWR _05826_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_83_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14503_ clknet_leaf_20_clk multiplier_inst.man_final\[3\] _00325_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
X_11715_ _04796_ _04800_ _04642_ _04658_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_15_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12695_ adder_inst.man_a\[23\] _05768_ VGND VGND VPWR VPWR adder_inst.is_zero_a sky130_fd_sc_hd__nor2_1
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14434_ clknet_leaf_8_clk net3482 _00256_ VGND VGND VPWR VPWR adder_inst.is_nan_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11646_ _04386_ _04727_ _04729_ _04723_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__o211ai_2
X_14365_ clknet_leaf_1_clk adder_inst.sum_raw\[14\] _00187_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[14\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput25 i_a[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
X_11577_ _04639_ _04660_ _04608_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__nand3_2
Xinput36 i_b[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput14 i_a[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13316_ net488 _06339_ _06340_ _06343_ VGND VGND VPWR VPWR _06345_ sky130_fd_sc_hd__o211a_1
XFILLER_10_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput58 i_b[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput47 i_b[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_14296_ clknet_leaf_18_clk net2 _00118_ VGND VGND VPWR VPWR adder_inst.i_a\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_10528_ net1638 net2532 net2558 net1603 VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__a22o_1
XFILLER_108_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13247_ _06273_ _06275_ VGND VGND VPWR VPWR _06276_ sky130_fd_sc_hd__nand2_1
X_10459_ _03542_ _03533_ net651 VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__and3_4
XFILLER_130_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13178_ net1649 net2324 net484 VGND VGND VPWR VPWR _06208_ sky130_fd_sc_hd__mux2_1
XFILLER_97_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2561 net2563 VGND VGND VPWR VPWR net2561 sky130_fd_sc_hd__buf_1
Xfanout2550 net2551 VGND VGND VPWR VPWR net2550 sky130_fd_sc_hd__buf_8
Xfanout2572 net2573 VGND VGND VPWR VPWR net2572 sky130_fd_sc_hd__buf_2
X_12129_ _05141_ _05142_ _05213_ VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__a21o_1
XFILLER_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2594 net2595 VGND VGND VPWR VPWR net2594 sky130_fd_sc_hd__buf_1
Xfanout2583 net2586 VGND VGND VPWR VPWR net2583 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1860 net1861 VGND VGND VPWR VPWR net1860 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1871 net1872 VGND VGND VPWR VPWR net1871 sky130_fd_sc_hd__buf_4
Xfanout1882 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net1882 sky130_fd_sc_hd__buf_4
Xfanout1893 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net1893 sky130_fd_sc_hd__buf_2
X_07670_ _00755_ _00730_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_125_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09340_ _01994_ _01969_ _01992_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__a21boi_1
X_09271_ _02010_ _02013_ _02354_ _02355_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__o211ai_2
XFILLER_33_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08222_ _01293_ _01294_ _01290_ VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__a21oi_2
XFILLER_138_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08153_ net1003 net984 _01235_ _01238_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__o211ai_1
XFILLER_107_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08084_ net1250 net1189 _00474_ net954 _01165_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__o221ai_4
X_07104_ adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _06876_ sky130_fd_sc_hd__inv_2
XFILLER_106_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08986_ _02063_ _02067_ _01945_ _02068_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__o211ai_2
XFILLER_87_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07937_ net1441 net1473 net2303 net2334 VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__and4_1
XFILLER_57_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07868_ net2098 net1715 net1751 net2077 VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_3_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07799_ _00762_ _00883_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__nand2_2
XFILLER_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09607_ _02683_ _02688_ _02691_ _02692_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__a2bb2oi_4
X_09538_ _02180_ net676 VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09469_ net1013 net928 _02553_ _02549_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__o22a_1
X_11500_ _04521_ net558 _04531_ _04525_ VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_42_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12480_ _02087_ _03481_ _05554_ _02321_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11431_ _04059_ _04063_ _04512_ _04515_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__o211a_1
XFILLER_138_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14150_ net2898 VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__inv_2
XFILLER_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11362_ _04438_ _04443_ _04442_ _04422_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__o211ai_1
XFILLER_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13101_ _06926_ net1054 _06048_ net785 net526 VGND VGND VPWR VPWR _06131_ sky130_fd_sc_hd__a311o_1
X_10313_ net1549 net2618 VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__nand2_2
X_14081_ net2824 VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__inv_2
X_11293_ net636 _04307_ _04308_ _04309_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__o2bb2a_1
X_13032_ net3202 _06057_ _06061_ VGND VGND VPWR VPWR _06062_ sky130_fd_sc_hd__a21oi_2
X_10244_ net1728 net2405 VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__nand2_1
XFILLER_79_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1101 _06907_ VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__buf_6
X_10175_ net1226 net1126 VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__nor2_1
Xfanout1112 net1115 VGND VGND VPWR VPWR net1112 sky130_fd_sc_hd__clkbuf_2
XFILLER_120_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1123 net1124 VGND VGND VPWR VPWR net1123 sky130_fd_sc_hd__clkbuf_2
Xfanout1145 _06900_ VGND VGND VPWR VPWR net1145 sky130_fd_sc_hd__buf_6
Xfanout1156 net1157 VGND VGND VPWR VPWR net1156 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1134 net1135 VGND VGND VPWR VPWR net1134 sky130_fd_sc_hd__buf_1
Xfanout191 _02444_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_4
Xfanout1189 net1190 VGND VGND VPWR VPWR net1189 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout180 _06384_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_2
Xfanout1178 _06894_ VGND VGND VPWR VPWR net1178 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1167 _06895_ VGND VGND VPWR VPWR net1167 sky130_fd_sc_hd__buf_2
X_13934_ _05630_ _06874_ net321 VGND VGND VPWR VPWR multiplier_inst.man_final\[22\]
+ sky130_fd_sc_hd__or3b_4
X_13865_ net130 _05558_ _05553_ VGND VGND VPWR VPWR _06826_ sky130_fd_sc_hd__o21a_1
XFILLER_90_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12816_ _05787_ net745 _05875_ _05877_ VGND VGND VPWR VPWR _05878_ sky130_fd_sc_hd__o31a_1
X_13796_ net3413 net726 VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__and2_1
XFILLER_15_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12747_ net2715 _05808_ _05800_ VGND VGND VPWR VPWR _05809_ sky130_fd_sc_hd__o21a_1
XFILLER_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12678_ adder_inst.i_b\[5\] adder_inst.i_b\[4\] adder_inst.i_b\[7\] adder_inst.i_b\[6\]
+ VGND VGND VPWR VPWR _05753_ sky130_fd_sc_hd__or4_1
X_14417_ clknet_leaf_17_clk net3352 _00239_ VGND VGND VPWR VPWR adder_inst.man_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11629_ _04714_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_96_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14348_ clknet_leaf_12_clk net56 _00170_ VGND VGND VPWR VPWR adder_inst.exp_b\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_14279_ net2898 VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__inv_2
XFILLER_131_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08840_ _01744_ _01922_ _01923_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_127_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2380 net2386 VGND VGND VPWR VPWR net2380 sky130_fd_sc_hd__clkbuf_2
X_08771_ _01852_ net907 net2184 net1683 VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__nand4_1
Xfanout2391 net2394 VGND VGND VPWR VPWR net2391 sky130_fd_sc_hd__buf_1
X_07722_ _00686_ _00687_ _00694_ _00695_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__nand4_1
Xfanout1690 net1691 VGND VGND VPWR VPWR net1690 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_0_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07653_ net1042 net990 _00733_ _00734_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__o22ai_4
XFILLER_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09323_ _02403_ _02405_ _02406_ _01976_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__o2bb2ai_1
X_07584_ _00668_ _00669_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_105_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09254_ net675 _02339_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_138_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08205_ net1049 net929 _01289_ _01284_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__o22a_1
X_09185_ _02268_ _02270_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_138_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08136_ net1654 net2291 net2316 net1619 VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__a22o_1
XFILLER_134_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08067_ net698 net714 VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__nand2_1
XFILLER_134_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08969_ _02024_ _02048_ _02049_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__nand3_2
X_11980_ _05065_ _05061_ _05064_ VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__nand3_2
XFILLER_90_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10931_ _04015_ _04010_ _04013_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_27_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13650_ _06611_ net159 _06663_ _06450_ net170 VGND VGND VPWR VPWR _06670_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_80_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10862_ net2298 net1955 VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__nand2_1
XFILLER_25_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13581_ _06605_ _06607_ _06608_ _06609_ VGND VGND VPWR VPWR _06610_ sky130_fd_sc_hd__nor4_4
XTAP_TAPCELL_ROW_80_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12601_ net1277 net2005 VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__and2b_1
X_10793_ net1172 _03660_ _03669_ net1286 VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__o211ai_2
X_12532_ _05441_ _05487_ VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__xnor2_2
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12463_ net140 net314 _05548_ VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__a21boi_4
XFILLER_33_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14202_ net2889 VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__inv_2
XFILLER_126_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11414_ _04497_ _04499_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__nand2_1
XFILLER_137_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12394_ _05457_ _05458_ _05459_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__a21oi_1
X_14133_ net2906 VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11345_ _04424_ _04425_ _04430_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__o21ai_1
X_14064_ net2831 VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__inv_2
X_11276_ net865 net795 net1175 net1133 VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__o2bb2ai_2
X_13015_ _05648_ _05657_ VGND VGND VPWR VPWR _06045_ sky130_fd_sc_hd__nor2_1
X_10227_ net656 _03312_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10158_ _03241_ _03242_ _03243_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__nand3_1
X_10089_ net807 _03172_ _02936_ _02941_ VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__o2bb2ai_1
X_13917_ net104 _06858_ _06859_ _06861_ VGND VGND VPWR VPWR _06863_ sky130_fd_sc_hd__nand4_4
XFILLER_75_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13848_ _06796_ _06798_ _06810_ VGND VGND VPWR VPWR _06811_ sky130_fd_sc_hd__o21ai_1
XFILLER_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13779_ net2007 net1279 net508 VGND VGND VPWR VPWR adder_inst.exp_larger\[3\] sky130_fd_sc_hd__mux2_1
XFILLER_31_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold414 adder_inst.i_vld_r VGND VGND VPWR VPWR net3332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold436 adder_inst.i_a\[0\] VGND VGND VPWR VPWR net3354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold425 adder_inst.i_b\[18\] VGND VGND VPWR VPWR net3343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold447 adder_inst.exp_b\[1\] VGND VGND VPWR VPWR net3365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold469 adder_inst.exp_a\[6\] VGND VGND VPWR VPWR net3387 sky130_fd_sc_hd__dlygate4sd3_1
Xhold458 adder_inst.exp_a\[4\] VGND VGND VPWR VPWR net3376 sky130_fd_sc_hd__dlygate4sd3_1
X_09941_ _02795_ _02994_ _03002_ _02993_ VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__o211ai_1
XFILLER_131_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout905 _02030_ VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__buf_4
Xfanout916 _01437_ VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__buf_2
Xfanout949 net951 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout927 net928 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__buf_8
Xfanout938 net939 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__buf_1
X_09872_ _02955_ _02956_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__nand2_1
XFILLER_100_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08823_ _01906_ _01830_ _01907_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__nand3_4
XFILLER_57_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08754_ net1591 net2274 _01837_ _01839_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__a22oi_1
XFILLER_85_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07705_ _00785_ _00787_ _00757_ VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_107_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08685_ net1384 net2470 net2505 net1357 VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_49_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07636_ net1512 net2242 VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nand2_1
X_07567_ net1042 net998 net1419 net2242 _00550_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__o2111ai_2
X_09306_ _02385_ _02386_ _02391_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__a21oi_2
XFILLER_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07498_ _00487_ _00501_ net616 _00504_ _00581_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__a41oi_2
X_09237_ _01942_ _02073_ _02071_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_32_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09168_ net1406 net2589 VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__and2_1
X_08119_ _01199_ _01203_ _01196_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__o21ai_4
X_09099_ _01396_ _01398_ net1577 net2403 VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__and4_1
XFILLER_134_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11130_ _04211_ net203 _04212_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__a21o_1
XFILLER_134_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11061_ _04100_ _04104_ _04145_ _03842_ net870 VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__o221a_1
XFILLER_103_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10012_ _03090_ _03096_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__nand2_1
XFILLER_91_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11963_ _04933_ _04935_ _04955_ _05024_ _05044_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__a32oi_2
X_13702_ _06358_ _06585_ _06355_ net136 VGND VGND VPWR VPWR _06716_ sky130_fd_sc_hd__a211o_1
XFILLER_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11894_ _04877_ _04882_ _04881_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__a21o_1
X_10914_ _03994_ _03997_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__nand2_2
X_13633_ _06462_ _06459_ _06651_ net1783 VGND VGND VPWR VPWR _06655_ sky130_fd_sc_hd__a22o_1
XFILLER_44_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10845_ net1821 net2445 VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__nand2_4
X_13564_ net771 net538 _06322_ _06323_ VGND VGND VPWR VPWR _06593_ sky130_fd_sc_hd__a31o_1
XFILLER_13_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10776_ _03816_ _03812_ _03815_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__nand3_4
X_12515_ net143 net317 _05600_ VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__a21oi_1
X_13495_ net1089 net1272 net602 net733 net2632 VGND VGND VPWR VPWR _06524_ sky130_fd_sc_hd__a221o_2
X_12446_ net2926 net322 net787 VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__nand3_1
XFILLER_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12377_ _07048_ _07050_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_93_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14116_ net2813 VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__inv_2
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11328_ _04378_ _04380_ _04381_ net559 _04413_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__a32oi_2
XFILLER_113_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14047_ net2879 VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__inv_2
X_11259_ net451 VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__inv_2
XFILLER_140_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_105_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08470_ _01553_ _01555_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__nand2_1
XFILLER_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07421_ _00438_ _00440_ _00459_ _00460_ VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_18_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07352_ _00422_ _00433_ _00435_ _00436_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_102_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_114_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07283_ _07052_ _07053_ VGND VGND VPWR VPWR _07054_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_135_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09022_ net2170 net1849 VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__and2_1
XFILLER_117_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout724 net725 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__clkbuf_1
XFILLER_132_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_123_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout702 _01029_ VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__buf_1
Xfanout713 _01474_ VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__buf_1
X_09924_ _03005_ _03008_ _03009_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__nand3_1
XFILLER_131_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout746 _05844_ VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout757 net759 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_113_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout735 _06071_ VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__clkbuf_1
X_09855_ net900 _02932_ _02938_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__o21ai_1
XFILLER_86_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08806_ _01885_ _01888_ _01890_ _01873_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__o211ai_1
Xfanout779 net781 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout768 net773 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__clkbuf_2
XFILLER_105_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09786_ _02867_ _02863_ _02866_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_106 net2952 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08737_ _01580_ _01581_ net470 _01607_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__a31o_1
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08668_ _01751_ net821 _01750_ _01753_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__a22oi_2
XANTENNA_117 net1350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07619_ _00697_ _00698_ _00700_ VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__nand3b_1
XFILLER_121_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_132_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08599_ net2125 net1773 VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__nand2_1
X_10630_ net2351 net1845 net877 net800 VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__a22o_1
XFILLER_139_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10561_ net885 _03646_ VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__or2_1
X_12300_ _02493_ _02495_ _02515_ net328 VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__a31o_1
Xrebuffer341 _06239_ VGND VGND VPWR VPWR net1570 sky130_fd_sc_hd__clkbuf_2
X_13280_ net286 _06283_ _06308_ net229 VGND VGND VPWR VPWR _06309_ sky130_fd_sc_hd__o211ai_1
XFILLER_10_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer330 _03674_ VGND VGND VPWR VPWR net1249 sky130_fd_sc_hd__buf_1
XFILLER_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10492_ net1206 net1162 net970 net921 _03333_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__o221ai_2
Xrebuffer363 net1943 VGND VGND VPWR VPWR net1968 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer352 net300 VGND VGND VPWR VPWR net1725 sky130_fd_sc_hd__buf_6
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12231_ net167 net2931 net3057 VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__a21o_4
XFILLER_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer385 _06080_ VGND VGND VPWR VPWR net3303 sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_141_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2902 net2903 VGND VGND VPWR VPWR net2902 sky130_fd_sc_hd__dlymetal6s2s_1
X_12162_ _05208_ _05201_ _05245_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__a21o_1
Xfanout2913 net2914 VGND VGND VPWR VPWR net2913 sky130_fd_sc_hd__buf_1
X_11113_ _04165_ _04196_ _04197_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__nand3_2
X_12093_ _05172_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__nand2_1
XFILLER_110_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11044_ net640 _04115_ net563 net561 VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__nand4_1
XFILLER_103_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12995_ net1294 _05809_ _06029_ net1069 VGND VGND VPWR VPWR _06030_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11946_ net1195 net1096 _04938_ net792 VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_86_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11877_ _04864_ _04866_ _04850_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__o21ai_2
X_14596_ clknet_leaf_7_clk net3445 _00418_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
X_13616_ _06517_ net3308 VGND VGND VPWR VPWR _06641_ sky130_fd_sc_hd__nor2_1
X_10828_ _03746_ _03748_ _03749_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__a21o_1
X_13547_ _06478_ _06570_ _06575_ VGND VGND VPWR VPWR _06576_ sky130_fd_sc_hd__o21ai_2
XFILLER_71_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10759_ _03623_ _03841_ _03838_ _03840_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__o31a_1
XFILLER_40_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_117_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13478_ _06503_ _06505_ _06495_ VGND VGND VPWR VPWR _06507_ sky130_fd_sc_hd__a21o_1
X_12429_ net2921 _05512_ _07066_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__a21o_1
XFILLER_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07970_ net251 _01055_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__nand2_1
XFILLER_102_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09640_ _02718_ _02721_ _02723_ _02725_ _02720_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__o221ai_4
X_09571_ net461 net588 _02653_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__nand3_1
XFILLER_48_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08522_ _01583_ _01604_ _01605_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__nand3_1
XFILLER_36_663 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08453_ _01533_ _01534_ _01519_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_46_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07404_ net1478 net2161 net2193 net1446 VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_34_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08384_ net1264 net1141 _01453_ _01463_ _01468_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__o221ai_2
X_07335_ _07070_ _07073_ net1262 net1245 VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__o2bb2ai_1
X_07266_ _07036_ net2135 net1424 _07035_ VGND VGND VPWR VPWR _07037_ sky130_fd_sc_hd__nand4b_4
XFILLER_31_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09005_ _02089_ _01288_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__nand2_2
XFILLER_117_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07197_ net2034 net1488 VGND VGND VPWR VPWR _06968_ sky130_fd_sc_hd__nand2_1
XFILLER_132_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2209 net2210 VGND VGND VPWR VPWR net2209 sky130_fd_sc_hd__buf_4
Xfanout1508 net1509 VGND VGND VPWR VPWR net1508 sky130_fd_sc_hd__clkbuf_1
Xfanout532 net533 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__buf_1
Xfanout521 net523 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__clkbuf_2
XFILLER_76_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout510 net517 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_6
XFILLER_59_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09907_ _02797_ _02798_ _02992_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__nand3_2
Xfanout1519 net1520 VGND VGND VPWR VPWR net1519 sky130_fd_sc_hd__clkbuf_1
XFILLER_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout543 net544 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__buf_4
Xfanout554 _04748_ VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__clkbuf_1
Xfanout565 _03983_ VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__buf_8
XFILLER_59_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout587 _02898_ VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__buf_6
Xfanout576 net578 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__buf_4
X_09838_ net918 net999 _02922_ _02918_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__o22a_1
XFILLER_100_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09769_ net666 net665 VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__nand2_1
XFILLER_18_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11800_ _04749_ _04750_ _04732_ _04733_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__o211ai_1
X_12780_ _05792_ net847 _05841_ net2700 VGND VGND VPWR VPWR _05842_ sky130_fd_sc_hd__o22a_1
Xrebuffer70 _01743_ VGND VGND VPWR VPWR net2988 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer81 _03556_ VGND VGND VPWR VPWR net2999 sky130_fd_sc_hd__buf_1
X_11731_ net2452 net2483 net1960 net1986 VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__nand4_2
Xrebuffer92 _04551_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__buf_2
X_14450_ clknet_leaf_1_clk _00066_ _00272_ VGND VGND VPWR VPWR add_res\[8\] sky130_fd_sc_hd__dfrtp_1
X_11662_ _04742_ _04746_ _04747_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__nand3_1
X_13401_ net272 _06222_ _06223_ VGND VGND VPWR VPWR _06430_ sky130_fd_sc_hd__nand3_4
X_10613_ net1220 net1127 net987 net925 VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__o22a_4
X_14381_ clknet_leaf_10_clk net3374 _00203_ VGND VGND VPWR VPWR adder_inst.man_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_11593_ _04677_ _04670_ _04676_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__nand3_1
X_13332_ _06359_ _06360_ VGND VGND VPWR VPWR _06361_ sky130_fd_sc_hd__nor2_1
XFILLER_10_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10544_ net1499 _03624_ net2664 _03625_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__a31o_1
XFILLER_127_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13263_ net493 net3193 net219 _06289_ _06288_ VGND VGND VPWR VPWR _06292_ sky130_fd_sc_hd__o311ai_4
Xrebuffer182 net3099 VGND VGND VPWR VPWR net3100 sky130_fd_sc_hd__buf_2
Xrebuffer160 _03424_ VGND VGND VPWR VPWR net3078 sky130_fd_sc_hd__buf_1
X_10475_ _03334_ _03559_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__nand2_1
Xrebuffer171 _03137_ VGND VGND VPWR VPWR net3089 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_136_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13194_ net1724 net484 _06222_ VGND VGND VPWR VPWR _06224_ sky130_fd_sc_hd__o21ai_1
X_12214_ _05145_ _05072_ net201 net197 VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__o211ai_2
XFILLER_6_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer193 _03226_ VGND VGND VPWR VPWR net3111 sky130_fd_sc_hd__buf_6
Xfanout2710 net2712 VGND VGND VPWR VPWR net2710 sky130_fd_sc_hd__buf_1
Xfanout2721 net2722 VGND VGND VPWR VPWR net2721 sky130_fd_sc_hd__buf_4
X_12145_ _05225_ _05230_ _05226_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__o21ba_1
Xfanout2743 net2744 VGND VGND VPWR VPWR net2743 sky130_fd_sc_hd__buf_1
Xfanout2732 net2735 VGND VGND VPWR VPWR net2732 sky130_fd_sc_hd__clkbuf_1
Xfanout2754 adder_inst.sum_raw_r\[15\] VGND VGND VPWR VPWR net2754 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_96_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2765 net2766 VGND VGND VPWR VPWR net2765 sky130_fd_sc_hd__buf_1
Xfanout2776 net2778 VGND VGND VPWR VPWR net2776 sky130_fd_sc_hd__clkbuf_2
Xfanout2787 adder_inst.sum_raw_r\[0\] VGND VGND VPWR VPWR net2787 sky130_fd_sc_hd__buf_1
X_12076_ _05081_ _05160_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__nand2_1
Xfanout2798 net2799 VGND VGND VPWR VPWR net2798 sky130_fd_sc_hd__buf_1
X_11027_ _04093_ _04094_ _04095_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_88_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12978_ net1076 net2752 net2747 VGND VGND VPWR VPWR _06018_ sky130_fd_sc_hd__and3_1
XFILLER_80_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11929_ _05006_ _05013_ _05012_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__o21ai_2
XFILLER_60_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_17 adder_inst.sum_raw\[15\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_39 net1202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 net960 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14579_ clknet_leaf_4_clk net3410 _00401_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
X_07120_ net2389 VGND VGND VPWR VPWR _06892_ sky130_fd_sc_hd__inv_2
XFILLER_118_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07953_ net409 _00980_ net477 _01036_ VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_110_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07884_ _00966_ _00967_ _00964_ _00965_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_52_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09623_ _02693_ _02703_ _02705_ _02706_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__o211ai_4
X_09554_ net1729 net2340 VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__nand2_4
XFILLER_43_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08505_ net1554 net2331 net2361 net1526 VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__a22oi_1
X_09485_ net1250 net1232 net958 _02565_ net813 VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__o311a_1
XFILLER_24_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08436_ net1554 net2345 VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__nand2_1
X_08367_ net1468 net2491 VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__nand2_1
XFILLER_137_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07318_ net1453 net2107 net1487 net2134 VGND VGND VPWR VPWR _07089_ sky130_fd_sc_hd__nand4_1
X_08298_ _01383_ net594 net593 VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__and3_1
XFILLER_125_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07249_ _06995_ _07019_ VGND VGND VPWR VPWR _07020_ sky130_fd_sc_hd__or2_1
XFILLER_109_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10260_ net807 net892 _03171_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__a21oi_1
Xfanout2006 adder_inst.exp_a_r\[4\] VGND VGND VPWR VPWR net2006 sky130_fd_sc_hd__clkbuf_1
XFILLER_132_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1305 net1306 VGND VGND VPWR VPWR net1305 sky130_fd_sc_hd__buf_1
Xfanout2028 net2030 VGND VGND VPWR VPWR net2028 sky130_fd_sc_hd__buf_1
Xfanout2017 net2018 VGND VGND VPWR VPWR net2017 sky130_fd_sc_hd__buf_4
Xfanout2039 net2041 VGND VGND VPWR VPWR net2039 sky130_fd_sc_hd__buf_4
X_10191_ net2261 net1865 VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__nand2_1
XFILLER_120_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1338 net1339 VGND VGND VPWR VPWR net1338 sky130_fd_sc_hd__clkbuf_1
Xfanout1316 net3327 VGND VGND VPWR VPWR net1316 sky130_fd_sc_hd__buf_1
Xfanout1327 adder_inst.is_nan_r VGND VGND VPWR VPWR net1327 sky130_fd_sc_hd__buf_1
Xfanout340 net341 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlymetal6s2s_1
X_13950_ net3409 mul_res\[14\] net2797 VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__mux2_1
Xfanout1349 net1350 VGND VGND VPWR VPWR net1349 sky130_fd_sc_hd__buf_1
Xfanout373 net374 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__buf_6
Xfanout362 net364 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__buf_1
Xfanout351 _02766_ VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__buf_6
Xfanout384 _04471_ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__buf_6
X_12901_ net2689 adder_inst.sum_raw_r\[13\] net2761 net754 VGND VGND VPWR VPWR _05951_
+ sky130_fd_sc_hd__a22o_1
Xfanout395 _02870_ VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_6_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13881_ net122 _05569_ _06837_ VGND VGND VPWR VPWR _06838_ sky130_fd_sc_hd__o21a_1
X_12832_ net1084 adder_inst.sum_raw_r\[2\] _05892_ net238 VGND VGND VPWR VPWR _00047_
+ sky130_fd_sc_hd__o211a_1
X_12763_ net2709 _05819_ _05822_ _05824_ VGND VGND VPWR VPWR _05825_ sky130_fd_sc_hd__nor4_2
XFILLER_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14502_ clknet_leaf_20_clk multiplier_inst.man_final\[2\] _00324_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_83_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11714_ _04651_ _04791_ _04789_ _04788_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__o211ai_2
X_14433_ clknet_leaf_11_clk adder_inst.man_b\[23\] _00255_ VGND VGND VPWR VPWR adder_inst.man_b_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_12694_ _05763_ _05766_ _05767_ VGND VGND VPWR VPWR _05768_ sky130_fd_sc_hd__or3_1
XFILLER_42_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11645_ _04723_ _04728_ _04729_ VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__and3_1
X_14364_ clknet_leaf_0_clk adder_inst.sum_raw\[13\] _00186_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[13\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput26 i_a[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11576_ _04642_ _04656_ _04657_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__nand3_2
Xinput15 i_a[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput37 i_b[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_114_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13315_ net519 _06339_ _06341_ _06342_ VGND VGND VPWR VPWR _06344_ sky130_fd_sc_hd__o211a_1
Xinput48 i_b[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput59 i_b[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
X_14295_ clknet_leaf_18_clk net32 _00117_ VGND VGND VPWR VPWR adder_inst.i_a\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_10527_ net1638 net2532 net2558 net1603 VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__a22oi_2
X_13246_ _06274_ VGND VGND VPWR VPWR _06275_ sky130_fd_sc_hd__inv_2
X_10458_ net651 _03542_ _03533_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__a21o_1
XFILLER_108_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13177_ net229 _06206_ _06191_ _06189_ VGND VGND VPWR VPWR _06207_ sky130_fd_sc_hd__o22ai_4
X_10389_ _03474_ _03472_ _03473_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__nand3_4
Xfanout2562 net2563 VGND VGND VPWR VPWR net2562 sky130_fd_sc_hd__buf_1
Xfanout2551 adder_inst.man_a_r\[5\] VGND VGND VPWR VPWR net2551 sky130_fd_sc_hd__buf_6
X_12128_ _05212_ _05140_ _05139_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__and3_1
Xfanout2540 net2548 VGND VGND VPWR VPWR net2540 sky130_fd_sc_hd__clkbuf_1
Xfanout1850 net1851 VGND VGND VPWR VPWR net1850 sky130_fd_sc_hd__clkbuf_2
Xfanout2573 net2574 VGND VGND VPWR VPWR net2573 sky130_fd_sc_hd__buf_4
X_12059_ _05141_ _05142_ net245 VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__a21o_4
Xfanout2584 net2585 VGND VGND VPWR VPWR net2584 sky130_fd_sc_hd__buf_4
Xfanout2595 net2606 VGND VGND VPWR VPWR net2595 sky130_fd_sc_hd__buf_1
Xfanout1861 net1862 VGND VGND VPWR VPWR net1861 sky130_fd_sc_hd__clkbuf_2
Xfanout1872 net1882 VGND VGND VPWR VPWR net1872 sky130_fd_sc_hd__clkbuf_2
Xfanout1883 net1885 VGND VGND VPWR VPWR net1883 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_125_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09270_ net712 _02013_ _02354_ _02355_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__o211a_1
X_08221_ _01300_ net1852 net2144 _01302_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__and4_1
XFILLER_60_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08152_ net1654 net2272 net2292 net1619 VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_08083_ _01164_ _01166_ _01163_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__o21bai_1
XFILLER_102_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08985_ _02069_ _02070_ _01944_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__a21oi_1
XFILLER_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07936_ net2300 net2329 VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__nand2_4
XFILLER_57_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07867_ net2070 net2098 net1715 net1751 VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_3_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07798_ net2073 net1719 net1755 net2047 VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__a22oi_4
XFILLER_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09606_ _02235_ _02238_ net1234 net1141 VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_71_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09537_ _02588_ _02593_ _02594_ _02596_ _02603_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_65_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09468_ net1012 net928 _02553_ _02549_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__o22ai_4
XFILLER_51_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09399_ _02481_ _02483_ _02479_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__o21ai_1
X_08419_ _01464_ _01494_ _01502_ _01503_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_22_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11430_ _04514_ _04511_ _04513_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__nand3_4
XFILLER_125_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11361_ _04423_ _04446_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__nand2_1
XFILLER_138_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13100_ _06926_ net1054 _06048_ VGND VGND VPWR VPWR _06130_ sky130_fd_sc_hd__a21oi_1
XFILLER_4_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10312_ _03395_ _03396_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__nand2_2
XFILLER_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14080_ net2826 VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__inv_2
X_11292_ _04376_ net635 _04364_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__a21o_1
XFILLER_79_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13031_ _05680_ _05687_ VGND VGND VPWR VPWR _06061_ sky130_fd_sc_hd__nand2_1
X_10243_ _03327_ _03321_ _03326_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__nand3_2
XFILLER_106_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1113 net1114 VGND VGND VPWR VPWR net1113 sky130_fd_sc_hd__buf_1
X_10174_ net2177 net2204 net1945 net1970 VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__nand4_4
Xfanout1102 net1104 VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__buf_2
Xfanout1124 net1125 VGND VGND VPWR VPWR net1124 sky130_fd_sc_hd__clkbuf_2
Xfanout1135 net1139 VGND VGND VPWR VPWR net1135 sky130_fd_sc_hd__buf_1
XFILLER_120_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1168 _06895_ VGND VGND VPWR VPWR net1168 sky130_fd_sc_hd__clkbuf_2
Xfanout192 _02081_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__buf_4
Xfanout170 _06577_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_1
Xfanout181 _03011_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_2
Xfanout1157 net1158 VGND VGND VPWR VPWR net1157 sky130_fd_sc_hd__clkbuf_2
Xfanout1179 net1181 VGND VGND VPWR VPWR net1179 sky130_fd_sc_hd__clkbuf_2
X_13933_ _06871_ _05636_ _05629_ _06873_ VGND VGND VPWR VPWR multiplier_inst.man_final\[21\]
+ sky130_fd_sc_hd__o31a_1
X_13864_ _05543_ _05546_ _05549_ _06825_ VGND VGND VPWR VPWR multiplier_inst.man_final\[1\]
+ sky130_fd_sc_hd__o31a_1
X_12815_ _05802_ net749 net750 net846 _05874_ VGND VGND VPWR VPWR _05877_ sky130_fd_sc_hd__o32a_1
X_13795_ net3427 net724 VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__and2_1
XFILLER_27_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12746_ _05803_ net1072 net1077 _05806_ _05807_ VGND VGND VPWR VPWR _05808_ sky130_fd_sc_hd__a311o_1
XFILLER_43_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12677_ net855 VGND VGND VPWR VPWR multiplier_inst.sign_res sky130_fd_sc_hd__inv_2
X_14416_ clknet_leaf_17_clk net3344 _00238_ VGND VGND VPWR VPWR adder_inst.man_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_11628_ _04401_ _04710_ _04713_ VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__o21ai_2
XFILLER_128_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14347_ clknet_leaf_12_clk net54 _00169_ VGND VGND VPWR VPWR adder_inst.exp_b\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11559_ _04624_ _04644_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__nand2_1
XFILLER_7_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14278_ net2899 VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__inv_2
XFILLER_112_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13229_ _06205_ net3251 net1693 VGND VGND VPWR VPWR _06258_ sky130_fd_sc_hd__a21oi_4
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_127_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2381 net2383 VGND VGND VPWR VPWR net2381 sky130_fd_sc_hd__clkbuf_2
X_08770_ _01852_ net907 net1232 net1212 VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_85_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2392 net2393 VGND VGND VPWR VPWR net2392 sky130_fd_sc_hd__buf_4
X_07721_ _00686_ _00687_ _00694_ _00695_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__a22o_1
Xfanout1691 net1692 VGND VGND VPWR VPWR net1691 sky130_fd_sc_hd__clkbuf_2
Xfanout1680 net1682 VGND VGND VPWR VPWR net1680 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_140_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07652_ net1042 net990 net1421 net2304 _00735_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_0_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07583_ _00466_ _00467_ net2082 net1598 VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__o211ai_1
XFILLER_53_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09322_ _01974_ net820 net1024 net985 VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_105_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09253_ _00944_ _02337_ _02011_ _02008_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__o211a_1
XFILLER_21_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_138_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08204_ _01289_ _01284_ _01287_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__o21ai_1
X_09184_ _02196_ _02201_ _01489_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__o21ai_1
X_08135_ net1654 net2291 net2315 net1619 VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__a22oi_1
XFILLER_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08066_ _01132_ _01127_ _01131_ net701 net699 VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_8_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08968_ _02051_ _02052_ _02023_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__nand3_2
XFILLER_29_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07919_ _00988_ _01000_ _00998_ _00992_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__o211ai_2
X_08899_ _01836_ _01842_ _01980_ _01982_ VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__o211ai_2
XFILLER_84_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10930_ net968 net935 _04015_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__o21ai_1
XFILLER_83_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12600_ net1278 net2005 net862 VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__a21o_1
X_10861_ _03943_ _03945_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__a21oi_2
X_13580_ _06291_ _06302_ _06292_ _06280_ VGND VGND VPWR VPWR _06609_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_80_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10792_ _03876_ _03669_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__nand2_1
X_12531_ net147 net321 _05615_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__a21o_1
XFILLER_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12462_ _03022_ net3061 VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__xnor2_4
XFILLER_138_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14201_ net2905 VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__inv_2
X_11413_ _04443_ _04438_ _04422_ _04441_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__o22a_1
X_12393_ _05477_ _05478_ VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__nand2_1
X_14132_ net2906 VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__inv_2
XFILLER_125_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11344_ net1676 net2647 VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__nand2_1
X_14063_ net2831 VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__inv_2
X_11275_ net1176 net1133 net865 net795 VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_18_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13014_ net1327 net1318 net3499 VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__and3b_1
X_10226_ net804 _03303_ _03308_ _03309_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_91_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10157_ _03025_ _03002_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__nand2_1
XFILLER_66_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10088_ net807 _03172_ VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__nand2_1
X_13916_ net104 _06858_ _06859_ _06861_ VGND VGND VPWR VPWR _06862_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_122_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13847_ net3001 _05301_ VGND VGND VPWR VPWR _06810_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_27_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13778_ net2010 net1282 net508 VGND VGND VPWR VPWR adder_inst.exp_larger\[2\] sky130_fd_sc_hd__mux2_1
X_12729_ net1310 net1305 net1299 VGND VGND VPWR VPWR _05791_ sky130_fd_sc_hd__or3_1
XFILLER_31_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold415 adder_inst.i_vld VGND VGND VPWR VPWR net3333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold426 adder_inst.i_b\[6\] VGND VGND VPWR VPWR net3344 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold448 adder_inst.exp_b\[7\] VGND VGND VPWR VPWR net3366 sky130_fd_sc_hd__dlygate4sd3_1
X_09940_ _03003_ _03025_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__nand2_1
Xhold459 adder_inst.i_a\[6\] VGND VGND VPWR VPWR net3377 sky130_fd_sc_hd__dlygate4sd3_1
Xhold437 adder_inst.i_b\[14\] VGND VGND VPWR VPWR net3355 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout906 _01881_ VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__clkbuf_2
Xfanout928 net929 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__buf_8
Xfanout939 _01286_ VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__buf_1
X_09871_ net1460 net2582 net2608 net1430 VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__a22oi_1
Xfanout917 net919 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__buf_6
X_08822_ _01900_ _01903_ _01905_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__o21ai_1
XFILLER_85_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08753_ _01633_ _01835_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__nand2_1
X_07704_ _00757_ net411 _00787_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_107_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08684_ net1331 net2535 VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__nand2_2
XFILLER_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07635_ net1533 net1564 net2187 net2214 VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__nand4_1
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07566_ net1419 net2242 _00550_ _00553_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__a22o_1
XFILLER_53_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09305_ _02378_ _02389_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_62_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07497_ net412 _00581_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__nand2_1
X_09236_ _01942_ net213 _02071_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09167_ net1431 net1461 net2527 net2554 VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__nand4_2
XFILLER_134_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08118_ net2200 net2227 net1710 net1744 VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__nand4_1
X_09098_ net1577 net2403 _01396_ _01398_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__a22o_1
XFILLER_134_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08049_ _01095_ net965 VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__nand2_1
X_11060_ net2642 net2666 net1033 _04145_ _04144_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__a311oi_4
X_10011_ _03091_ _03092_ _03093_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__nand3_4
XFILLER_103_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13701_ net150 net158 _06714_ _06356_ VGND VGND VPWR VPWR _06715_ sky130_fd_sc_hd__a22o_1
XFILLER_56_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11962_ _04933_ _04935_ _04955_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__nand3_1
XFILLER_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11893_ _04877_ _04881_ _04882_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__nand3_1
X_10913_ net569 _03732_ _03753_ _03754_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__o2bb2ai_2
X_13632_ _06463_ _06654_ VGND VGND VPWR VPWR adder_inst.sum_raw\[6\] sky130_fd_sc_hd__xor2_1
XFILLER_44_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10844_ _03927_ _03928_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__nand2_2
X_13563_ net162 _06590_ _06589_ VGND VGND VPWR VPWR _06592_ sky130_fd_sc_hd__a21o_1
XFILLER_13_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12514_ _05598_ _05599_ VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__nand2_1
X_10775_ _03818_ _03819_ net3146 VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__a21oi_4
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13494_ _06517_ _06520_ VGND VGND VPWR VPWR _06523_ sky130_fd_sc_hd__nand2_4
XFILLER_13_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12445_ net2926 net322 net787 VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__a21o_1
X_12376_ _05452_ _05448_ net381 VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_93_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14115_ net2816 VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__inv_2
X_11327_ _04410_ _04412_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__nand2_4
X_14046_ net2878 VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__inv_2
XFILLER_79_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11258_ _04315_ _04340_ _04339_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__nand3_2
X_10209_ _03287_ net3084 _03292_ _03293_ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__o211ai_4
X_11189_ net1148 net1143 net3145 net1120 net1193 VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__o32a_1
XFILLER_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07420_ _00438_ _00440_ _00459_ _00460_ VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__nand4_1
XFILLER_90_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07351_ _00435_ _00436_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_102_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07282_ net601 _07048_ _07049_ _07051_ VGND VGND VPWR VPWR _07053_ sky130_fd_sc_hd__a31oi_1
XFILLER_136_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09021_ _02092_ _02093_ _02104_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__nand3_4
XFILLER_116_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout703 _01028_ VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__buf_1
XFILLER_98_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout714 _01134_ VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__buf_1
X_09923_ net209 _02761_ _02768_ _02770_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout725 net726 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__buf_1
Xfanout758 net759 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__clkbuf_1
Xfanout736 net738 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__buf_1
Xfanout747 _05844_ VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_113_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09854_ net1141 net1117 net1015 net1109 net1233 VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__o32a_4
XFILLER_112_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08805_ _01889_ _01890_ _01873_ VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__a21oi_2
XFILLER_85_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout769 net770 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__clkbuf_2
X_09785_ _02867_ _02863_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__nand2_1
X_08736_ _01675_ _01666_ _01815_ _01817_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__o211ai_2
XANTENNA_107 net1599 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08667_ net821 _01748_ _01751_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__a21oi_1
XANTENNA_118 net1350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07618_ _00594_ _00595_ _00701_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08598_ net1253 net1189 VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__nor2_1
XFILLER_81_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07549_ net1391 net2281 VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__nand2_1
XFILLER_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10560_ net1464 net2644 net2662 net1434 VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__a22oi_2
XFILLER_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer320 net356 VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__dlymetal6s2s_1
X_09219_ _02303_ _02304_ _02300_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__nand3_2
Xrebuffer331 _03664_ VGND VGND VPWR VPWR net1286 sky130_fd_sc_hd__buf_6
X_10491_ _03382_ _03385_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__o21ai_2
Xrebuffer342 net3306 VGND VGND VPWR VPWR net3260 sky130_fd_sc_hd__buf_6
Xrebuffer353 _06138_ VGND VGND VPWR VPWR net1758 sky130_fd_sc_hd__clkbuf_2
XFILLER_6_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12230_ _05315_ net167 _04814_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__a21oi_4
XFILLER_135_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer386 _06058_ VGND VGND VPWR VPWR net3304 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2903 net2904 VGND VGND VPWR VPWR net2903 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_108_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12161_ _05198_ _05200_ _05206_ _05207_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__o211ai_2
Xfanout2914 net2915 VGND VGND VPWR VPWR net2914 sky130_fd_sc_hd__buf_1
XFILLER_107_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11112_ _04164_ _04193_ _04195_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__nand3_4
X_12092_ _05176_ _05177_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__nor2_1
X_11043_ net563 net560 _04116_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__and3_1
X_12994_ _05800_ net1293 VGND VGND VPWR VPWR _06029_ sky130_fd_sc_hd__nand2_1
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11945_ net1768 net2674 _04938_ net792 VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_86_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13615_ _06523_ net171 _06633_ VGND VGND VPWR VPWR _06640_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11876_ _04864_ _04866_ _04959_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__o21ai_2
X_14595_ clknet_leaf_7_clk net3436 _00417_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
XFILLER_20_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10827_ net2387 net1791 net2415 net1820 _03749_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__a41o_1
X_13546_ _06573_ _06572_ _06475_ _06476_ VGND VGND VPWR VPWR _06575_ sky130_fd_sc_hd__o31a_1
X_10758_ _03843_ _03838_ _03840_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__o21ai_1
X_13477_ _06503_ _06505_ VGND VGND VPWR VPWR _06506_ sky130_fd_sc_hd__nand2_4
X_12428_ _05511_ _05512_ _07066_ VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_117_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10689_ net1669 net2533 VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_130_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12359_ _07078_ _07099_ _05444_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__o21ai_1
XFILLER_99_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14029_ net2837 VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__inv_2
XFILLER_83_759 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09570_ net461 net588 _02653_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__and3_1
X_08521_ net471 VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__inv_2
X_08452_ _01519_ _01533_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_46_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07403_ net1478 net2161 net2193 net1447 VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__a22oi_1
XFILLER_90_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08383_ _01456_ _01466_ _01463_ _01453_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__o2bb2ai_1
X_07334_ _07073_ net1510 net2107 _07070_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__nand4_1
XFILLER_50_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07265_ net1453 net2109 net1488 net2079 VGND VGND VPWR VPWR _07036_ sky130_fd_sc_hd__a22oi_2
X_09004_ net1129 net1263 net929 net1049 _01285_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__o221ai_4
X_07196_ net1048 net1043 _06965_ _06964_ VGND VGND VPWR VPWR _06967_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_105_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1509 net1510 VGND VGND VPWR VPWR net1509 sky130_fd_sc_hd__clkbuf_2
Xfanout522 net523 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__clkbuf_1
Xfanout511 net514 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout533 _06074_ VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_6
X_09906_ _02990_ net3097 _02912_ _02916_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout500 net501 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_70_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout544 net547 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_6
Xfanout566 _03850_ VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__clkbuf_2
Xfanout555 _04577_ VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__buf_4
Xfanout599 _00729_ VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__buf_4
Xfanout588 _02632_ VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__clkbuf_2
Xfanout577 net578 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__clkbuf_1
X_09837_ _02922_ _02918_ _02921_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__o21ai_2
X_09768_ _02847_ _02848_ _02849_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__nand3_1
XFILLER_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08719_ _01790_ _01800_ _01801_ _01786_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__a31o_1
XFILLER_73_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer71 _01743_ VGND VGND VPWR VPWR net2989 sky130_fd_sc_hd__dlymetal6s2s_1
X_09699_ _02783_ _02784_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__nand2_1
X_11730_ net2482 net1960 VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__nand2_2
Xrebuffer82 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net3000 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer60 _03692_ VGND VGND VPWR VPWR net2978 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_42_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11661_ _04463_ _04464_ _04419_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__a21o_1
XFILLER_41_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13400_ _06409_ _06427_ _06410_ VGND VGND VPWR VPWR _06429_ sky130_fd_sc_hd__and3b_1
X_10612_ net2296 net1927 VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__nand2_1
X_14380_ clknet_leaf_12_clk net3347 _00202_ VGND VGND VPWR VPWR adder_inst.man_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_11592_ _04677_ _04670_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__nand2_1
XFILLER_128_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13331_ _06344_ _06345_ VGND VGND VPWR VPWR _06360_ sky130_fd_sc_hd__or2_2
X_10543_ _03399_ _03623_ net1238 net1094 VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__a211o_1
XFILLER_127_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer150 _05282_ VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer161 net3080 VGND VGND VPWR VPWR net3079 sky130_fd_sc_hd__buf_1
X_13262_ net1255 net494 _06243_ net2947 _06290_ VGND VGND VPWR VPWR _06291_ sky130_fd_sc_hd__o221a_2
Xrebuffer172 _02583_ VGND VGND VPWR VPWR net3090 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_10_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer183 _03193_ VGND VGND VPWR VPWR net3101 sky130_fd_sc_hd__dlymetal6s4s_1
X_10474_ net1726 net2447 net2475 net1694 VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__a22oi_2
XFILLER_108_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13193_ net1089 net1273 net602 net3297 net1724 VGND VGND VPWR VPWR _06223_ sky130_fd_sc_hd__a221o_1
Xrebuffer194 _02580_ VGND VGND VPWR VPWR net3112 sky130_fd_sc_hd__buf_2
X_12213_ _05154_ _05214_ _05296_ _05298_ VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__a22oi_4
XFILLER_135_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2700 net2707 VGND VGND VPWR VPWR net2700 sky130_fd_sc_hd__clkbuf_2
X_12144_ net1887 net2656 _05227_ _05229_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__a31o_1
Xfanout2733 net2735 VGND VGND VPWR VPWR net2733 sky130_fd_sc_hd__buf_1
Xfanout2744 net2745 VGND VGND VPWR VPWR net2744 sky130_fd_sc_hd__buf_1
Xfanout2722 adder_inst.sum_raw_r\[20\] VGND VGND VPWR VPWR net2722 sky130_fd_sc_hd__buf_6
Xfanout2755 adder_inst.sum_raw_r\[15\] VGND VGND VPWR VPWR net2755 sky130_fd_sc_hd__clkbuf_1
Xfanout2777 net2778 VGND VGND VPWR VPWR net2777 sky130_fd_sc_hd__clkbuf_1
Xfanout2766 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR net2766 sky130_fd_sc_hd__clkbuf_2
Xfanout2788 adder_inst.sum_raw_r\[0\] VGND VGND VPWR VPWR net2788 sky130_fd_sc_hd__buf_1
XFILLER_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12075_ net2571 net1989 net2602 net1963 VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__a22oi_1
Xfanout2799 net2800 VGND VGND VPWR VPWR net2799 sky130_fd_sc_hd__clkbuf_2
X_11026_ _04096_ _04097_ _04092_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_88_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12977_ net2687 net2704 net2697 VGND VGND VPWR VPWR _06017_ sky130_fd_sc_hd__o21a_1
XFILLER_18_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11928_ net962 net911 net1861 net2630 _05007_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__o2111a_1
X_11859_ net1765 net2653 _04853_ _04855_ VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__a22o_1
XFILLER_33_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14578_ clknet_leaf_4_clk net3433 _00400_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
XANTENNA_18 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_29 net1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_13529_ _06518_ net3308 VGND VGND VPWR VPWR _06558_ sky130_fd_sc_hd__nand2_8
XFILLER_9_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07952_ net409 _00980_ _01037_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_110_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07883_ _00965_ _00968_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09622_ _02704_ _02707_ _02243_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__nand3_4
X_09553_ _02170_ _02637_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__nand2_2
XFILLER_83_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08504_ net1526 net2361 VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__nand2_1
XFILLER_70_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09484_ net2141 net2171 net1873 net1903 VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__nand4_4
XFILLER_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08435_ net1500 net2401 VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__nand2_1
XFILLER_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08366_ _01449_ _01428_ _01448_ VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__nand3_2
X_07317_ net1452 net2108 net1486 VGND VGND VPWR VPWR _07088_ sky130_fd_sc_hd__nand3_2
X_08297_ _01377_ _01378_ _01379_ VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__nand3_2
X_07248_ _06943_ _06994_ VGND VGND VPWR VPWR _07019_ sky130_fd_sc_hd__and2_1
X_07179_ net2054 net1537 VGND VGND VPWR VPWR _06950_ sky130_fd_sc_hd__nand2_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2007 adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR net2007 sky130_fd_sc_hd__buf_4
X_10190_ net2229 net1895 VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__nand2_1
Xfanout2029 net2030 VGND VGND VPWR VPWR net2029 sky130_fd_sc_hd__clkbuf_1
Xfanout2018 net2019 VGND VGND VPWR VPWR net2018 sky130_fd_sc_hd__clkbuf_2
Xfanout1339 net1348 VGND VGND VPWR VPWR net1339 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1306 adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR net1306 sky130_fd_sc_hd__buf_4
Xfanout330 _02213_ VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__clkbuf_1
Xfanout341 net2936 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__buf_4
Xfanout1328 net1329 VGND VGND VPWR VPWR net1328 sky130_fd_sc_hd__clkbuf_2
Xfanout374 _06090_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__buf_6
Xfanout363 net364 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkbuf_1
XFILLER_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12900_ net2767 net1064 net746 _05949_ _05948_ VGND VGND VPWR VPWR _05950_ sky130_fd_sc_hd__o311a_1
X_13880_ net141 net315 _05568_ VGND VGND VPWR VPWR _06837_ sky130_fd_sc_hd__a21o_1
Xfanout396 net3096 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__buf_1
Xfanout385 _03826_ VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12831_ adder_inst.sum_raw_r\[1\] net2696 _05891_ net2691 VGND VGND VPWR VPWR _05892_
+ sky130_fd_sc_hd__a211o_1
XFILLER_74_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12762_ net2787 _05823_ net2696 net846 VGND VGND VPWR VPWR _05824_ sky130_fd_sc_hd__or4b_4
XTAP_TAPCELL_ROW_83_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14501_ clknet_leaf_20_clk multiplier_inst.man_final\[1\] _00323_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_83_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12693_ _05761_ _05762_ _05765_ VGND VGND VPWR VPWR _05767_ sky130_fd_sc_hd__or3_1
XFILLER_42_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11713_ _04797_ net3122 VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__nand2_2
XFILLER_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11644_ _04386_ _04727_ _04729_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__o21ai_2
X_14432_ clknet_leaf_15_clk net3388 _00254_ VGND VGND VPWR VPWR adder_inst.man_b_r\[22\]
+ sky130_fd_sc_hd__dfrtp_2
X_14363_ clknet_leaf_20_clk adder_inst.sum_raw\[12\] _00185_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput16 i_a[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11575_ _04642_ _04656_ _04657_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__and3_1
Xinput27 i_a[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_114_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13314_ net519 _06339_ _06342_ VGND VGND VPWR VPWR _06343_ sky130_fd_sc_hd__o21ai_1
Xinput49 i_b[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
X_14294_ clknet_leaf_18_clk net31 _00116_ VGND VGND VPWR VPWR adder_inst.i_a\[8\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput38 i_b[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
X_10526_ _03592_ _03607_ _03608_ _03610_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__nand4_1
X_13245_ _06271_ _06270_ VGND VGND VPWR VPWR _06274_ sky130_fd_sc_hd__nor2_1
XFILLER_6_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10457_ _03542_ net651 _03533_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__a21oi_4
X_13176_ _06204_ _06205_ VGND VGND VPWR VPWR _06206_ sky130_fd_sc_hd__nand2_4
X_10388_ _03244_ _03245_ _03247_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__a21o_1
Xfanout2563 net2564 VGND VGND VPWR VPWR net2563 sky130_fd_sc_hd__buf_1
Xfanout2530 net2531 VGND VGND VPWR VPWR net2530 sky130_fd_sc_hd__clkbuf_2
X_12127_ net3123 net116 net245 VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__nand3b_4
Xfanout2552 net2553 VGND VGND VPWR VPWR net2552 sky130_fd_sc_hd__clkbuf_4
Xfanout2541 net2548 VGND VGND VPWR VPWR net2541 sky130_fd_sc_hd__buf_2
XFILLER_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1851 net1852 VGND VGND VPWR VPWR net1851 sky130_fd_sc_hd__clkbuf_2
Xfanout1840 adder_inst.man_b_r\[6\] VGND VGND VPWR VPWR net1840 sky130_fd_sc_hd__buf_6
Xfanout2574 net2575 VGND VGND VPWR VPWR net2574 sky130_fd_sc_hd__clkbuf_2
Xfanout2585 net2586 VGND VGND VPWR VPWR net2585 sky130_fd_sc_hd__clkbuf_2
X_12058_ _05141_ _05142_ net245 VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__a21oi_1
Xfanout2596 net2598 VGND VGND VPWR VPWR net2596 sky130_fd_sc_hd__buf_2
Xfanout1873 net1875 VGND VGND VPWR VPWR net1873 sky130_fd_sc_hd__buf_4
X_11009_ _03895_ _03896_ _03897_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__a21o_1
Xfanout1884 net1885 VGND VGND VPWR VPWR net1884 sky130_fd_sc_hd__buf_1
Xfanout1862 net1863 VGND VGND VPWR VPWR net1862 sky130_fd_sc_hd__buf_1
Xfanout1895 net1897 VGND VGND VPWR VPWR net1895 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_125_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08220_ net2144 net1848 _01300_ _01302_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__a22oi_4
XFILLER_60_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08151_ net1655 net2272 net2291 net1620 VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__a22oi_1
XFILLER_107_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08082_ net2092 net2116 net1805 net1836 _01163_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__a41o_1
XFILLER_9_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08984_ _02006_ _02064_ net401 VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__nand3_2
X_07935_ _01019_ _01020_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__nand2_1
XFILLER_102_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07866_ net2070 net2098 net1715 VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__nand3_2
XFILLER_68_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09605_ _01420_ _02236_ net1496 net2524 _02235_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__o2111ai_4
XFILLER_113_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07797_ net2071 net1716 VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__nand2_1
XFILLER_83_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09536_ _02589_ _02591_ _02592_ _02595_ _02604_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__a32oi_4
XFILLER_43_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09467_ net2148 net1929 VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08418_ _01464_ _01494_ _01502_ _01503_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__o211a_1
X_09398_ _01005_ _02480_ _02412_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__a21o_1
XFILLER_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08349_ net1554 net2372 VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11360_ _04438_ _04443_ _04442_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__o21ai_1
XFILLER_138_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10311_ net1544 net2584 net2611 net1516 VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__a22oi_4
XFILLER_4_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13030_ net783 net861 VGND VGND VPWR VPWR _06060_ sky130_fd_sc_hd__nor2_1
X_11291_ _04357_ _04360_ _04361_ _04376_ net635 VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__a32oi_4
XFILLER_133_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10242_ _03322_ _03324_ _03325_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__nand3_4
XFILLER_120_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1103 net1104 VGND VGND VPWR VPWR net1103 sky130_fd_sc_hd__clkbuf_1
X_10173_ _03256_ _03257_ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__nand2_4
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1114 net1115 VGND VGND VPWR VPWR net1114 sky130_fd_sc_hd__clkbuf_4
Xfanout1136 net1138 VGND VGND VPWR VPWR net1136 sky130_fd_sc_hd__buf_2
Xfanout1125 _06902_ VGND VGND VPWR VPWR net1125 sky130_fd_sc_hd__buf_2
Xfanout1147 net1150 VGND VGND VPWR VPWR net1147 sky130_fd_sc_hd__buf_2
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_93_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout171 _06558_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_8
Xfanout182 _03010_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_2
Xfanout1158 net1159 VGND VGND VPWR VPWR net1158 sky130_fd_sc_hd__clkbuf_1
Xfanout1169 net1171 VGND VGND VPWR VPWR net1169 sky130_fd_sc_hd__buf_4
X_13932_ _06871_ _05636_ net3128 net104 VGND VGND VPWR VPWR _06874_ sky130_fd_sc_hd__and4bb_1
XFILLER_86_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout193 _06297_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_6
X_13863_ _05550_ _05551_ VGND VGND VPWR VPWR _06825_ sky130_fd_sc_hd__or2_4
XFILLER_90_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13794_ net3434 net726 VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__and2_1
X_12814_ net1315 _05787_ _05802_ VGND VGND VPWR VPWR _05876_ sky130_fd_sc_hd__a21o_1
XFILLER_28_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12745_ net1305 net1299 net2725 VGND VGND VPWR VPWR _05807_ sky130_fd_sc_hd__o21a_1
XFILLER_63_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12676_ adder_inst.sign_b_r adder_inst.sign_a_r VGND VGND VPWR VPWR _05752_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_41_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14415_ clknet_leaf_17_clk net3361 _00237_ VGND VGND VPWR VPWR adder_inst.man_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_11627_ _04712_ net2629 net1767 _04711_ VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__nand4_2
X_14346_ clknet_leaf_12_clk net53 _00168_ VGND VGND VPWR VPWR adder_inst.exp_b\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_11558_ _04626_ _04616_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__nand2_1
XFILLER_128_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10509_ _03571_ _03583_ _03592_ _03593_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__nand4_2
X_14277_ net2869 VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__inv_2
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11489_ _04572_ _04574_ _04115_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__nand3_1
X_13228_ _06255_ _06256_ VGND VGND VPWR VPWR _06257_ sky130_fd_sc_hd__nand2b_1
XFILLER_97_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13159_ net286 _06188_ VGND VGND VPWR VPWR _06189_ sky130_fd_sc_hd__and2_4
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2371 net2372 VGND VGND VPWR VPWR net2371 sky130_fd_sc_hd__buf_4
Xfanout2360 adder_inst.man_a_r\[11\] VGND VGND VPWR VPWR net2360 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_127_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07720_ _00796_ _00805_ VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__nand2_1
Xfanout2382 net2383 VGND VGND VPWR VPWR net2382 sky130_fd_sc_hd__buf_1
XFILLER_66_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2393 net2394 VGND VGND VPWR VPWR net2393 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1681 net1682 VGND VGND VPWR VPWR net1681 sky130_fd_sc_hd__buf_1
Xfanout1692 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net1692 sky130_fd_sc_hd__clkbuf_2
Xfanout1670 net1675 VGND VGND VPWR VPWR net1670 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_140_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07651_ _00732_ net2244 net1483 VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__nand3_1
XFILLER_93_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07582_ net2082 net1597 _00466_ _00467_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__a211oi_1
XFILLER_80_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09321_ net1504 net820 net2335 _01976_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_105_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09252_ _02008_ _02011_ _02337_ _00944_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__a211oi_1
XFILLER_21_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08203_ net2090 net1928 VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__nand2_1
X_09183_ _01485_ _01486_ _01487_ net436 VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_138_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08134_ net1587 net2345 VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__nand2_1
X_08065_ net701 net699 net714 VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__a21boi_1
XFILLER_115_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08967_ _02023_ _02052_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__nand2_1
XFILLER_57_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07918_ _00992_ _00998_ VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__nand2_1
X_08898_ _01836_ _01842_ _01980_ _01982_ VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__o211a_1
X_07849_ _00923_ _00925_ _00924_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_67_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10860_ _03943_ _03944_ _03910_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_27_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09519_ _02595_ _02596_ net902 _02602_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10791_ net634 _03660_ net1307 _03670_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__o211ai_1
X_12530_ _05615_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__inv_2
XFILLER_138_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12461_ _05321_ _05317_ _03476_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__a21boi_4
XFILLER_12_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14200_ net2888 VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__inv_2
X_11412_ _04422_ _04441_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__nor2_1
X_14131_ net2893 VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__inv_2
XFILLER_126_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12392_ _05475_ _05476_ _05461_ VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_78_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11343_ net1704 net1736 net2596 net2623 VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__nand4_2
XFILLER_125_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14062_ net2838 VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__inv_2
X_11274_ _04359_ _04287_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__nand2_1
XFILLER_4_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13013_ net1325 net1996 _06044_ net1321 VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__o31a_1
XFILLER_79_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10225_ _03306_ _03307_ _03304_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__a21oi_1
XFILLER_133_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10156_ _02994_ _02795_ _02993_ _03003_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__o211ai_2
XFILLER_59_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10087_ _03171_ _03167_ net892 VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__o21ai_1
X_13915_ _05615_ _05623_ net128 VGND VGND VPWR VPWR _06861_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13846_ _05294_ _06808_ _06804_ _06801_ _06799_ VGND VGND VPWR VPWR _06809_ sky130_fd_sc_hd__a2111o_1
X_13777_ net2011 net1283 net515 VGND VGND VPWR VPWR adder_inst.exp_larger\[1\] sky130_fd_sc_hd__mux2_1
X_10989_ _04073_ net564 _04047_ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__a21boi_4
X_12728_ net1308 net1303 VGND VGND VPWR VPWR _05790_ sky130_fd_sc_hd__or2_1
X_12659_ _05736_ net2002 net1276 VGND VGND VPWR VPWR _05738_ sky130_fd_sc_hd__and3_1
XFILLER_128_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold416 adder_inst.i_b\[31\] VGND VGND VPWR VPWR net3334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold427 adder_inst.i_a\[1\] VGND VGND VPWR VPWR net3345 sky130_fd_sc_hd__dlygate4sd3_1
X_14329_ clknet_leaf_18_clk net35 _00151_ VGND VGND VPWR VPWR adder_inst.i_b\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_132_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap157 _06610_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_1
Xhold449 adder_inst.exp_b\[5\] VGND VGND VPWR VPWR net3367 sky130_fd_sc_hd__dlygate4sd3_1
Xhold438 adder_inst.i_b\[11\] VGND VGND VPWR VPWR net3356 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout907 _01853_ VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_4
X_09870_ net1460 net2581 VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__nand2_1
X_08821_ _01869_ _01870_ _01902_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__nand3_1
Xfanout929 net933 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__buf_8
Xfanout918 net919 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__buf_8
XFILLER_112_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08752_ net1623 net2237 net1658 net2213 VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__a22oi_1
Xfanout2190 net3002 VGND VGND VPWR VPWR net2190 sky130_fd_sc_hd__buf_1
X_07703_ net599 _00756_ net411 _00787_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_107_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08683_ _01757_ _01764_ _01766_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__nand3_1
X_07634_ _00615_ _00718_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_49_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07565_ net1043 net995 _00650_ VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__o21ai_1
XFILLER_41_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07496_ _00495_ net616 _00575_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__and3_1
X_09304_ _02388_ _02389_ _02378_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__a21oi_2
XFILLER_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09235_ _02320_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_32_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09166_ net1461 net2554 VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__nand2_1
XFILLER_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08117_ net995 net977 VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__nor2_4
X_09097_ net1576 net2403 _01396_ _01398_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__a22oi_4
XFILLER_135_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08048_ _01128_ net1773 net2200 _01130_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__a31o_1
XFILLER_134_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10010_ net459 net458 _02856_ _02857_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09999_ net660 _03077_ _03084_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__a21o_1
XFILLER_76_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11961_ _04932_ _04934_ _04954_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__o21ai_2
XFILLER_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13700_ _06707_ _06358_ VGND VGND VPWR VPWR _06714_ sky130_fd_sc_hd__nand2_1
XFILLER_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10912_ _03755_ _03757_ net569 _03732_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__o211ai_2
XFILLER_72_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11892_ _04879_ _04880_ _04882_ _04877_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__a22o_1
XFILLER_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13631_ net856 net1783 _06651_ _06653_ VGND VGND VPWR VPWR _06654_ sky130_fd_sc_hd__a31o_1
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10843_ net2416 net1813 net2445 net1784 VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__a22oi_4
X_13562_ net162 _06590_ _06589_ VGND VGND VPWR VPWR _06591_ sky130_fd_sc_hd__a21oi_1
X_10774_ _03827_ _03855_ _03856_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__o21ai_1
X_12513_ _00702_ _00704_ _00815_ _05597_ VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_100_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13493_ net526 _06516_ _06508_ _06520_ VGND VGND VPWR VPWR _06522_ sky130_fd_sc_hd__o211a_1
XFILLER_12_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12444_ _06924_ _05528_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__or2_1
XFILLER_125_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12375_ _05457_ _05460_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14114_ net2817 VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__inv_2
XFILLER_4_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11326_ net633 net632 _04406_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__nand3_4
X_14045_ net2878 VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__inv_2
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11257_ _04341_ _04333_ _04316_ _04342_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__o211ai_4
XFILLER_95_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10208_ net3084 _03287_ _03290_ _03291_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__a2bb2oi_2
X_11188_ net1764 net2567 VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__nand2_1
X_10139_ net327 _02917_ _02984_ _02985_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_35_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13829_ _04234_ _05536_ VGND VGND VPWR VPWR _06792_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_18_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07350_ _07028_ _07068_ _07075_ VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_102_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07281_ net601 _07048_ _07049_ _07051_ VGND VGND VPWR VPWR _07052_ sky130_fd_sc_hd__and4_1
X_09020_ _02102_ _02098_ _02091_ _02090_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_135_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout704 _00717_ VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__clkbuf_2
Xfanout715 _01093_ VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__buf_6
X_09922_ net209 _02761_ _02769_ _02771_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__nand4_1
Xfanout726 net729 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__buf_1
XFILLER_131_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout737 net738 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_113_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09853_ _02937_ net2581 net1495 VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__and3_1
Xfanout759 _05782_ VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__buf_1
X_08804_ _01679_ _01882_ _01883_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__nand3b_4
X_09784_ _02864_ _02868_ _02869_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_0_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08735_ _01675_ _01666_ _01815_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__o21ai_4
XFILLER_73_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08666_ net821 _01748_ _01751_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__a21o_2
XANTENNA_108 net1722 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07617_ _00594_ _00595_ _00701_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__and3_1
XFILLER_121_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08597_ _01178_ net941 _01180_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__o21ai_1
XFILLER_81_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07548_ _00633_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__inv_2
XFILLER_139_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07479_ _00557_ _00558_ _00564_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_46_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer321 _05514_ VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__dlygate4sd1_1
X_09218_ _01741_ _01742_ net210 _01731_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__o211ai_1
Xrebuffer310 _06304_ VGND VGND VPWR VPWR net3228 sky130_fd_sc_hd__buf_6
Xrebuffer332 _03664_ VGND VGND VPWR VPWR net1307 sky130_fd_sc_hd__buf_2
X_10490_ net886 _03383_ _03384_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__a21o_1
XFILLER_108_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer354 _06490_ VGND VGND VPWR VPWR net1783 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer343 _06371_ VGND VGND VPWR VPWR net3261 sky130_fd_sc_hd__buf_6
XFILLER_5_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09149_ _02232_ _02233_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__nand2_2
Xrebuffer398 _06523_ VGND VGND VPWR VPWR net3316 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_75_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer387 _06091_ VGND VGND VPWR VPWR net3305 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer376 net277 VGND VGND VPWR VPWR net3294 sky130_fd_sc_hd__buf_8
X_12160_ _05198_ _05200_ _05206_ _05207_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__o211a_4
XFILLER_30_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11111_ _04174_ _04176_ _04186_ _04188_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2915 net2916 VGND VGND VPWR VPWR net2915 sky130_fd_sc_hd__buf_1
Xfanout2904 net2915 VGND VGND VPWR VPWR net2904 sky130_fd_sc_hd__clkbuf_1
X_12091_ _05175_ net2675 net1860 _05174_ VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__and4_1
X_11042_ net640 _04115_ net563 net561 VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__a22o_1
XFILLER_131_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_55_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12993_ net1325 net1995 _06028_ net1321 VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__o31a_1
XFILLER_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11944_ net792 net2674 net1767 _04938_ VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_86_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11875_ _04960_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__inv_2
X_13614_ net138 _06638_ _06611_ _06564_ net854 VGND VGND VPWR VPWR _06639_ sky130_fd_sc_hd__a221o_1
XFILLER_72_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10826_ _03746_ _03748_ net1183 net1169 VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__o2bb2ai_2
X_14594_ clknet_leaf_7_clk net3419 _00416_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
X_13545_ _06573_ _06572_ VGND VGND VPWR VPWR _06574_ sky130_fd_sc_hd__nor2_1
X_10757_ net1101 net1094 net1019 VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__or3_1
X_13476_ _06504_ VGND VGND VPWR VPWR _06505_ sky130_fd_sc_hd__inv_2
XFILLER_9_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10688_ net1694 net1726 net2474 net2510 VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__nand4_1
X_12427_ _05491_ _05510_ _05512_ VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_117_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12358_ _07047_ _05443_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__nor2_1
XFILLER_99_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12289_ _05372_ _05374_ _05373_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__a21boi_2
XFILLER_113_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11309_ _04391_ _04388_ _04390_ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__nand3_2
X_14028_ net2843 VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__inv_2
XFILLER_82_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08520_ _01583_ _01602_ _01603_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__nand3b_1
XFILLER_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08451_ _01533_ _01534_ _01518_ VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_46_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07402_ net1420 net2193 _00450_ _00451_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__a22o_1
XFILLER_91_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08382_ net1468 net2459 net2491 net1435 VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__a22o_1
X_07333_ _07070_ _07073_ _07071_ VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__a21oi_2
XFILLER_137_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07264_ net2081 net1453 net2109 net1489 VGND VGND VPWR VPWR _07035_ sky130_fd_sc_hd__nand4_2
X_09003_ _01285_ _01287_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__nand2_1
X_07195_ _06964_ _06963_ _06965_ VGND VGND VPWR VPWR _06966_ sky130_fd_sc_hd__and3_1
XFILLER_132_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout512 net514 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__buf_1
Xfanout523 net524 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__buf_1
Xfanout501 net504 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__buf_6
X_09905_ _02986_ _02989_ net327 VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__o21ai_2
Xfanout545 net547 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_70_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout556 _04575_ VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout589 _02632_ VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__clkbuf_1
Xfanout567 _03850_ VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__clkbuf_1
Xfanout578 _03358_ VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__buf_6
X_09836_ net1574 net2501 VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__nand2_1
X_09767_ _02850_ _02851_ _02846_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__a21oi_4
XFILLER_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08718_ net682 net681 VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__nand2_1
X_09698_ _02762_ _02767_ net351 VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__o21ai_2
XFILLER_27_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer50 _01866_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_2
X_08649_ _01544_ _01492_ _01543_ _01491_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__a31o_1
Xrebuffer72 _04795_ VGND VGND VPWR VPWR net2990 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer61 net3125 VGND VGND VPWR VPWR net2979 sky130_fd_sc_hd__buf_6
XFILLER_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer83 _05299_ VGND VGND VPWR VPWR net3001 sky130_fd_sc_hd__dlygate4sd1_1
X_11660_ _04419_ _04463_ _04464_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__nand3_1
XFILLER_30_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10611_ net2298 net1930 VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__and2_1
X_11591_ net1170 net1134 _04672_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__o21ai_2
X_13330_ _06356_ _06358_ VGND VGND VPWR VPWR _06359_ sky130_fd_sc_hd__nand2_4
X_10542_ net1499 net2664 VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__nand2_1
XFILLER_127_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13261_ net494 net217 net3192 _06289_ VGND VGND VPWR VPWR _06290_ sky130_fd_sc_hd__o31ai_1
Xrebuffer140 net3105 VGND VGND VPWR VPWR net3058 sky130_fd_sc_hd__clkbuf_2
Xrebuffer162 net3242 VGND VGND VPWR VPWR net3080 sky130_fd_sc_hd__buf_1
Xrebuffer173 _02106_ VGND VGND VPWR VPWR net3091 sky130_fd_sc_hd__buf_6
Xrebuffer151 _04219_ VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlymetal6s2s_1
X_12212_ _05145_ _05155_ _05215_ _05297_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__a31oi_4
X_10473_ net1694 net2474 VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__nand2_1
XFILLER_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13192_ net773 net540 net2395 VGND VGND VPWR VPWR _06222_ sky130_fd_sc_hd__a21o_1
Xrebuffer195 _03042_ VGND VGND VPWR VPWR net3113 sky130_fd_sc_hd__buf_6
Xrebuffer184 _03359_ VGND VGND VPWR VPWR net3102 sky130_fd_sc_hd__buf_2
Xfanout2712 net2713 VGND VGND VPWR VPWR net2712 sky130_fd_sc_hd__buf_4
Xfanout2701 net2707 VGND VGND VPWR VPWR net2701 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_63_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12143_ net1916 net2656 net1096 _06898_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_123_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2734 net2735 VGND VGND VPWR VPWR net2734 sky130_fd_sc_hd__buf_1
XFILLER_111_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2745 adder_inst.sum_raw_r\[18\] VGND VGND VPWR VPWR net2745 sky130_fd_sc_hd__buf_1
X_12074_ net1962 net2601 VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__nand2_1
Xfanout2756 net2757 VGND VGND VPWR VPWR net2756 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2767 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR net2767 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_110_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2778 adder_inst.sum_raw_r\[5\] VGND VGND VPWR VPWR net2778 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_104_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11025_ net796 net2649 net1582 net870 VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__nand4_1
Xfanout2789 net2791 VGND VGND VPWR VPWR net2789 sky130_fd_sc_hd__clkbuf_2
XFILLER_92_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12976_ _06015_ _06016_ net242 VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__o21a_1
XFILLER_45_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11927_ net1890 net1915 net2573 net2599 _05003_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__a41o_1
X_11858_ net1765 net2653 _04853_ _04855_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__a22oi_1
X_14577_ clknet_leaf_1_clk net3423 _00399_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
XANTENNA_19 net2168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10809_ _03772_ _03894_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__nand2_2
X_11789_ _04719_ _04720_ _04700_ net450 VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__o211ai_2
XFILLER_119_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13528_ _06549_ _06553_ _06556_ VGND VGND VPWR VPWR _06557_ sky130_fd_sc_hd__o21ai_1
XFILLER_9_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13459_ net1091 net3191 net604 net735 net3166 VGND VGND VPWR VPWR _06488_ sky130_fd_sc_hd__a221o_1
XFILLER_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_81_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07951_ net477 _01036_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_110_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07882_ _00829_ _00826_ _00966_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__a21oi_1
XFILLER_68_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09621_ _02230_ _02231_ _02234_ _02239_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_55_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09552_ net2314 net1731 net2340 net1699 VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__a22oi_2
XFILLER_102_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08503_ net1555 net2316 VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__nand2_1
XFILLER_55_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09483_ _02566_ _02567_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__nand2_2
X_08434_ net1239 net1173 VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__nor2_1
XFILLER_24_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08365_ _01442_ _01445_ _01430_ _01446_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__o211ai_2
XFILLER_11_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07316_ net1452 net2134 VGND VGND VPWR VPWR _07087_ sky130_fd_sc_hd__nand2_1
X_08296_ _01381_ _01376_ _01380_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__nand3_2
X_07247_ _07016_ _07017_ _07008_ _07010_ VGND VGND VPWR VPWR _07018_ sky130_fd_sc_hd__o211ai_2
XFILLER_124_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07178_ net2054 net1537 VGND VGND VPWR VPWR _06949_ sky130_fd_sc_hd__and2_1
XFILLER_133_732 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2019 net2020 VGND VGND VPWR VPWR net2019 sky130_fd_sc_hd__clkbuf_2
Xfanout2008 adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR net2008 sky130_fd_sc_hd__clkbuf_1
Xfanout320 net321 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_1
Xfanout1318 net1323 VGND VGND VPWR VPWR net1318 sky130_fd_sc_hd__buf_1
Xfanout331 _01394_ VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__buf_6
Xfanout1329 net1330 VGND VGND VPWR VPWR net1329 sky130_fd_sc_hd__buf_1
Xfanout353 _02367_ VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__buf_4
Xfanout342 _06117_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__buf_6
Xfanout364 _06107_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_129_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout397 _02621_ VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__buf_6
XFILLER_47_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09819_ net587 net585 _02889_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__and3_1
XFILLER_46_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout386 _03558_ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__buf_6
X_12830_ net2787 net2702 net842 VGND VGND VPWR VPWR _05891_ sky130_fd_sc_hd__and3_1
XFILLER_100_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12761_ net2781 net2778 net2779 net2773 VGND VGND VPWR VPWR _05823_ sky130_fd_sc_hd__or4_1
XFILLER_55_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14500_ clknet_leaf_20_clk multiplier_inst.man_final\[0\] _00322_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_83_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12692_ adder_inst.i_a\[21\] adder_inst.i_a\[20\] adder_inst.i_a\[22\] _05764_ VGND
+ VGND VPWR VPWR _05766_ sky130_fd_sc_hd__or4_2
X_11712_ _04785_ _04219_ _04794_ _04790_ VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14431_ clknet_leaf_17_clk net3350 _00253_ VGND VGND VPWR VPWR adder_inst.man_b_r\[21\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_25_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11643_ _04385_ net3081 _04409_ _04411_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_11_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_138_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14362_ clknet_leaf_2_clk adder_inst.sum_raw\[11\] _00184_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput17 i_a[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 i_a[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
X_11574_ _04631_ _04641_ _04654_ _04655_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_114_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13313_ net1091 net1274 net603 net734 net2253 VGND VGND VPWR VPWR _06342_ sky130_fd_sc_hd__a221o_1
X_14293_ clknet_leaf_13_clk net30 _00115_ VGND VGND VPWR VPWR adder_inst.i_a\[7\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput39 i_b[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
X_10525_ _03607_ _03608_ _03609_ _03591_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__o2bb2ai_4
XTAP_TAPCELL_ROW_114_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13244_ _06270_ _06271_ VGND VGND VPWR VPWR _06273_ sky130_fd_sc_hd__nand2_1
X_10456_ _03536_ _03538_ _03535_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__o21bai_4
XFILLER_124_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13175_ net269 _06195_ _06196_ net281 VGND VGND VPWR VPWR _06205_ sky130_fd_sc_hd__o211ai_2
XFILLER_124_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10387_ _03244_ _03245_ _03247_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__nand3_1
Xfanout2520 net2521 VGND VGND VPWR VPWR net2520 sky130_fd_sc_hd__buf_4
X_12126_ _05208_ net3158 net246 _05202_ VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__and4b_1
XFILLER_69_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2542 net2544 VGND VGND VPWR VPWR net2542 sky130_fd_sc_hd__buf_8
Xfanout2531 net2534 VGND VGND VPWR VPWR net2531 sky130_fd_sc_hd__clkbuf_2
Xfanout2553 net2556 VGND VGND VPWR VPWR net2553 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1852 net1853 VGND VGND VPWR VPWR net1852 sky130_fd_sc_hd__clkbuf_2
Xfanout2575 net2576 VGND VGND VPWR VPWR net2575 sky130_fd_sc_hd__buf_6
Xfanout1830 adder_inst.man_b_r\[6\] VGND VGND VPWR VPWR net1830 sky130_fd_sc_hd__buf_4
X_12057_ _05139_ _05140_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__nand2_1
Xfanout2586 net2590 VGND VGND VPWR VPWR net2586 sky130_fd_sc_hd__buf_1
Xfanout2564 net2580 VGND VGND VPWR VPWR net2564 sky130_fd_sc_hd__buf_2
Xfanout1874 net1875 VGND VGND VPWR VPWR net1874 sky130_fd_sc_hd__buf_1
X_11008_ net1208 net1121 net973 net898 _03895_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__o221ai_4
Xfanout2597 net2598 VGND VGND VPWR VPWR net2597 sky130_fd_sc_hd__clkbuf_2
XFILLER_37_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1863 adder_inst.man_b_r\[5\] VGND VGND VPWR VPWR net1863 sky130_fd_sc_hd__buf_4
Xfanout1885 net1892 VGND VGND VPWR VPWR net1885 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1896 net1897 VGND VGND VPWR VPWR net1896 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_125_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12959_ net2758 _05801_ net1081 net2752 net2732 VGND VGND VPWR VPWR _06001_ sky130_fd_sc_hd__a32o_1
XFILLER_92_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08150_ net1619 net1654 net2272 net2291 VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__nand4_1
XFILLER_14_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08081_ _01164_ _01166_ _01163_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__o21ai_1
XFILLER_106_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08983_ _02004_ _02001_ net355 _02066_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__o211ai_1
XFILLER_87_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07934_ net1473 net2303 VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__nand2_1
X_07865_ net2070 net1751 VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__nand2_1
XFILLER_68_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09604_ _02687_ _02683_ _02686_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__o21ai_1
XFILLER_113_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07796_ _00777_ _00881_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__nor2_2
X_09535_ _02610_ _02585_ _02615_ _02614_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__o211ai_2
XFILLER_37_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09466_ net2148 net1930 VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_65_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08417_ net1046 net917 net1411 net2497 _01499_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__o2111ai_2
XFILLER_24_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09397_ _01005_ _02480_ _02412_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__a21oi_2
XFILLER_51_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08348_ net1502 net2442 VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__and2_1
X_08279_ net1652 net2315 net2344 net1616 VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__a22o_1
XFILLER_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10310_ net1547 net2607 VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__nand2_1
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11290_ _04375_ _04373_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__nand2_4
XFILLER_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10241_ _03089_ _03323_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__nand2_1
XFILLER_106_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1104 net1108 VGND VGND VPWR VPWR net1104 sky130_fd_sc_hd__clkbuf_2
X_10172_ net2204 net1945 net1970 net2177 VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__a22oi_2
Xfanout1126 net1127 VGND VGND VPWR VPWR net1126 sky130_fd_sc_hd__clkbuf_2
Xfanout1137 net1138 VGND VGND VPWR VPWR net1137 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1115 _06905_ VGND VGND VPWR VPWR net1115 sky130_fd_sc_hd__clkbuf_4
X_13931_ _06871_ _06872_ _05628_ _06869_ VGND VGND VPWR VPWR _06873_ sky130_fd_sc_hd__a2bb2o_1
Xfanout161 _06619_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_2
Xfanout150 _06611_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_6
Xfanout172 _06449_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_1
Xfanout183 _02305_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_4
Xfanout1148 net1150 VGND VGND VPWR VPWR net1148 sky130_fd_sc_hd__clkbuf_1
Xfanout1159 net1160 VGND VGND VPWR VPWR net1159 sky130_fd_sc_hd__clkbuf_2
Xfanout194 net2935 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_1
X_13862_ _05550_ _06824_ VGND VGND VPWR VPWR multiplier_inst.man_final\[0\] sky130_fd_sc_hd__nor2_2
XFILLER_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13793_ net3407 net724 VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__and2_1
X_12813_ net1308 net1304 net1298 VGND VGND VPWR VPWR _05875_ sky130_fd_sc_hd__a21oi_1
X_12744_ net1300 _05805_ net1077 net2738 VGND VGND VPWR VPWR _05806_ sky130_fd_sc_hd__o211a_1
X_12675_ adder_inst.exp_a\[6\] _05750_ _05751_ VGND VGND VPWR VPWR adder_inst.man_a\[23\]
+ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_41_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14414_ clknet_leaf_17_clk net3369 _00236_ VGND VGND VPWR VPWR adder_inst.man_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_11626_ _04401_ _04710_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__nand2_1
X_14345_ clknet_leaf_12_clk net52 _00167_ VGND VGND VPWR VPWR adder_inst.exp_b\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_11557_ _04619_ _04622_ _04623_ _04616_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__a31oi_2
XFILLER_116_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10508_ _03592_ _03593_ _03584_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__a21o_1
X_14276_ net2868 VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__inv_2
X_11488_ _04108_ _04110_ _04112_ _04098_ VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__o22ai_2
X_13227_ net2059 net529 net216 net2944 _06254_ VGND VGND VPWR VPWR _06256_ sky130_fd_sc_hd__a221o_1
X_10439_ _03521_ _03522_ _03518_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__nand3_2
X_13158_ net260 _06185_ _06187_ VGND VGND VPWR VPWR _06188_ sky130_fd_sc_hd__o21ai_2
Xfanout2361 net2363 VGND VGND VPWR VPWR net2361 sky130_fd_sc_hd__clkbuf_2
X_13089_ net341 net364 VGND VGND VPWR VPWR _06119_ sky130_fd_sc_hd__nand2_1
X_12109_ _05156_ _05185_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__nand2_1
Xfanout2350 net2352 VGND VGND VPWR VPWR net2350 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_127_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2383 net2384 VGND VGND VPWR VPWR net2383 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1660 net1662 VGND VGND VPWR VPWR net1660 sky130_fd_sc_hd__buf_2
Xfanout2372 net2373 VGND VGND VPWR VPWR net2372 sky130_fd_sc_hd__buf_4
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2394 net2395 VGND VGND VPWR VPWR net2394 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1682 net1691 VGND VGND VPWR VPWR net1682 sky130_fd_sc_hd__clkbuf_1
Xfanout1671 net1673 VGND VGND VPWR VPWR net1671 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_140_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07650_ _00642_ net2277 net1449 VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_0_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07581_ _00665_ _00666_ net2023 net1687 _00664_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__o2111a_1
XFILLER_93_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09320_ net819 net2335 net1503 VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__and3_1
XFILLER_80_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09251_ net2048 net1779 net1807 net2021 VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__a22oi_1
X_08202_ net2091 net1928 VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__and2_1
XFILLER_138_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09182_ _01485_ _01486_ _01487_ net436 VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_138_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08133_ net697 VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__inv_2
X_08064_ _01145_ _01146_ _01136_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__nand3_1
XFILLER_119_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08966_ _02044_ _02045_ _02037_ net679 VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__o211ai_2
XFILLER_69_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07917_ _00988_ _01000_ _00992_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__o21ai_1
X_08897_ _01836_ _01842_ _01982_ VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__o21ai_2
XFILLER_75_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07848_ _00931_ _00932_ _00929_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_67_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07779_ net1267 net1218 _00736_ _00737_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__o211ai_2
X_09518_ net1227 net1222 net945 net902 _02601_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__o32a_1
XTAP_TAPCELL_ROW_80_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10790_ _03659_ _03660_ net1286 VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__o21ai_2
XFILLER_25_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09449_ _01752_ _02081_ _02079_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__a21o_1
XFILLER_130_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12460_ _05545_ VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__inv_2
X_12391_ _05461_ _05475_ _05476_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__nand3_1
X_11411_ _04495_ _04496_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__nand2_1
XFILLER_138_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14130_ net2905 VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__inv_2
X_11342_ net1703 net2592 VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__nand2_1
XFILLER_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14061_ net2850 VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__inv_2
X_11273_ net865 net795 VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__nand2_1
X_13012_ _05832_ _05830_ _06923_ VGND VGND VPWR VPWR _06044_ sky130_fd_sc_hd__and3b_1
X_10224_ _03306_ _03307_ _03304_ VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__nand3_4
XFILLER_121_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10155_ _03221_ net3018 _03225_ net3063 _03239_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__a32o_1
XFILLER_48_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10086_ net892 _03171_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__nand2_1
X_13914_ net104 _05613_ _05617_ _05618_ _06860_ VGND VGND VPWR VPWR multiplier_inst.man_final\[16\]
+ sky130_fd_sc_hd__a41oi_2
XFILLER_59_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_122_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13845_ _05290_ _06806_ _06807_ VGND VGND VPWR VPWR _06808_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_122_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13776_ net2013 net1285 net515 VGND VGND VPWR VPWR adder_inst.exp_larger\[0\] sky130_fd_sc_hd__mux2_1
X_10988_ _04073_ net564 _04040_ _04046_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__o2bb2ai_4
X_12727_ net2685 adder_inst.exp_larger_r\[7\] _05787_ _05788_ VGND VGND VPWR VPWR
+ _05789_ sky130_fd_sc_hd__nand4_1
X_12658_ net1275 net2001 _05736_ VGND VGND VPWR VPWR _05737_ sky130_fd_sc_hd__a21oi_1
X_11609_ net607 _04693_ _04675_ _04678_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_128_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12589_ net121 net786 _06933_ _06930_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__a31oi_1
Xclkbuf_leaf_10_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_13_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire381 _05450_ VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkbuf_1
Xhold417 adder_inst.i_a\[31\] VGND VGND VPWR VPWR net3335 sky130_fd_sc_hd__dlygate4sd3_1
X_14328_ clknet_leaf_18_clk net34 _00150_ VGND VGND VPWR VPWR adder_inst.i_b\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_14259_ net2891 VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold428 adder_inst.i_b\[17\] VGND VGND VPWR VPWR net3346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold439 adder_inst.i_a\[10\] VGND VGND VPWR VPWR net3357 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout908 _01762_ VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__clkbuf_2
XFILLER_98_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08820_ _01871_ net467 _01901_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__nand3_1
Xfanout919 _01419_ VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__buf_8
Xfanout2180 net2181 VGND VGND VPWR VPWR net2180 sky130_fd_sc_hd__buf_4
XFILLER_39_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2191 net2192 VGND VGND VPWR VPWR net2191 sky130_fd_sc_hd__buf_1
XFILLER_97_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08751_ net2213 net1623 net2237 net1657 VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__nand4_2
X_07702_ net599 _00756_ net411 _00787_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_107_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1490 net1491 VGND VGND VPWR VPWR net1490 sky130_fd_sc_hd__clkbuf_2
X_08682_ net685 VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07633_ net1564 net2187 net2218 net1539 VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_49_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07564_ _00647_ net2281 net1421 _00646_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__nand4_4
X_07495_ _00495_ net616 VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__and2_1
X_09303_ _02383_ _02384_ _02387_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_62_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09234_ _02087_ _02318_ _02084_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09165_ _02249_ _02250_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__nand2_1
X_08116_ net2227 net1745 VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__nand2_1
XFILLER_119_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09096_ _02174_ _02175_ _02176_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__nand3_4
X_08047_ net1008 net952 _01132_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__o21ai_2
XFILLER_134_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09998_ _03080_ _03082_ net967 net943 VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__o2bb2a_1
X_08949_ _01848_ net907 _01851_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__a21o_1
XFILLER_29_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11960_ _05018_ _05019_ _05020_ net447 _05042_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__a32o_1
XFILLER_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10911_ net569 _03732_ _03755_ _03757_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_71_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11891_ _04877_ _04879_ _04880_ _04882_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__nand4_1
X_13630_ net138 _06652_ _06611_ net3295 net855 VGND VGND VPWR VPWR _06653_ sky130_fd_sc_hd__a221oi_2
X_10842_ net1789 net2445 VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__nand2_1
X_13561_ _06586_ _06583_ VGND VGND VPWR VPWR _06590_ sky130_fd_sc_hd__and2_4
X_10773_ _03857_ _03858_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__nand2_2
X_12512_ _00818_ _05596_ net185 _00704_ _00816_ VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__o2111ai_4
XFILLER_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13492_ net3296 _06516_ _06519_ VGND VGND VPWR VPWR _06521_ sky130_fd_sc_hd__o21a_4
X_12443_ _06924_ _05528_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__nor2_1
X_12374_ _05458_ _05459_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14113_ net2817 VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__inv_2
X_11325_ _04395_ net632 _04406_ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__and3_1
XFILLER_125_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14044_ net2865 VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__inv_2
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11256_ _04337_ _04327_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__nand2_1
XFILLER_122_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10207_ net1317 _03048_ _03055_ _03057_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__o2bb2ai_2
X_11187_ net1798 net1829 net2512 net2541 VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__nand4_4
XFILLER_94_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10138_ _02986_ _02989_ net327 _02917_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__o211ai_2
XFILLER_85_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10069_ _03151_ _02974_ _03149_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__nand3_4
XFILLER_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13828_ _04805_ _06790_ VGND VGND VPWR VPWR _06791_ sky130_fd_sc_hd__xor2_1
XFILLER_16_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_102_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13759_ net152 _06765_ VGND VGND VPWR VPWR _06766_ sky130_fd_sc_hd__nand2_4
XFILLER_90_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07280_ _06976_ _06978_ VGND VGND VPWR VPWR _07051_ sky130_fd_sc_hd__nand2_1
XFILLER_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09921_ _02768_ _02770_ net209 _02761_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__o211ai_1
XFILLER_131_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout705 _00716_ VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__buf_6
Xfanout727 net729 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__buf_1
Xfanout738 net739 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__clkbuf_1
Xfanout749 _05835_ VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_113_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout716 _00667_ VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__buf_1
X_09852_ net1494 net2583 VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__nand2_1
XFILLER_86_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08803_ _01880_ _01884_ _01679_ _01886_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__o211ai_4
X_09783_ _02586_ net462 _02606_ _02607_ VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__nand4_1
XFILLER_100_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08734_ _01816_ _01814_ _01819_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__o21ai_4
X_08665_ _01616_ _01625_ _01747_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__a21oi_2
XANTENNA_109 net1782 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07616_ _00594_ _00595_ _00701_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__a21o_1
XFILLER_121_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08596_ net1269 net1154 _01180_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_37_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07547_ _00627_ _00630_ _00631_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__nand3_2
XFILLER_139_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07478_ _00562_ _00563_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_101_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09217_ net210 _01731_ _01743_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__a21bo_1
Xrebuffer311 net272 VGND VGND VPWR VPWR net3229 sky130_fd_sc_hd__buf_4
XFILLER_10_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer322 _03681_ VGND VGND VPWR VPWR net1140 sky130_fd_sc_hd__buf_6
Xrebuffer300 _04519_ VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlymetal6s4s_1
Xrebuffer355 _06394_ VGND VGND VPWR VPWR net1812 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer333 _06204_ VGND VGND VPWR VPWR net3251 sky130_fd_sc_hd__buf_4
X_09148_ net1548 net2462 net2491 net1521 VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__a22oi_2
XFILLER_108_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer399 _06608_ VGND VGND VPWR VPWR net3317 sky130_fd_sc_hd__buf_6
Xrebuffer377 _06570_ VGND VGND VPWR VPWR net3295 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_75_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09079_ _02159_ _02158_ _02160_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__nand3_2
Xrebuffer388 _06138_ VGND VGND VPWR VPWR net3306 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_75_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11110_ _04174_ _04176_ _04187_ _04189_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__nand4_2
XFILLER_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2905 net2909 VGND VGND VPWR VPWR net2905 sky130_fd_sc_hd__buf_2
Xfanout2916 net2917 VGND VGND VPWR VPWR net2916 sky130_fd_sc_hd__clkbuf_1
X_12090_ net1860 net2675 _05174_ net791 VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__a22oi_1
X_11041_ net562 net560 _04116_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_110_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12992_ net2015 _05886_ VGND VGND VPWR VPWR _06028_ sky130_fd_sc_hd__nor2_1
XFILLER_57_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11943_ net963 net911 _05003_ _05006_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__o22ai_1
X_11874_ _04867_ _04850_ _04848_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__nand3_1
X_13613_ _06522_ _06615_ _06630_ net171 _06563_ VGND VGND VPWR VPWR _06638_ sky130_fd_sc_hd__o311a_4
XFILLER_60_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10825_ net646 _03909_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__nand2_1
XFILLER_33_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14593_ clknet_leaf_6_clk net3431 _00415_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_15_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13544_ net514 net3183 _06460_ VGND VGND VPWR VPWR _06573_ sky130_fd_sc_hd__o21ai_2
X_10756_ net2642 net2666 net1033 VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__and3_1
X_13475_ net2577 net515 _06496_ net177 VGND VGND VPWR VPWR _06504_ sky130_fd_sc_hd__o211a_1
XFILLER_9_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10687_ net1694 net1726 net2474 net2501 VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__and4_1
XFILLER_40_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12426_ _05507_ _05502_ _05503_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_117_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12357_ _07045_ _07046_ _07032_ VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_130_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12288_ _05357_ _05360_ _05359_ VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__a21boi_1
XFILLER_113_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11308_ _04391_ _04388_ _04390_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__and3_1
X_14027_ net2841 VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__inv_2
X_11239_ _04319_ _04321_ net1170 net1153 VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_96_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08450_ _01534_ _01518_ _01533_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__nand3_1
XFILLER_51_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07401_ _00433_ _00464_ _00485_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__a21o_1
X_08381_ net1465 net2463 net2498 net1436 VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_34_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07332_ net2051 net2025 net1596 net1630 VGND VGND VPWR VPWR _07103_ sky130_fd_sc_hd__and4_1
XFILLER_50_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07263_ net2080 net1452 net2110 net1486 VGND VGND VPWR VPWR _07034_ sky130_fd_sc_hd__and4_1
X_07194_ net1424 net2109 VGND VGND VPWR VPWR _06965_ sky130_fd_sc_hd__and2_1
X_09002_ _02086_ _01933_ _02085_ _02084_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__o31a_4
XFILLER_129_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout513 net514 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__clkbuf_2
Xfanout502 net504 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_2
Xfanout524 _06074_ VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlymetal6s2s_1
X_09904_ _02982_ _02988_ _02987_ VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__o21ai_1
XFILLER_101_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout546 net547 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__buf_1
Xfanout535 net540 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_70_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout557 _04575_ VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__buf_1
X_09835_ net1603 net1637 net2435 net2466 VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__nand4_1
Xfanout579 _03357_ VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__buf_4
Xfanout568 _03800_ VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__buf_6
XFILLER_86_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09766_ _02851_ _02850_ _02846_ VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__nand3_4
X_08717_ _01790_ _01800_ _01801_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__nand3_1
X_09697_ _02776_ _02780_ _02781_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__nand3_2
X_08648_ _01733_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__inv_2
Xrebuffer51 _04210_ VGND VGND VPWR VPWR net2969 sky130_fd_sc_hd__buf_6
Xrebuffer73 _04795_ VGND VGND VPWR VPWR net2991 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer40 _04166_ VGND VGND VPWR VPWR net2958 sky130_fd_sc_hd__buf_6
Xrebuffer62 _05293_ VGND VGND VPWR VPWR net2980 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_27_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer84 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net3002 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_15_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08579_ _01661_ _01642_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__nand2_1
XFILLER_42_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10610_ net2266 net1946 net1976 net2251 VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__a22o_1
X_11590_ net1123 _04351_ net2451 _04354_ net1936 VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__o2111ai_4
XFILLER_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10541_ net1499 net2665 VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__and2_1
Xrebuffer141 _02318_ VGND VGND VPWR VPWR net3059 sky130_fd_sc_hd__dlymetal6s2s_1
X_13260_ net494 net1454 VGND VGND VPWR VPWR _06289_ sky130_fd_sc_hd__nand2_1
XFILLER_6_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer130 net206 VGND VGND VPWR VPWR net3048 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_108_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer174 _02586_ VGND VGND VPWR VPWR net3092 sky130_fd_sc_hd__clkbuf_1
X_12211_ _05145_ _05215_ _05072_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__a21oi_2
Xrebuffer152 _03413_ VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_1
X_10472_ _03552_ _03549_ _03553_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__nand3_4
Xrebuffer163 _04387_ VGND VGND VPWR VPWR net3081 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer185 _02317_ VGND VGND VPWR VPWR net3103 sky130_fd_sc_hd__dlygate4sd1_1
X_13191_ net1692 net2359 net484 VGND VGND VPWR VPWR _06221_ sky130_fd_sc_hd__mux2_1
Xrebuffer196 _03500_ VGND VGND VPWR VPWR net3114 sky130_fd_sc_hd__buf_6
XFILLER_135_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2702 net2706 VGND VGND VPWR VPWR net2702 sky130_fd_sc_hd__buf_1
X_12142_ net1888 net2656 _05227_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__and3_1
XFILLER_123_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2735 net2736 VGND VGND VPWR VPWR net2735 sky130_fd_sc_hd__buf_4
Xfanout2724 net3325 VGND VGND VPWR VPWR net2724 sky130_fd_sc_hd__buf_1
Xfanout2713 adder_inst.sum_raw_r\[21\] VGND VGND VPWR VPWR net2713 sky130_fd_sc_hd__buf_1
X_12073_ _05109_ net3129 _05118_ _05119_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__o2bb2ai_4
Xfanout2768 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR net2768 sky130_fd_sc_hd__buf_1
Xfanout2757 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR net2757 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2779 adder_inst.sum_raw_r\[4\] VGND VGND VPWR VPWR net2779 sky130_fd_sc_hd__buf_1
Xfanout2746 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR net2746 sky130_fd_sc_hd__buf_4
XFILLER_77_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11024_ _04105_ net2649 net1582 net869 VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__and4_1
XFILLER_103_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12975_ net2693 net2705 net757 net2710 VGND VGND VPWR VPWR _06016_ sky130_fd_sc_hd__a22o_1
XFILLER_18_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11926_ net1155 net1106 _05008_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__o21ai_1
XFILLER_60_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11857_ _04914_ _04916_ _04919_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__o21ai_1
X_14576_ clknet_leaf_0_clk net3489 _00398_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
X_11788_ _04721_ _04871_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__nand2_1
X_10808_ net1703 net2536 VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__nand2_2
XFILLER_32_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13527_ _06239_ _06555_ VGND VGND VPWR VPWR _06556_ sky130_fd_sc_hd__nand2_2
XFILLER_9_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10739_ _03647_ net572 _03643_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__nand3b_1
XFILLER_13_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13458_ net779 net545 net1863 VGND VGND VPWR VPWR _06487_ sky130_fd_sc_hd__a21o_1
XFILLER_127_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12409_ _07057_ _05494_ VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__nand2_1
X_13389_ net370 net227 net193 _06416_ net521 VGND VGND VPWR VPWR _06418_ sky130_fd_sc_hd__o311a_1
XFILLER_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07950_ _01011_ _01031_ _01033_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__nand3_1
XFILLER_99_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_110_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07881_ _00826_ _00827_ _00828_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__and3_1
XFILLER_68_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09620_ _02234_ _02239_ _02230_ _02231_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__o211ai_2
XFILLER_110_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09551_ net1699 net2341 VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__nand2_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08502_ net1500 net2384 VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__nand2_1
X_09482_ net2170 net1873 net1903 net2141 VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__a22oi_2
X_08433_ _01434_ net822 net913 net1020 VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__o2bb2a_1
X_08364_ _01431_ _01447_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__nand2_1
XFILLER_11_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07315_ _07084_ _07085_ VGND VGND VPWR VPWR _07086_ sky130_fd_sc_hd__nor2_1
X_08295_ _01217_ net696 _01225_ _01226_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_31_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07246_ _06996_ _06997_ _07014_ _07015_ _07005_ VGND VGND VPWR VPWR _07017_ sky130_fd_sc_hd__a221oi_2
XFILLER_117_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07177_ _06945_ _06947_ VGND VGND VPWR VPWR _06948_ sky130_fd_sc_hd__nand2_1
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2009 adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR net2009 sky130_fd_sc_hd__clkbuf_2
XFILLER_132_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout321 net322 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1308 adder_inst.exp_larger_r\[1\] VGND VGND VPWR VPWR net1308 sky130_fd_sc_hd__clkbuf_2
Xfanout1319 net1323 VGND VGND VPWR VPWR net1319 sky130_fd_sc_hd__clkbuf_1
XFILLER_78_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout332 _01392_ VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__buf_6
Xfanout310 _06119_ VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout354 _02367_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_1
Xfanout365 _06107_ VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_6
XFILLER_86_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout376 _06089_ VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout398 _02621_ VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkbuf_2
X_09818_ _02898_ net586 _02889_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__a21o_1
XFILLER_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout387 _03556_ VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__buf_8
XFILLER_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09749_ _02833_ _02829_ _02834_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__nand3_4
XFILLER_27_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12760_ net2757 net2752 _05820_ _05821_ VGND VGND VPWR VPWR _05822_ sky130_fd_sc_hd__or4_4
XFILLER_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12691_ adder_inst.i_a\[17\] adder_inst.i_a\[16\] adder_inst.i_a\[19\] adder_inst.i_a\[18\]
+ VGND VGND VPWR VPWR _05765_ sky130_fd_sc_hd__or4_1
X_11711_ _04795_ _04785_ _04219_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__nand3_2
X_14430_ clknet_leaf_14_clk net3360 _00252_ VGND VGND VPWR VPWR adder_inst.man_b_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_11642_ _04385_ net559 _04410_ _04412_ VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__nand4_1
X_14361_ clknet_leaf_1_clk adder_inst.sum_raw\[10\] _00183_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13312_ net489 _06339_ _06340_ VGND VGND VPWR VPWR _06341_ sky130_fd_sc_hd__o21ai_1
Xinput18 i_a[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
X_11573_ _04656_ _04657_ _04642_ VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_114_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14292_ clknet_leaf_12_clk net29 _00114_ VGND VGND VPWR VPWR adder_inst.i_a\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_10_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10524_ _03570_ _03582_ _03593_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__o21ai_1
Xinput29 i_a[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_114_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13243_ net2085 net522 net215 _06268_ VGND VGND VPWR VPWR _06272_ sky130_fd_sc_hd__a22o_1
X_10455_ _03537_ _03539_ _03535_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__a21oi_1
XFILLER_123_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13174_ net266 _06201_ _06199_ net287 VGND VGND VPWR VPWR _06204_ sky130_fd_sc_hd__o211ai_4
XFILLER_97_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12125_ net245 net116 VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__nand2_1
X_10386_ _03470_ _03471_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__nand2_1
Xfanout2510 net2511 VGND VGND VPWR VPWR net2510 sky130_fd_sc_hd__clkbuf_2
Xfanout2521 net2522 VGND VGND VPWR VPWR net2521 sky130_fd_sc_hd__buf_4
Xfanout2543 net2544 VGND VGND VPWR VPWR net2543 sky130_fd_sc_hd__clkbuf_1
XFILLER_2_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2532 net2533 VGND VGND VPWR VPWR net2532 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2554 net2555 VGND VGND VPWR VPWR net2554 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1831 net1833 VGND VGND VPWR VPWR net1831 sky130_fd_sc_hd__clkbuf_2
Xfanout2587 net2588 VGND VGND VPWR VPWR net2587 sky130_fd_sc_hd__buf_1
Xfanout1842 net1844 VGND VGND VPWR VPWR net1842 sky130_fd_sc_hd__clkbuf_2
Xfanout2576 net2579 VGND VGND VPWR VPWR net2576 sky130_fd_sc_hd__clkbuf_2
X_12056_ _04734_ _05052_ _05066_ net248 VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__o211ai_2
Xfanout2565 net2567 VGND VGND VPWR VPWR net2565 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1820 net1822 VGND VGND VPWR VPWR net1820 sky130_fd_sc_hd__clkbuf_2
Xfanout1853 net1854 VGND VGND VPWR VPWR net1853 sky130_fd_sc_hd__clkbuf_2
Xfanout1875 net1880 VGND VGND VPWR VPWR net1875 sky130_fd_sc_hd__clkbuf_2
X_11007_ _04087_ _04090_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__nor2_1
Xfanout2598 net2605 VGND VGND VPWR VPWR net2598 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1897 net1902 VGND VGND VPWR VPWR net1897 sky130_fd_sc_hd__buf_1
Xfanout1886 net1892 VGND VGND VPWR VPWR net1886 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_125_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12958_ _05999_ _06000_ net243 VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__o21a_1
XFILLER_92_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12889_ net2775 _06918_ net1078 _05939_ VGND VGND VPWR VPWR _05940_ sky130_fd_sc_hd__o211a_1
X_11909_ _04994_ _04991_ _04993_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_44_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14559_ clknet_leaf_8_clk _00090_ _00381_ VGND VGND VPWR VPWR mul_res\[26\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08080_ net2095 net2116 net1803 net1834 VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__and4_1
XFILLER_142_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08982_ _02003_ _02005_ _02064_ _02065_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__a22o_1
X_07933_ net1441 net2333 VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__nand2_1
X_07864_ net2096 net1715 VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__nand2_1
XFILLER_113_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09603_ _02681_ _02682_ _02687_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__a21oi_1
X_07795_ _00772_ _00776_ _00775_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__a21oi_1
X_09534_ _02585_ _02610_ _02615_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__o21ai_1
X_09465_ net2105 net2129 net1950 net1976 VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__nand4_1
XFILLER_36_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08416_ net1411 net2498 _01497_ _01499_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__a22o_1
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09396_ _01001_ _01004_ _02404_ _02411_ _02480_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_22_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08347_ _01362_ _01368_ _01364_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__a21o_1
XFILLER_11_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08278_ net1652 net2318 net2344 net1617 VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__a22oi_2
X_07229_ _06998_ _06999_ VGND VGND VPWR VPWR _07000_ sky130_fd_sc_hd__nor2_1
XFILLER_106_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10240_ _03087_ _03088_ _03068_ net456 VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__o211ai_1
XFILLER_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10171_ net2204 net1944 VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__nand2_4
Xfanout140 net142 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_8
XFILLER_120_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1105 net1106 VGND VGND VPWR VPWR net1105 sky130_fd_sc_hd__buf_2
Xfanout1116 _06904_ VGND VGND VPWR VPWR net1116 sky130_fd_sc_hd__clkbuf_2
Xfanout1138 net1139 VGND VGND VPWR VPWR net1138 sky130_fd_sc_hd__buf_1
Xfanout1127 net1131 VGND VGND VPWR VPWR net1127 sky130_fd_sc_hd__buf_1
X_13930_ net128 _05635_ VGND VGND VPWR VPWR _06872_ sky130_fd_sc_hd__nor2_1
Xfanout162 _06576_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_6
XFILLER_47_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout173 _03882_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_6
Xfanout1149 _06899_ VGND VGND VPWR VPWR net1149 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout195 _06287_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_6
XFILLER_47_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13861_ _06785_ _06822_ _06823_ VGND VGND VPWR VPWR _06824_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13792_ net3394 net724 VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__and2_1
X_12812_ net2725 net1299 _05805_ _05792_ _05785_ VGND VGND VPWR VPWR _05874_ sky130_fd_sc_hd__o32ai_1
XFILLER_74_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12743_ net1309 net1312 net1306 VGND VGND VPWR VPWR _05805_ sky130_fd_sc_hd__o21a_1
X_12674_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] adder_inst.exp_a\[2\]
+ VGND VGND VPWR VPWR _05751_ sky130_fd_sc_hd__or4_1
X_14413_ clknet_leaf_17_clk net3341 _00235_ VGND VGND VPWR VPWR adder_inst.man_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11625_ net1794 net1825 net2575 net2598 VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__nand4_2
X_14344_ clknet_leaf_11_clk net51 _00166_ VGND VGND VPWR VPWR adder_inst.exp_b\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_11556_ _04562_ _04633_ _04631_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__a21oi_4
X_14275_ net2899 VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__inv_2
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10507_ _03587_ _03586_ _03588_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__nand3_2
X_13226_ net1375 net513 net211 _06253_ _06252_ VGND VGND VPWR VPWR _06255_ sky130_fd_sc_hd__a221oi_2
X_11487_ _04109_ _04111_ _04113_ net640 VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__a22oi_1
X_10438_ _03503_ _03517_ _03520_ _03286_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__a22oi_1
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13157_ net261 _06182_ VGND VGND VPWR VPWR _06187_ sky130_fd_sc_hd__nand2_1
X_10369_ _02950_ _03205_ _03204_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__a21bo_1
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2362 net2363 VGND VGND VPWR VPWR net2362 sky130_fd_sc_hd__clkbuf_1
X_13088_ _06097_ _06099_ net365 _06116_ VGND VGND VPWR VPWR _06118_ sky130_fd_sc_hd__o211a_1
Xfanout2340 net2341 VGND VGND VPWR VPWR net2340 sky130_fd_sc_hd__clkbuf_2
X_12108_ _05180_ _05181_ _05182_ _05191_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__a31o_1
Xfanout2351 net2352 VGND VGND VPWR VPWR net2351 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_127_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2384 net2385 VGND VGND VPWR VPWR net2384 sky130_fd_sc_hd__clkbuf_2
Xfanout2373 net2374 VGND VGND VPWR VPWR net2373 sky130_fd_sc_hd__buf_2
Xfanout1650 adder_inst.man_b_r\[12\] VGND VGND VPWR VPWR net1650 sky130_fd_sc_hd__buf_6
X_12039_ _05121_ _05123_ _05124_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__nand3_2
Xfanout2395 net2396 VGND VGND VPWR VPWR net2395 sky130_fd_sc_hd__clkbuf_2
Xfanout1661 net1662 VGND VGND VPWR VPWR net1661 sky130_fd_sc_hd__buf_1
Xfanout1683 net1686 VGND VGND VPWR VPWR net1683 sky130_fd_sc_hd__buf_1
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1694 net1696 VGND VGND VPWR VPWR net1694 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_38_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1672 net1673 VGND VGND VPWR VPWR net1672 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_140_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07580_ _00523_ _00525_ net2102 net1595 VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__o211a_1
XFILLER_92_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09250_ _02021_ _02056_ _02057_ net591 VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__a31o_1
X_08201_ net2039 net2064 net1948 net1974 VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__nand4_2
X_09181_ _02181_ _02188_ _02197_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_138_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08132_ _01210_ _01214_ _01207_ _01208_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__o211ai_1
XFILLER_119_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08063_ _01137_ _01147_ _01148_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__nand3_1
XFILLER_135_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08965_ _02037_ net679 _02046_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__a21o_1
X_07916_ _00984_ _00981_ net969 _00987_ _00989_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__o2111ai_1
XFILLER_69_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08896_ _01977_ net819 net1242 net1204 VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_96_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07847_ _00929_ _00931_ _00932_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_67_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07778_ _00863_ _00860_ net1042 net985 VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_71_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09517_ _02601_ net901 _02599_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_80_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09448_ _02532_ _02530_ _02531_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__a21oi_4
X_09379_ _02462_ _02463_ _02461_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__o21bai_2
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12390_ _05473_ _05474_ _05462_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__o21ai_1
X_11410_ _04492_ _04485_ _04475_ _04490_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__o211ai_4
XFILLER_126_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11341_ _04424_ _04425_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__nand2_2
XFILLER_138_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14060_ net2865 VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__inv_2
X_11272_ _04356_ _04352_ _04353_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__a21oi_2
X_13011_ net1324 adder_inst.is_inf_r _06043_ net1320 VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__o31a_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10223_ net967 net944 net2342 net1760 _03080_ VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__o2111ai_4
XFILLER_133_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10154_ net3071 _03222_ _03223_ _03234_ _03236_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__a32o_1
XFILLER_58_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10085_ net1575 net2526 VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__nand2_1
X_13913_ net104 _06858_ _06859_ VGND VGND VPWR VPWR _06860_ sky130_fd_sc_hd__a21oi_4
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13844_ _05274_ _05277_ _05284_ _05279_ VGND VGND VPWR VPWR _06807_ sky130_fd_sc_hd__o31a_1
XFILLER_35_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13775_ _06779_ net765 VGND VGND VPWR VPWR adder_inst.sum_raw\[24\] sky130_fd_sc_hd__nor2_2
XFILLER_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10987_ _04069_ _04072_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__nand2_2
X_12726_ net1315 net1291 net1289 net1287 VGND VGND VPWR VPWR _05788_ sky130_fd_sc_hd__and4b_1
X_12657_ net776 _05735_ VGND VGND VPWR VPWR _05736_ sky130_fd_sc_hd__nand2_1
XFILLER_128_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11608_ _04670_ _04676_ _04677_ net607 _04693_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__a32oi_4
XFILLER_31_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12588_ _05666_ _05638_ _05671_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[3\]
+ sky130_fd_sc_hd__o21a_1
X_14327_ clknet_leaf_17_clk net64 _00149_ VGND VGND VPWR VPWR adder_inst.i_b\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold418 add_vld VGND VGND VPWR VPWR net3336 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11539_ _04618_ _04620_ _04621_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__and3_1
X_14258_ net2885 VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__inv_2
Xhold429 adder_inst.i_a\[4\] VGND VGND VPWR VPWR net3347 sky130_fd_sc_hd__dlygate4sd3_1
X_14189_ net2883 VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13209_ _06235_ net528 _06076_ _06238_ VGND VGND VPWR VPWR _06239_ sky130_fd_sc_hd__o211ai_2
XFILLER_97_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout909 _01594_ VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_2
XFILLER_3_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2170 net2171 VGND VGND VPWR VPWR net2170 sky130_fd_sc_hd__clkbuf_2
Xfanout2192 net3002 VGND VGND VPWR VPWR net2192 sky130_fd_sc_hd__dlymetal6s2s_1
X_08750_ net2213 net1622 net2237 net1659 VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__and4_1
XFILLER_57_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2181 net2182 VGND VGND VPWR VPWR net2181 sky130_fd_sc_hd__buf_1
XFILLER_39_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_107_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07701_ _00667_ _00758_ _00778_ _00781_ _00782_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__o311ai_4
X_08681_ _01763_ _01765_ _01756_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__o21ai_1
Xfanout1480 net1481 VGND VGND VPWR VPWR net1480 sky130_fd_sc_hd__clkbuf_1
Xfanout1491 net1492 VGND VGND VPWR VPWR net1491 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_107_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07632_ net1533 net2214 VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__nand2_1
XFILLER_53_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09302_ _02385_ _02386_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__nand2_2
X_07563_ _00644_ net2220 net1482 VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__nand3_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07494_ _00497_ _00499_ VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__nand2_1
XFILLER_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09233_ _02313_ _02315_ _02316_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_32_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09164_ net1430 net2554 VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__nand2_1
X_08115_ net2211 net1718 VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09095_ _02174_ _02175_ _02176_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__and3_1
X_08046_ net2201 net1776 VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__nand2_2
XFILLER_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09997_ net967 net943 _03080_ _03082_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__a2bb2o_2
X_08948_ net1250 net1212 _02029_ net905 VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__o211ai_2
X_08879_ _01963_ _01964_ _01955_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__a21o_1
XFILLER_17_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10910_ _03753_ _03754_ net569 net3116 VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__o211ai_4
XFILLER_29_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11890_ _04975_ _04965_ _04961_ _04966_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__o2bb2ai_1
X_10841_ net2415 net1820 VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__nand2_1
X_13560_ _06587_ _06588_ VGND VGND VPWR VPWR _06589_ sky130_fd_sc_hd__nand2_1
X_10772_ net385 _03828_ _03854_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__a21o_1
X_12511_ _00818_ _05596_ VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__nor2_1
X_13491_ net3296 _06516_ _06519_ VGND VGND VPWR VPWR _06520_ sky130_fd_sc_hd__o21ai_4
XFILLER_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12442_ net2013 net1285 VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__and2_1
XFILLER_60_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12373_ _00463_ _00509_ _00510_ VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_10_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14112_ net2817 VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__inv_2
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11324_ net633 net632 _04399_ _04404_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__o2bb2ai_4
X_14043_ net2863 VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__inv_2
X_11255_ _04323_ _04324_ _04329_ _04335_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__o22ai_2
X_10206_ net2924 _03048_ _03056_ _03058_ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__nand4_4
X_11186_ _04254_ _04270_ VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__nand2_2
X_10137_ _02984_ _02985_ net327 _02917_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10068_ _02968_ _02969_ net583 net584 VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__o211ai_2
XFILLER_75_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13827_ _04783_ _06789_ _04661_ _04663_ VGND VGND VPWR VPWR _06790_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_102_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13758_ _06277_ _06604_ _06262_ net187 _06606_ VGND VGND VPWR VPWR _06765_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_18_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12709_ net3481 net3485 _05774_ VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__or3_1
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13689_ net760 _06700_ _06704_ _06702_ VGND VGND VPWR VPWR _06705_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_31_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_135_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09920_ net209 _02761_ _02772_ _02773_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout706 _06055_ VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__buf_8
XFILLER_131_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout739 net740 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__buf_1
Xfanout728 net729 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__buf_1
Xfanout717 _00639_ VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlymetal6s2s_1
X_09851_ net1543 net2524 net2553 net1516 VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__a22o_1
XFILLER_140_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08802_ _01886_ _01679_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__nand2_1
XFILLER_85_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09782_ _02586_ net462 _02605_ _02608_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__o2bb2ai_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08733_ _01675_ _01666_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__nor2_4
XFILLER_94_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08664_ net821 _01748_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__or2_1
XFILLER_54_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07615_ _00698_ _00700_ _00697_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__a21oi_1
X_08595_ _01679_ _01680_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__nor2_1
XFILLER_53_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07546_ _00628_ _00629_ _00626_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__nand3_2
XFILLER_139_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07477_ _00559_ _00561_ net1337 net2307 VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__o211ai_1
X_09216_ _01729_ _01731_ _01743_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer323 _05610_ VGND VGND VPWR VPWR net3241 sky130_fd_sc_hd__clkbuf_1
Xrebuffer312 _04471_ VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer301 _03996_ VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_6
Xrebuffer356 net374 VGND VGND VPWR VPWR net1841 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer345 _06079_ VGND VGND VPWR VPWR net3263 sky130_fd_sc_hd__buf_6
Xrebuffer334 _03328_ VGND VGND VPWR VPWR net1311 sky130_fd_sc_hd__dlymetal6s2s_1
X_09147_ net1545 net2459 VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__nand2_1
XFILLER_107_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer378 net507 VGND VGND VPWR VPWR net3296 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer389 net299 VGND VGND VPWR VPWR net3307 sky130_fd_sc_hd__dlymetal6s2s_1
X_09078_ _02159_ _02160_ _02158_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__a21o_1
X_08029_ net2043 net2067 net1876 net1907 VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_75_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2906 net2907 VGND VGND VPWR VPWR net2906 sky130_fd_sc_hd__clkbuf_2
Xfanout2917 net2918 VGND VGND VPWR VPWR net2917 sky130_fd_sc_hd__buf_1
XFILLER_1_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11040_ _04117_ net562 net560 VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__and3_1
XFILLER_89_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12991_ net1325 net1995 _06027_ net1321 VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__o31a_1
XFILLER_84_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11942_ _04936_ _05026_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__or2_1
XFILLER_17_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11873_ _04848_ _04850_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__nand2_1
XFILLER_33_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14592_ clknet_leaf_6_clk net3425 _00414_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_13612_ _06614_ _06637_ VGND VGND VPWR VPWR adder_inst.sum_raw\[3\] sky130_fd_sc_hd__xor2_2
XFILLER_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10824_ net646 _03909_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__and2_1
XFILLER_111_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13543_ _06458_ net2522 net532 VGND VGND VPWR VPWR _06572_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_15_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10755_ net1549 net2666 VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__nand2_1
X_13474_ _06497_ net178 VGND VGND VPWR VPWR _06503_ sky130_fd_sc_hd__or2_4
XFILLER_9_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10686_ net1735 net2510 VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__nand2_1
XFILLER_139_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12425_ _05490_ _05489_ _05510_ VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__o21bai_4
XTAP_TAPCELL_ROW_117_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12356_ _07078_ _07099_ VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__nor2_1
X_11307_ net1196 net1121 _04272_ _04273_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__o211ai_2
XFILLER_141_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12287_ _05367_ _05368_ _05369_ VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__nand3_1
XFILLER_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11238_ _04319_ _04321_ _04317_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__a21oi_1
X_14026_ net2809 VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__inv_2
XFILLER_67_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11169_ net1784 net2508 VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__nand2_1
XFILLER_121_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07400_ _00433_ _00464_ _00485_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__a21oi_1
X_08380_ net1465 net2459 VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_34_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07331_ net2026 net1597 VGND VGND VPWR VPWR _07102_ sky130_fd_sc_hd__nand2_1
X_07262_ net2107 net1486 VGND VGND VPWR VPWR _07033_ sky130_fd_sc_hd__nand2_1
XFILLER_117_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07193_ _06961_ _06962_ VGND VGND VPWR VPWR _06964_ sky130_fd_sc_hd__nand2_1
X_09001_ _02082_ _02083_ _01926_ _01931_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__a211o_4
XFILLER_129_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout514 net516 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout503 net504 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__buf_1
X_09903_ _02976_ net433 _02983_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__and3_4
XFILLER_100_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout536 net537 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__clkbuf_2
Xfanout525 net533 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__buf_2
Xfanout547 net548 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__buf_6
X_09834_ net1602 net1637 net2435 net2466 VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__and4_1
XFILLER_112_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout558 _04529_ VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__buf_6
Xfanout569 _03729_ VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__buf_8
XFILLER_86_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09765_ net901 _02599_ _02600_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__nand3b_4
X_08716_ _01798_ _01799_ _01789_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__nand3_1
X_09696_ _02779_ _02775_ _02778_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__nand3_2
Xrebuffer30 _05295_ VGND VGND VPWR VPWR net2948 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_27_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer41 _02140_ VGND VGND VPWR VPWR net2959 sky130_fd_sc_hd__dlymetal6s2s_1
X_08647_ _01506_ _01512_ _01504_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__a21oi_1
Xrebuffer52 _04211_ VGND VGND VPWR VPWR net2970 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer63 adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR net2981 sky130_fd_sc_hd__buf_2
XFILLER_27_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer85 _02002_ VGND VGND VPWR VPWR net3003 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer74 _02554_ VGND VGND VPWR VPWR net2992 sky130_fd_sc_hd__buf_1
Xrebuffer96 net3016 VGND VGND VPWR VPWR net3014 sky130_fd_sc_hd__buf_6
XFILLER_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08578_ _01641_ _01636_ _01640_ net687 _01660_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__o2111ai_4
X_07529_ net1563 net2187 VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__nand2_1
X_10540_ net1522 net1549 net2618 net2641 VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__nand4_1
Xrebuffer131 _01205_ VGND VGND VPWR VPWR net3049 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer120 _03038_ VGND VGND VPWR VPWR net3038 sky130_fd_sc_hd__clkbuf_1
X_10471_ _03549_ _03553_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__nand2_1
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer164 _01909_ VGND VGND VPWR VPWR net3082 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer153 _03220_ VGND VGND VPWR VPWR net3071 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer142 net3062 VGND VGND VPWR VPWR net3060 sky130_fd_sc_hd__buf_1
X_12210_ _05250_ _05251_ _05255_ _05295_ VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__o22ai_4
Xrebuffer175 _02106_ VGND VGND VPWR VPWR net3093 sky130_fd_sc_hd__buf_6
X_13190_ net338 net298 _06219_ _06212_ VGND VGND VPWR VPWR _06220_ sky130_fd_sc_hd__o211ai_2
Xrebuffer197 _04652_ VGND VGND VPWR VPWR net3115 sky130_fd_sc_hd__buf_1
Xrebuffer186 _04168_ VGND VGND VPWR VPWR net3104 sky130_fd_sc_hd__buf_6
XFILLER_123_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2703 net2706 VGND VGND VPWR VPWR net2703 sky130_fd_sc_hd__clkbuf_1
X_12141_ net1916 net2675 VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__and2_1
Xfanout2736 adder_inst.sum_raw_r\[19\] VGND VGND VPWR VPWR net2736 sky130_fd_sc_hd__buf_6
Xfanout2714 net2715 VGND VGND VPWR VPWR net2714 sky130_fd_sc_hd__buf_1
Xfanout2725 net3321 VGND VGND VPWR VPWR net2725 sky130_fd_sc_hd__buf_1
XFILLER_2_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12072_ _05116_ _05117_ _05103_ _05108_ net3165 VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__o221ai_4
Xfanout2758 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR net2758 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2769 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR net2769 sky130_fd_sc_hd__buf_1
Xfanout2747 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR net2747 sky130_fd_sc_hd__dlymetal6s2s_1
X_11023_ net1582 net2649 net869 net796 VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__a22o_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12974_ net2720 net1058 _06012_ _06014_ net843 VGND VGND VPWR VPWR _06015_ sky130_fd_sc_hd__o221a_1
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11925_ net1157 net1105 _05008_ VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__o21a_1
X_11856_ net1766 net792 net2673 _04937_ VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__a31o_1
X_14575_ clknet_leaf_0_clk net3447 _00397_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
X_10807_ _03692_ _03690_ _03889_ _03891_ VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__nand4_4
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11787_ _04700_ net450 _04721_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__nand3_1
XFILLER_41_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13526_ net502 _06546_ _06551_ _06549_ VGND VGND VPWR VPWR _06555_ sky130_fd_sc_hd__o211ai_4
X_10738_ _03643_ net571 _03647_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__a21bo_1
XFILLER_41_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13457_ net376 net255 _06269_ _06485_ VGND VGND VPWR VPWR _06486_ sky130_fd_sc_hd__o31ai_4
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12408_ _07055_ _07056_ _07021_ VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__o21ai_1
X_10669_ _03741_ net649 net876 _03750_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_142_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13388_ net193 net221 _06416_ VGND VGND VPWR VPWR _06417_ sky130_fd_sc_hd__o21a_4
X_12339_ _05423_ _05424_ _05414_ VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14009_ net2806 VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__inv_2
XFILLER_122_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07880_ _00826_ _00827_ _00828_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_52_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09550_ net1207 net1200 _01347_ _02170_ _02169_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__o221ai_1
X_08501_ net1003 net984 _01235_ _01237_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__o22a_1
X_09481_ net2170 net1873 VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__nand2_1
X_08432_ net2372 net2400 net1034 _01434_ net822 VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__a32o_1
XFILLER_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08363_ _01447_ _01430_ VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__nand2_1
X_07314_ _07083_ net2221 net1342 _07082_ VGND VGND VPWR VPWR _07085_ sky130_fd_sc_hd__and4b_1
X_08294_ _01227_ _01228_ _01217_ net696 VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__o211ai_2
X_07245_ _06998_ _07005_ _07014_ _07015_ VGND VGND VPWR VPWR _07016_ sky130_fd_sc_hd__o211a_2
XFILLER_137_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07176_ _06945_ _06946_ net1343 net2136 VGND VGND VPWR VPWR _06947_ sky130_fd_sc_hd__nand4_2
XFILLER_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout322 _05525_ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__buf_2
Xfanout1309 net3322 VGND VGND VPWR VPWR net1309 sky130_fd_sc_hd__clkbuf_2
XFILLER_87_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout311 _06119_ VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_1
Xfanout300 _06121_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_6
XFILLER_98_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout355 _02003_ VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_2
Xfanout333 net2961 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_1
Xfanout366 _06107_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkbuf_1
Xfanout344 _04542_ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_6
XFILLER_74_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout377 _06089_ VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_1
Xfanout399 _02619_ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_2
X_09817_ net587 net585 _02889_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__a21oi_1
XFILLER_86_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09748_ _02563_ net674 _02574_ _02576_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__nand4_2
X_09679_ _02260_ _02678_ _02744_ _02764_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__nand4_2
X_11710_ _04786_ _04793_ _04787_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__nand3_1
XFILLER_27_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12690_ adder_inst.i_a\[9\] adder_inst.i_a\[8\] adder_inst.i_a\[11\] adder_inst.i_a\[10\]
+ VGND VGND VPWR VPWR _05764_ sky130_fd_sc_hd__or4_1
XFILLER_42_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11641_ _04385_ _04410_ _04412_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__nand3_1
X_14360_ clknet_leaf_1_clk adder_inst.sum_raw\[9\] _00182_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_11572_ _04655_ _04654_ VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_25_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13311_ net769 net536 net1569 VGND VGND VPWR VPWR _06340_ sky130_fd_sc_hd__a21o_1
X_10523_ _03570_ _03582_ _03593_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__o21a_1
Xinput19 i_a[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
X_14291_ clknet_leaf_12_clk net28 _00113_ VGND VGND VPWR VPWR adder_inst.i_a\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_124_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13242_ net1271 net493 _06243_ net3227 VGND VGND VPWR VPWR _06271_ sky130_fd_sc_hd__o22a_1
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10454_ _03537_ _03539_ _03535_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__nand3_1
X_13173_ _06200_ net264 _06202_ VGND VGND VPWR VPWR _06203_ sky130_fd_sc_hd__o21ai_4
X_10385_ _03466_ _03463_ _03465_ _03458_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__a31o_1
XFILLER_123_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12124_ _05131_ _05132_ _05133_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__nand3_4
Xfanout2500 net2503 VGND VGND VPWR VPWR net2500 sky130_fd_sc_hd__clkbuf_1
Xfanout2511 net2521 VGND VGND VPWR VPWR net2511 sky130_fd_sc_hd__buf_1
Xfanout2522 net2523 VGND VGND VPWR VPWR net2522 sky130_fd_sc_hd__buf_6
Xfanout2544 net2545 VGND VGND VPWR VPWR net2544 sky130_fd_sc_hd__buf_8
Xfanout2533 net2534 VGND VGND VPWR VPWR net2533 sky130_fd_sc_hd__buf_1
Xfanout1810 net1811 VGND VGND VPWR VPWR net1810 sky130_fd_sc_hd__buf_6
Xfanout1832 net1833 VGND VGND VPWR VPWR net1832 sky130_fd_sc_hd__clkbuf_2
Xfanout2577 net2578 VGND VGND VPWR VPWR net2577 sky130_fd_sc_hd__buf_4
Xfanout1843 net1847 VGND VGND VPWR VPWR net1843 sky130_fd_sc_hd__buf_1
Xfanout2555 net2556 VGND VGND VPWR VPWR net2555 sky130_fd_sc_hd__clkbuf_2
X_12055_ _05138_ net551 VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__nand2_1
Xfanout2566 net2567 VGND VGND VPWR VPWR net2566 sky130_fd_sc_hd__clkbuf_2
Xfanout1821 net1822 VGND VGND VPWR VPWR net1821 sky130_fd_sc_hd__clkbuf_2
Xfanout1876 net1878 VGND VGND VPWR VPWR net1876 sky130_fd_sc_hd__clkbuf_2
Xfanout2588 net2589 VGND VGND VPWR VPWR net2588 sky130_fd_sc_hd__buf_1
Xfanout1865 net1866 VGND VGND VPWR VPWR net1865 sky130_fd_sc_hd__buf_1
Xfanout1854 adder_inst.man_b_r\[5\] VGND VGND VPWR VPWR net1854 sky130_fd_sc_hd__clkbuf_2
X_11006_ _03894_ _04086_ _04091_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__o21ai_1
XFILLER_38_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2599 net2600 VGND VGND VPWR VPWR net2599 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_5_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1887 net1889 VGND VGND VPWR VPWR net1887 sky130_fd_sc_hd__clkbuf_2
Xfanout1898 net1900 VGND VGND VPWR VPWR net1898 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_125_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12957_ net2692 net2721 net757 net2734 VGND VGND VPWR VPWR _06000_ sky130_fd_sc_hd__a22o_1
XFILLER_80_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12888_ net2776 net743 net2780 net749 VGND VGND VPWR VPWR _05939_ sky130_fd_sc_hd__o22a_1
X_11908_ net1939 net2572 VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__nand2_2
XFILLER_33_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11839_ _04833_ _04918_ net1858 net2599 net793 VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__o2111ai_2
XFILLER_119_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14558_ clknet_leaf_8_clk _00089_ _00380_ VGND VGND VPWR VPWR mul_res\[25\] sky130_fd_sc_hd__dfrtp_1
XFILLER_119_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13509_ _06924_ _05528_ _06142_ _06133_ VGND VGND VPWR VPWR _06538_ sky130_fd_sc_hd__o31a_1
X_14489_ clknet_leaf_11_clk net3379 _00311_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_142_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08981_ _02001_ _02004_ net401 net355 VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__o211ai_1
X_07932_ _01016_ _01017_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__nor2_1
XFILLER_102_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07863_ _00942_ _00943_ _00945_ net613 VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__o22ai_4
XFILLER_96_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09602_ net999 net921 _02687_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__o21a_4
X_07794_ _00879_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__inv_2
X_09533_ _02616_ _02617_ _02611_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__nand3_2
XFILLER_64_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09464_ _02547_ _02548_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__nand2_1
X_09395_ _01001_ _01004_ _02404_ _02411_ _02480_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_65_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08415_ _01497_ _01499_ _01495_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__a21o_1
X_08346_ _01223_ _01363_ _01362_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_22_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08277_ net1617 net2344 VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__nand2_1
X_07228_ _06996_ _06997_ VGND VGND VPWR VPWR _06999_ sky130_fd_sc_hd__nor2_1
XFILLER_105_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07159_ _06929_ VGND VGND VPWR VPWR _06930_ sky130_fd_sc_hd__inv_2
XFILLER_3_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10170_ net2177 net1969 VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__nand2_1
Xfanout130 net131 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_4
XFILLER_120_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1128 net1130 VGND VGND VPWR VPWR net1128 sky130_fd_sc_hd__buf_2
Xfanout1106 net1107 VGND VGND VPWR VPWR net1106 sky130_fd_sc_hd__clkbuf_2
Xfanout1117 net1118 VGND VGND VPWR VPWR net1117 sky130_fd_sc_hd__buf_4
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_1
Xfanout152 _06621_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_6
XFILLER_87_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1139 _06901_ VGND VGND VPWR VPWR net1139 sky130_fd_sc_hd__clkbuf_1
Xfanout174 _03882_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_1
Xfanout185 _00702_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_2
Xfanout196 _05148_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_2
X_13860_ _05534_ _05545_ net124 VGND VGND VPWR VPWR _06823_ sky130_fd_sc_hd__mux2_1
XFILLER_47_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13791_ net3450 net729 VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__and2_1
X_12811_ net1313 net848 net1296 VGND VGND VPWR VPWR _05873_ sky130_fd_sc_hd__o21ai_1
X_12742_ net2730 net1072 VGND VGND VPWR VPWR _05804_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12673_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] VGND VGND
+ VPWR VPWR _05750_ sky130_fd_sc_hd__or3_1
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11624_ net1794 net2596 VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__nand2_2
X_14412_ clknet_leaf_16_clk net3426 _00234_ VGND VGND VPWR VPWR adder_inst.man_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14343_ clknet_leaf_12_clk net50 _00165_ VGND VGND VPWR VPWR adder_inst.exp_b\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_11555_ _04627_ _04628_ _04610_ _04563_ VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__a31oi_1
XFILLER_11_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14274_ net2871 VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__inv_2
XFILLER_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10506_ _03590_ _03585_ _03589_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__nand3_2
X_11486_ _04510_ _04517_ _04516_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__o21ai_1
XFILLER_109_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13225_ net1375 net513 net211 net214 VGND VGND VPWR VPWR _06254_ sky130_fd_sc_hd__a22oi_2
X_10437_ _03270_ net658 _03280_ _03281_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13156_ net1540 net479 _06184_ VGND VGND VPWR VPWR _06186_ sky130_fd_sc_hd__o21a_1
X_10368_ _03411_ _03423_ _03432_ net430 VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__o31a_1
XFILLER_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13087_ _06098_ _06100_ _06114_ _06115_ VGND VGND VPWR VPWR _06117_ sky130_fd_sc_hd__a22oi_4
Xfanout2330 net2339 VGND VGND VPWR VPWR net2330 sky130_fd_sc_hd__buf_4
Xfanout2341 net2343 VGND VGND VPWR VPWR net2341 sky130_fd_sc_hd__clkbuf_1
X_10299_ _03169_ _03380_ _03384_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__o21ai_1
X_12107_ _05180_ _05181_ _05182_ _05191_ VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__a31oi_4
Xfanout2352 net2358 VGND VGND VPWR VPWR net2352 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_127_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2385 net2386 VGND VGND VPWR VPWR net2385 sky130_fd_sc_hd__buf_2
Xfanout2363 net2368 VGND VGND VPWR VPWR net2363 sky130_fd_sc_hd__clkbuf_1
Xfanout2374 net2375 VGND VGND VPWR VPWR net2374 sky130_fd_sc_hd__clkbuf_1
Xfanout1651 net1653 VGND VGND VPWR VPWR net1651 sky130_fd_sc_hd__clkbuf_2
X_12038_ _05024_ net447 _05040_ _05041_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout1640 net1641 VGND VGND VPWR VPWR net1640 sky130_fd_sc_hd__buf_1
Xfanout2396 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net2396 sky130_fd_sc_hd__buf_6
Xfanout1684 net1686 VGND VGND VPWR VPWR net1684 sky130_fd_sc_hd__buf_1
Xfanout1662 net1663 VGND VGND VPWR VPWR net1662 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_69_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1673 net1674 VGND VGND VPWR VPWR net1673 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_140_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1695 net1696 VGND VGND VPWR VPWR net1695 sky130_fd_sc_hd__clkbuf_1
XFILLER_34_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13989_ net2828 VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08200_ net1961 net1992 VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__nand2_8
XPHY_EDGE_ROW_78_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09180_ _02264_ _02265_ _02244_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_138_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08131_ _01205_ _01206_ _01216_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__nand3_4
X_08062_ _01142_ _01144_ net2172 net1775 VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08964_ _02037_ net679 _02046_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__a21oi_1
XFILLER_124_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07915_ _00988_ _01000_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_87_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08895_ _01977_ net819 _01974_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__a21oi_1
X_07846_ _00795_ _00796_ _00802_ _00803_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__nand4_1
X_07777_ net1417 net2336 VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_67_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09516_ net1227 net1222 net946 net1181 net1218 VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__o32a_4
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09447_ _02448_ _02528_ _02532_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_80_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09378_ net1045 _01022_ net1414 net2365 _01021_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__o2111ai_1
XFILLER_8_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08329_ net1020 net922 _01404_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__o21ai_2
XFILLER_126_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11340_ net1737 net2592 net2622 net1707 VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__a22oi_1
XFILLER_20_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13010_ _05814_ _05815_ _05812_ _05828_ _06923_ VGND VGND VPWR VPWR _06043_ sky130_fd_sc_hd__o311a_1
XFILLER_106_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11271_ _04352_ _04356_ _04353_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__a21o_1
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10222_ net1200 net1181 _03305_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__o21ai_1
XFILLER_121_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10153_ _03234_ _03236_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__nand2_1
XFILLER_121_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10084_ net1601 net1635 net2462 net2494 VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__nand4_2
X_13912_ net128 _05618_ _05617_ VGND VGND VPWR VPWR _06859_ sky130_fd_sc_hd__o21a_1
XFILLER_74_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13843_ net3168 _05281_ _06805_ VGND VGND VPWR VPWR _06806_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_122_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_732 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13774_ net1340 _06247_ _06250_ _06778_ VGND VGND VPWR VPWR _06779_ sky130_fd_sc_hd__o2bb2a_4
X_10986_ _04070_ _04056_ VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__nand2_2
X_12725_ net1308 net1303 net1298 VGND VGND VPWR VPWR _05787_ sky130_fd_sc_hd__and3_1
X_12656_ net1085 net1997 VGND VGND VPWR VPWR _05735_ sky130_fd_sc_hd__nand2_1
X_12587_ net103 net110 _05670_ net108 VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__nand4_1
X_11607_ _04688_ _04690_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__nand2_2
XFILLER_128_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14326_ clknet_leaf_18_clk net63 _00148_ VGND VGND VPWR VPWR adder_inst.i_b\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11538_ _04619_ _04622_ _04623_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__nand3_2
X_14257_ net2890 VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__inv_2
Xhold419 adder_inst.i_b\[8\] VGND VGND VPWR VPWR net3337 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11469_ net1612 net2648 _04418_ _04451_ _04465_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__a32oi_1
XTAP_TAPCELL_ROW_133_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14188_ net2881 VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__inv_2
X_13208_ net502 _06235_ _06237_ VGND VGND VPWR VPWR _06238_ sky130_fd_sc_hd__o21ai_2
X_13139_ net1840 net499 _06168_ VGND VGND VPWR VPWR _06169_ sky130_fd_sc_hd__o21a_1
XFILLER_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2160 net2167 VGND VGND VPWR VPWR net2160 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2171 net2176 VGND VGND VPWR VPWR net2171 sky130_fd_sc_hd__clkbuf_2
XFILLER_112_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07700_ net716 _00758_ _00778_ _00781_ _00782_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__o311a_1
Xfanout2193 net2194 VGND VGND VPWR VPWR net2193 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_85_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2182 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net2182 sky130_fd_sc_hd__clkbuf_2
X_08680_ net1266 net1168 _01761_ net908 VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__o211ai_4
Xfanout1481 net1485 VGND VGND VPWR VPWR net1481 sky130_fd_sc_hd__buf_1
Xfanout1492 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net1492 sky130_fd_sc_hd__buf_4
Xfanout1470 net1471 VGND VGND VPWR VPWR net1470 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_107_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07631_ _00715_ _00709_ _00623_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__nand3_1
XFILLER_66_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07562_ _00645_ net2243 net1448 VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__nand3_1
XFILLER_80_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09301_ _01957_ _01962_ _01960_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__a21oi_1
X_07493_ _00508_ _00517_ _00577_ net412 VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__a22o_1
XFILLER_61_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09232_ _02315_ _02313_ _02316_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_62_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09163_ net1461 net2527 VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__nand2_1
XFILLER_119_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08114_ _01197_ _01198_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__nand2_1
XFILLER_135_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09094_ _02177_ _02178_ _02173_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__nand3_2
X_08045_ net2144 net2172 net1800 net1832 VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__nand4_2
XFILLER_131_810 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09996_ net1200 net1179 VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__nor2_1
X_08947_ _02029_ net905 _02025_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__a21o_1
X_08878_ net1266 net1173 _01961_ _01962_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__o211ai_1
X_07829_ net597 _00878_ net440 net410 VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__a22o_4
XFILLER_29_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10840_ _03747_ _03913_ _03924_ _03912_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__o211ai_2
XFILLER_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10771_ net385 _03828_ _03854_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__nand3_1
XFILLER_13_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12510_ _05588_ _01072_ _01075_ VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__a21boi_4
X_13490_ net507 net1923 VGND VGND VPWR VPWR _06519_ sky130_fd_sc_hd__nand2_1
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12441_ net147 net321 VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__nand2_8
XFILLER_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12372_ _05455_ _05456_ _00513_ VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_10_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14111_ net2818 VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__inv_2
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11323_ net633 net632 _04399_ _04404_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_125_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14042_ net2864 VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__inv_2
X_11254_ _04323_ _04324_ _04337_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__o21ai_2
XFILLER_140_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10205_ net3113 _03048_ _03053_ _03054_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_79_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11185_ net1829 net2512 net2536 net1798 VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__a22oi_2
XFILLER_121_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10136_ net327 _02917_ _02986_ _02989_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__o2bb2ai_2
X_10067_ _02970_ _02971_ net583 net584 VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__a22o_1
XFILLER_62_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13826_ net167 net453 _05312_ _04781_ VGND VGND VPWR VPWR _06789_ sky130_fd_sc_hd__a31o_1
XFILLER_16_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13757_ _06277_ _06764_ VGND VGND VPWR VPWR adder_inst.sum_raw\[21\] sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_18_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10969_ _04050_ _04051_ _04053_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_102_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12708_ adder_inst.is_zero_a_r adder_inst.is_inf_b_r adder_inst.is_inf_a_r adder_inst.is_zero_b_r
+ VGND VGND VPWR VPWR _05774_ sky130_fd_sc_hd__a22o_1
X_13688_ _06703_ net160 net154 net761 VGND VGND VPWR VPWR _06704_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_135_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12639_ net1278 net2006 net862 _05693_ VGND VGND VPWR VPWR _05719_ sky130_fd_sc_hd__a31o_1
XFILLER_8_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14309_ clknet_leaf_12_clk net16 _00131_ VGND VGND VPWR VPWR adder_inst.exp_a\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_116_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout729 _06781_ VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__clkbuf_2
Xfanout718 _00639_ VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__clkbuf_1
Xfanout707 net708 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__clkbuf_2
X_09850_ net1543 net2526 net2552 net1516 VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__a22oi_2
XFILLER_140_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08801_ _01880_ _01884_ _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__o21a_1
X_09781_ net3106 net462 _02609_ VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__a21o_1
X_08732_ _01815_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__nand2_1
X_08663_ _01746_ _01747_ net402 _01625_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__and4b_1
XFILLER_26_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07614_ _00598_ _00687_ _00696_ VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__nand3_1
XFILLER_121_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08594_ net2044 net1851 net1879 net2020 VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_37_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07545_ _00530_ _00532_ _00543_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__nand3_1
XFILLER_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07476_ net1339 net2307 _00559_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__a211o_1
XFILLER_139_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09215_ net210 _01731_ net2988 VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__nand3_1
XFILLER_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer302 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer313 _03659_ VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer324 _05489_ VGND VGND VPWR VPWR net3242 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer346 net3263 VGND VGND VPWR VPWR net3264 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer357 _06120_ VGND VGND VPWR VPWR net1864 sky130_fd_sc_hd__buf_2
Xrebuffer335 _03042_ VGND VGND VPWR VPWR net1317 sky130_fd_sc_hd__buf_6
X_09146_ net1518 net2492 VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__nand2_1
Xrebuffer368 _06235_ VGND VGND VPWR VPWR net2115 sky130_fd_sc_hd__clkbuf_2
X_09077_ _02132_ _02157_ _02162_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__nand3_2
Xrebuffer379 net732 VGND VGND VPWR VPWR net3297 sky130_fd_sc_hd__dlygate4sd1_1
XPHY_EDGE_ROW_15_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08028_ net1893 net1923 VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__nand2_1
Xfanout2907 net2908 VGND VGND VPWR VPWR net2907 sky130_fd_sc_hd__clkbuf_2
XFILLER_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2918 net67 VGND VGND VPWR VPWR net2918 sky130_fd_sc_hd__clkbuf_2
X_09979_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__inv_2
X_12990_ net2015 _05864_ VGND VGND VPWR VPWR _06027_ sky130_fd_sc_hd__nor2_1
XFILLER_85_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11941_ net1794 net1826 net2655 net2677 VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__and4_1
X_11872_ _04928_ _04931_ _04956_ VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14591_ clknet_leaf_7_clk net3402 _00413_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_13611_ _06636_ _06634_ _06633_ net854 VGND VGND VPWR VPWR _06637_ sky130_fd_sc_hd__a2bb2o_4
X_10823_ _03905_ _03906_ _03904_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__o21ai_1
X_13542_ _06561_ _06565_ _06569_ VGND VGND VPWR VPWR _06571_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_15_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10754_ _03833_ _03836_ _03837_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__nand3_1
X_13473_ _06501_ _06498_ VGND VGND VPWR VPWR _06502_ sky130_fd_sc_hd__nor2_4
X_10685_ net1726 net2474 net2510 net1694 VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__a22oi_1
X_12424_ _05507_ _05508_ _05504_ VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_117_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12355_ _05439_ _05440_ VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_117_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_607 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11306_ _04272_ _04273_ _04274_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_130_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12286_ _05366_ _05370_ _05371_ VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__nand3_2
XFILLER_5_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11237_ net1169 net1153 _04319_ _04321_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__o211a_1
X_14025_ net2809 VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__inv_2
XFILLER_121_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11168_ net1828 net2512 VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__nand2_1
X_10119_ _03199_ _03200_ _03201_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__nand3b_4
XPHY_EDGE_ROW_42_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11099_ _04183_ _04179_ _04182_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__nand3_1
X_13809_ multiplier_inst.is_nan_r _06782_ net1318 VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_34_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07330_ net3147 _07100_ VGND VGND VPWR VPWR _07101_ sky130_fd_sc_hd__nor2_1
XFILLER_50_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07261_ _07030_ _07031_ VGND VGND VPWR VPWR _07032_ sky130_fd_sc_hd__nor2_1
X_09000_ _02080_ net192 _01753_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_51_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07192_ net2055 net2079 net1452 net1486 VGND VGND VPWR VPWR _06963_ sky130_fd_sc_hd__nand4_2
XFILLER_117_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout515 net516 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__clkbuf_2
Xfanout504 net510 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_2
X_09902_ _02738_ _02977_ _02980_ net457 VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__a31o_1
XFILLER_98_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout537 net538 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__clkbuf_1
Xfanout526 net527 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_1
Xfanout548 _06073_ VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__clkbuf_2
X_09833_ net1637 net2435 net2466 net1602 VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_70_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout559 _04387_ VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__buf_4
XFILLER_132_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09764_ net901 _02598_ _02601_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__o21ai_4
X_08715_ net1242 net1201 net1024 net968 _01794_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__o221ai_2
XFILLER_67_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer20 _02144_ VGND VGND VPWR VPWR net2938 sky130_fd_sc_hd__dlygate4sd1_1
X_09695_ _02287_ _02289_ _02297_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__nand3_1
XFILLER_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer64 _01858_ VGND VGND VPWR VPWR net2982 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_82_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer42 net2959 VGND VGND VPWR VPWR net2960 sky130_fd_sc_hd__dlymetal6s2s_1
X_08646_ _01509_ _01507_ _01508_ VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__a21boi_4
Xrebuffer31 adder_inst.man_a_r\[11\] VGND VGND VPWR VPWR net2949 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer53 _03558_ VGND VGND VPWR VPWR net2971 sky130_fd_sc_hd__clkbuf_2
Xrebuffer86 _02002_ VGND VGND VPWR VPWR net3004 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer75 _03226_ VGND VGND VPWR VPWR net2993 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer97 _03692_ VGND VGND VPWR VPWR net3015 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_85_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08577_ _01642_ net687 _01660_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__nand3_4
XFILLER_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07528_ _00540_ _00609_ _00608_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__o21bai_2
X_07459_ _00530_ _00543_ _00531_ VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__a21oi_1
Xrebuffer110 _01924_ VGND VGND VPWR VPWR net3028 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer132 net367 VGND VGND VPWR VPWR net3050 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer121 _03352_ VGND VGND VPWR VPWR net3039 sky130_fd_sc_hd__clkbuf_2
X_10470_ _03554_ _03550_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__nand3_4
XFILLER_136_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer165 _01909_ VGND VGND VPWR VPWR net3083 sky130_fd_sc_hd__buf_1
Xrebuffer143 _05547_ VGND VGND VPWR VPWR net3061 sky130_fd_sc_hd__dlygate4sd1_1
X_09129_ net691 net690 _01422_ _01425_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__o2bb2ai_2
Xrebuffer154 _03522_ VGND VGND VPWR VPWR net3072 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer187 _02305_ VGND VGND VPWR VPWR net3105 sky130_fd_sc_hd__buf_1
Xrebuffer176 _02090_ VGND VGND VPWR VPWR net3094 sky130_fd_sc_hd__dlymetal6s4s_1
X_12140_ _05223_ _05224_ _05222_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__o21a_1
Xrebuffer198 _03732_ VGND VGND VPWR VPWR net3116 sky130_fd_sc_hd__buf_6
Xfanout2704 net2706 VGND VGND VPWR VPWR net2704 sky130_fd_sc_hd__buf_1
Xfanout2726 net2730 VGND VGND VPWR VPWR net2726 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2715 adder_inst.sum_raw_r\[20\] VGND VGND VPWR VPWR net2715 sky130_fd_sc_hd__clkbuf_2
Xhold580 _00071_ VGND VGND VPWR VPWR net3498 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12071_ _05118_ _05119_ _05109_ net3165 VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__o211ai_2
Xfanout2759 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR net2759 sky130_fd_sc_hd__clkbuf_1
Xfanout2748 net2750 VGND VGND VPWR VPWR net2748 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_110_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11022_ net1582 net2649 net869 net796 VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__a22oi_2
XFILLER_49_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12973_ _06010_ _06013_ net1070 net2705 VGND VGND VPWR VPWR _06014_ sky130_fd_sc_hd__o2bb2a_1
X_11924_ _05008_ net2627 net1860 VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__and3_1
XFILLER_73_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11855_ net792 net2673 net1765 VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__and3_1
X_14574_ clknet_leaf_0_clk net3474 _00396_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
X_10806_ _03888_ _03886_ _03884_ _03890_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__a22oi_4
X_11786_ _04700_ net450 _04719_ _04720_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__o2bb2ai_1
X_13525_ _06550_ _06552_ _06548_ VGND VGND VPWR VPWR _06554_ sky130_fd_sc_hd__o21ai_2
X_10737_ _03643_ net572 _03647_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__a21o_1
X_13456_ _06483_ _06482_ net254 _06484_ VGND VGND VPWR VPWR _06485_ sky130_fd_sc_hd__o211ai_4
XFILLER_127_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12407_ _07060_ _05492_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__nand2_1
X_10668_ _03741_ net649 _03751_ VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__a21oi_1
XFILLER_126_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13387_ net372 _06415_ net252 _06414_ VGND VGND VPWR VPWR _06416_ sky130_fd_sc_hd__nand4_4
X_10599_ net190 net347 _03469_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__nand3_2
XFILLER_142_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12338_ _05418_ _05419_ _05422_ VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__nand3b_1
XFILLER_114_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12269_ _01043_ _05351_ _05352_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__and3_1
XFILLER_114_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14008_ net2804 VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_52_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08500_ _01235_ _01237_ _01236_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__o21ai_1
X_09480_ net2142 net1904 VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__nand2_1
XFILLER_102_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08431_ _01445_ _01442_ _01431_ _01446_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_63_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08362_ _01442_ _01445_ _01446_ _01415_ _01408_ VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__o2111ai_2
X_07313_ net1342 net2221 _07081_ _07083_ VGND VGND VPWR VPWR _07084_ sky130_fd_sc_hd__o2bb2a_1
X_08293_ _01225_ _01226_ _01217_ net696 VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__o211ai_4
X_07244_ _07011_ _07012_ _07001_ _07003_ VGND VGND VPWR VPWR _07015_ sky130_fd_sc_hd__o211ai_2
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07175_ net1397 net2083 net2111 net1372 VGND VGND VPWR VPWR _06946_ sky130_fd_sc_hd__a22o_1
XFILLER_132_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout312 _06118_ VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__buf_4
Xfanout301 net303 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_4
Xfanout323 _04134_ VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_6
XFILLER_132_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout356 _01829_ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__buf_6
Xfanout334 net337 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__buf_1
Xfanout345 _03667_ VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout378 _06082_ VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__buf_6
X_09816_ _02890_ net585 net587 VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__and3_1
Xfanout389 _03437_ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__buf_6
XFILLER_100_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_87_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09747_ _02563_ net674 _02573_ _02575_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09678_ _02247_ net816 _02259_ VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__nand3_1
XFILLER_15_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08629_ _01672_ net3121 _01712_ net469 VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__nand4_4
X_11640_ _04385_ net559 _04407_ _04408_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__o2bb2ai_1
X_11571_ _04612_ net3100 _04650_ _04652_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_25_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13310_ net224 _06337_ _06338_ _06155_ VGND VGND VPWR VPWR _06339_ sky130_fd_sc_hd__o22a_2
XFILLER_10_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10522_ _03412_ _03413_ _03420_ _03421_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_109_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14290_ clknet_leaf_12_clk net27 _00112_ VGND VGND VPWR VPWR adder_inst.i_a\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13241_ net495 net1401 _06268_ net214 VGND VGND VPWR VPWR _06270_ sky130_fd_sc_hd__a22o_1
X_10453_ net944 _01366_ net2388 net1760 net803 VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__o2111ai_1
XPHY_EDGE_ROW_107_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13172_ net264 _06198_ VGND VGND VPWR VPWR _06202_ sky130_fd_sc_hd__nand2_4
X_10384_ _03467_ _03464_ _03468_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__nand3_4
XFILLER_124_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12123_ _05205_ _05204_ _05202_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__nand3_4
Xfanout2501 net2502 VGND VGND VPWR VPWR net2501 sky130_fd_sc_hd__clkbuf_2
XFILLER_117_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1800 net1801 VGND VGND VPWR VPWR net1800 sky130_fd_sc_hd__clkbuf_2
Xfanout2523 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR net2523 sky130_fd_sc_hd__buf_6
Xfanout2545 net2546 VGND VGND VPWR VPWR net2545 sky130_fd_sc_hd__buf_6
X_12054_ net248 net551 _05066_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__nand3_1
Xfanout2534 net2535 VGND VGND VPWR VPWR net2534 sky130_fd_sc_hd__buf_4
Xfanout2512 net2514 VGND VGND VPWR VPWR net2512 sky130_fd_sc_hd__clkbuf_2
XFILLER_89_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1833 net1839 VGND VGND VPWR VPWR net1833 sky130_fd_sc_hd__buf_6
Xfanout1811 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net1811 sky130_fd_sc_hd__buf_6
Xfanout2578 net2579 VGND VGND VPWR VPWR net2578 sky130_fd_sc_hd__clkbuf_2
Xfanout2556 net2560 VGND VGND VPWR VPWR net2556 sky130_fd_sc_hd__clkbuf_2
Xfanout2567 net2576 VGND VGND VPWR VPWR net2567 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1822 net1823 VGND VGND VPWR VPWR net1822 sky130_fd_sc_hd__clkbuf_1
Xfanout2589 net2590 VGND VGND VPWR VPWR net2589 sky130_fd_sc_hd__clkbuf_2
Xfanout1844 net1847 VGND VGND VPWR VPWR net1844 sky130_fd_sc_hd__clkbuf_1
X_11005_ _04083_ _04084_ _04089_ VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__a21o_1
Xfanout1855 net1857 VGND VGND VPWR VPWR net1855 sky130_fd_sc_hd__buf_1
Xfanout1866 net1872 VGND VGND VPWR VPWR net1866 sky130_fd_sc_hd__clkbuf_2
Xfanout1877 net1878 VGND VGND VPWR VPWR net1877 sky130_fd_sc_hd__clkbuf_1
Xfanout1899 net1900 VGND VGND VPWR VPWR net1899 sky130_fd_sc_hd__clkbuf_2
Xfanout890 _03260_ VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_5_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1888 net1889 VGND VGND VPWR VPWR net1888 sky130_fd_sc_hd__clkbuf_1
XFILLER_92_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_125_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12956_ net2752 net1063 net747 _05998_ _05997_ VGND VGND VPWR VPWR _05999_ sky130_fd_sc_hd__o311a_1
XFILLER_45_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12887_ _05937_ _05938_ net239 VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__o21a_1
X_11907_ net2516 net2542 net1964 net1987 VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_44_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11838_ _06898_ net1143 _04918_ net793 _04913_ VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__o311a_1
X_14557_ clknet_leaf_6_clk _00088_ _00379_ VGND VGND VPWR VPWR mul_res\[24\] sky130_fd_sc_hd__dfrtp_1
XFILLER_60_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13508_ _06924_ _05528_ _06147_ VGND VGND VPWR VPWR _06537_ sky130_fd_sc_hd__o21ai_1
X_11769_ net1796 net1827 net2597 net2628 VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__nand4_1
X_14488_ clknet_leaf_11_clk net3367 _00310_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_2
X_13439_ net334 _06466_ net307 _06467_ VGND VGND VPWR VPWR _06468_ sky130_fd_sc_hd__nand4_1
XFILLER_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08980_ _02064_ net401 VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__nand2_1
X_07931_ net1332 net2413 _01013_ _01015_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__a22oi_2
X_07862_ net614 _00944_ _00946_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__nand3b_1
XFILLER_83_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09601_ net1576 net2465 VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__nand2_2
X_07793_ net597 _00878_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__nand2_1
XFILLER_113_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09532_ _02616_ _02617_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09463_ net2119 net1949 net1975 net2089 VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__a22oi_2
XFILLER_51_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09394_ _00999_ _01003_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__nand2_2
XFILLER_51_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08414_ net1264 net1149 net1046 net917 _01499_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__o221ai_4
XFILLER_24_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08345_ net2400 net2432 net1033 _01403_ _01408_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__a32o_1
XFILLER_138_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08276_ net1588 net2371 VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__nand2_1
X_07227_ _06936_ _06938_ _06941_ _06981_ VGND VGND VPWR VPWR _06998_ sky130_fd_sc_hd__o22a_1
XFILLER_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07158_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] _06926_ net1054 VGND VGND
+ VPWR VPWR _06929_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_121_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout131 net132 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_6
XFILLER_87_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout120 net121 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
Xfanout1129 net1130 VGND VGND VPWR VPWR net1129 sky130_fd_sc_hd__buf_6
Xfanout1107 net1108 VGND VGND VPWR VPWR net1107 sky130_fd_sc_hd__buf_4
Xfanout1118 net1119 VGND VGND VPWR VPWR net1118 sky130_fd_sc_hd__clkbuf_2
Xfanout142 net146 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_8
XFILLER_120_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout153 _06621_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_6
XFILLER_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout186 _06350_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_6
XFILLER_74_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout175 _06529_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_6
Xfanout197 _05148_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_1
X_12810_ net1313 net1296 net848 net2698 VGND VGND VPWR VPWR _05872_ sky130_fd_sc_hd__o31a_1
XFILLER_74_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13790_ net3414 net723 VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__and2_1
XFILLER_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12741_ _05786_ net2747 net847 adder_inst.exp_larger_r\[2\] net1301 VGND VGND VPWR
+ VPWR _05803_ sky130_fd_sc_hd__a221o_1
XFILLER_103_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12672_ net3379 _05748_ _05749_ VGND VGND VPWR VPWR adder_inst.man_b\[23\] sky130_fd_sc_hd__or3_1
XFILLER_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11623_ net630 _04708_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14411_ clknet_leaf_16_clk net3405 _00233_ VGND VGND VPWR VPWR adder_inst.man_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14342_ clknet_leaf_12_clk net49 _00164_ VGND VGND VPWR VPWR adder_inst.exp_b\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_11554_ _04637_ _04608_ _04636_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__nand3_1
XFILLER_128_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14273_ net2871 VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__inv_2
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10505_ _03590_ _03585_ _03589_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__and3_1
X_11485_ net866 _04261_ _04516_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__o21ai_1
X_13224_ net531 net258 net1841 VGND VGND VPWR VPWR _06253_ sky130_fd_sc_hd__and3_1
X_10436_ _03280_ _03281_ _03270_ net658 VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__o211ai_2
XFILLER_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13155_ net1540 net479 _06184_ VGND VGND VPWR VPWR _06185_ sky130_fd_sc_hd__o21ai_2
X_10367_ _03376_ _03443_ _03449_ _03450_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__o211ai_4
Xfanout2320 net2330 VGND VGND VPWR VPWR net2320 sky130_fd_sc_hd__clkbuf_2
XFILLER_112_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2331 net2332 VGND VGND VPWR VPWR net2331 sky130_fd_sc_hd__clkbuf_2
X_13086_ _06114_ _06115_ VGND VGND VPWR VPWR _06116_ sky130_fd_sc_hd__nand2_1
Xfanout2353 net2356 VGND VGND VPWR VPWR net2353 sky130_fd_sc_hd__buf_6
X_10298_ net1575 net2552 VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__nand2_1
X_12106_ _05188_ _05190_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__nand2_1
Xfanout2342 net2343 VGND VGND VPWR VPWR net2342 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_127_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2364 net2365 VGND VGND VPWR VPWR net2364 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1630 net1631 VGND VGND VPWR VPWR net1630 sky130_fd_sc_hd__clkbuf_2
X_12037_ _05036_ _05038_ _05024_ net447 VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__o211ai_1
Xfanout1641 net1642 VGND VGND VPWR VPWR net1641 sky130_fd_sc_hd__buf_1
Xfanout2386 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net2386 sky130_fd_sc_hd__buf_6
Xfanout2375 net2380 VGND VGND VPWR VPWR net2375 sky130_fd_sc_hd__buf_4
Xfanout1663 net1667 VGND VGND VPWR VPWR net1663 sky130_fd_sc_hd__clkbuf_2
Xfanout1685 net1690 VGND VGND VPWR VPWR net1685 sky130_fd_sc_hd__clkbuf_2
Xfanout1652 net1653 VGND VGND VPWR VPWR net1652 sky130_fd_sc_hd__buf_1
Xfanout1674 net1675 VGND VGND VPWR VPWR net1674 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_109_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1696 net1702 VGND VGND VPWR VPWR net1696 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_140_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13988_ net2828 VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__inv_2
X_12939_ net2756 net1063 net747 _05983_ _05982_ VGND VGND VPWR VPWR _05984_ sky130_fd_sc_hd__o311a_1
XFILLER_80_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08130_ _01213_ _01210_ _01212_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__o21ai_4
Xclkbuf_leaf_13_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_08061_ net825 _01144_ _01138_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__a21o_1
XFILLER_134_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08963_ _02037_ net679 _02044_ _02045_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_130_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07914_ _00984_ _00981_ net969 _00987_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__o211ai_2
XFILLER_111_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08894_ net1025 net985 net1504 net2331 net819 VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__o2111ai_4
X_07845_ _00804_ _00930_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__nand2_1
XFILLER_140_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07776_ net1444 net1476 net2277 net2304 VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_67_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09515_ net2289 net1761 VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__nand2_2
XFILLER_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09446_ _02528_ _02448_ _02446_ _02444_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_80_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09377_ _01021_ _01024_ net1414 net2364 VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__and4_1
XFILLER_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08328_ net1239 net1161 _01412_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08259_ _01317_ _01340_ _01343_ _01344_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__nand4_2
XFILLER_137_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11270_ net2450 net1935 VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__nand2_1
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10221_ net1200 net1179 net967 net943 _03080_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__o221ai_2
XFILLER_133_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10152_ _03232_ _02950_ net2639 net1356 VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__and4_1
X_10083_ net1635 net2494 VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__nand2_1
X_13911_ net105 _06858_ VGND VGND VPWR VPWR multiplier_inst.man_final\[15\] sky130_fd_sc_hd__xor2_1
XFILLER_87_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13842_ net2979 _05247_ _05243_ _05239_ net3164 VGND VGND VPWR VPWR _06805_ sky130_fd_sc_hd__a2111oi_2
XTAP_TAPCELL_ROW_122_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13773_ _06252_ _06254_ _06772_ VGND VGND VPWR VPWR _06778_ sky130_fd_sc_hd__o21a_1
XFILLER_62_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12724_ net1309 net1306 VGND VGND VPWR VPWR _05786_ sky130_fd_sc_hd__and2_4
XFILLER_16_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10985_ _04054_ _04056_ _04064_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_104_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12655_ net1090 net1272 VGND VGND VPWR VPWR _05734_ sky130_fd_sc_hd__nand2_1
X_12586_ _05666_ _05669_ _05668_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__o21bai_1
X_11606_ _04686_ net2547 net1859 _04684_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__and4_1
X_14325_ clknet_leaf_17_clk net62 _00147_ VGND VGND VPWR VPWR adder_inst.i_b\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11537_ net423 _04082_ _04125_ _04126_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_116_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14256_ net2893 VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__inv_2
XFILLER_128_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11468_ _04553_ VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__inv_2
XFILLER_140_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14187_ net2882 VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13207_ net775 net541 net1985 VGND VGND VPWR VPWR _06237_ sky130_fd_sc_hd__a21o_1
X_11399_ _04482_ _04483_ _04484_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__and3_2
X_10419_ net2269 net1896 VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__nand2_1
X_13138_ net774 net541 net2519 VGND VGND VPWR VPWR _06168_ sky130_fd_sc_hd__a21o_1
Xfanout2161 net2162 VGND VGND VPWR VPWR net2161 sky130_fd_sc_hd__buf_1
XFILLER_97_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2150 net2151 VGND VGND VPWR VPWR net2150 sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_2_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
Xfanout2194 net3002 VGND VGND VPWR VPWR net2194 sky130_fd_sc_hd__clkbuf_2
Xfanout2183 net2185 VGND VGND VPWR VPWR net2183 sky130_fd_sc_hd__clkbuf_2
Xfanout2172 net2174 VGND VGND VPWR VPWR net2172 sky130_fd_sc_hd__dlymetal6s2s_1
X_13069_ _06095_ _06096_ _05716_ VGND VGND VPWR VPWR _06099_ sky130_fd_sc_hd__and3_1
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1482 net1484 VGND VGND VPWR VPWR net1482 sky130_fd_sc_hd__clkbuf_2
Xfanout1471 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net1471 sky130_fd_sc_hd__clkbuf_2
Xfanout1460 net1462 VGND VGND VPWR VPWR net1460 sky130_fd_sc_hd__buf_4
XFILLER_93_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07630_ _00623_ _00709_ _00710_ _00714_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_65_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07561_ _00644_ _00645_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__nand2_1
XFILLER_80_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09300_ _01957_ _01962_ _01960_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__a21o_1
XFILLER_80_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07492_ _00577_ net412 VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__nand2_1
XFILLER_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09231_ _01926_ _01932_ net3058 net3098 _02312_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_62_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09162_ _02246_ net2638 net1328 _02245_ VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__nand4_1
XFILLER_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08113_ net2228 net1710 net1747 net2202 VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_32_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09093_ _02177_ _02178_ _02173_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__and3_1
XFILLER_119_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08044_ net1009 net952 VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_77_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_822 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09995_ net2311 net1816 VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__nand2_1
XFILLER_130_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08946_ _02029_ net905 net2152 net1683 VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__nand4_1
X_08877_ _01961_ _01962_ _01957_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__a21o_1
XFILLER_96_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07828_ net597 _00878_ net440 net410 VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__nand4_2
XFILLER_56_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07759_ _00843_ _00839_ _00842_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__o21ai_1
XFILLER_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10770_ _03828_ net385 _03853_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__a21o_1
X_09429_ _02508_ _02510_ net354 VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__o21ai_2
XFILLER_13_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12440_ net144 net317 VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__and2_4
XFILLER_9_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12371_ _05456_ _00513_ _05455_ VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_10_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14110_ net2815 VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__inv_2
XFILLER_125_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11322_ _04399_ _04404_ net633 net632 VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__o211a_1
X_14041_ net2863 VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__inv_2
X_11253_ _04329_ _04335_ _04334_ _04327_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__o211ai_1
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10204_ _03042_ _03048_ _03059_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__nand3_4
XFILLER_133_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11184_ net1794 net2541 VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__nand2_2
XFILLER_121_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10135_ net2922 _03219_ _03141_ _03146_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_125_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10066_ _02970_ _02971_ net583 net584 VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__a22oi_4
XFILLER_85_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13825_ _04232_ _05537_ _04240_ VGND VGND VPWR VPWR _06788_ sky130_fd_sc_hd__o21ai_1
XFILLER_63_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13756_ _06762_ _06763_ net851 VGND VGND VPWR VPWR _06764_ sky130_fd_sc_hd__mux2_4
XFILLER_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10968_ _04029_ _04032_ _04048_ _04049_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__o211ai_4
X_13687_ _06584_ _06388_ _06701_ VGND VGND VPWR VPWR _06703_ sky130_fd_sc_hd__a21oi_1
X_12707_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r multiplier_inst.is_nan_r VGND
+ VGND VPWR VPWR _00069_ sky130_fd_sc_hd__o21ba_1
X_12638_ net859 _05714_ adder_inst.exp_b_r\[5\] net2003 VGND VGND VPWR VPWR _05718_
+ sky130_fd_sc_hd__o211ai_1
X_10899_ _03925_ net644 net797 VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_135_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12569_ _06929_ _05651_ _05650_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__o21a_1
X_14308_ clknet_leaf_14_clk net15 _00130_ VGND VGND VPWR VPWR adder_inst.i_a\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_14239_ net2901 VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_59_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout708 net709 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__clkbuf_1
Xfanout719 _00481_ VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__buf_6
X_08800_ _01879_ _01881_ net1259 net1188 VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_112_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09780_ _02608_ _02605_ net3092 net462 VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08731_ _01779_ _01781_ _01811_ _01813_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__a22o_1
XFILLER_78_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1290 adder_inst.exp_larger_r\[5\] VGND VGND VPWR VPWR net1290 sky130_fd_sc_hd__buf_1
X_08662_ net402 _01625_ _01747_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__nand3_1
X_07613_ _00598_ _00687_ _00696_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__and3_1
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08593_ net2044 net2020 net1851 net1879 VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__and4_2
XTAP_TAPCELL_ROW_37_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07544_ _00529_ _00531_ _00542_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__o21ai_1
X_07475_ net1364 net1391 net2254 net2282 VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__and4_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09214_ _02287_ _02298_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__nand2_1
XFILLER_10_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer314 _04762_ VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__buf_2
Xrebuffer303 _03923_ VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer347 net277 VGND VGND VPWR VPWR net3265 sky130_fd_sc_hd__buf_4
Xrebuffer336 _06055_ VGND VGND VPWR VPWR net1459 sky130_fd_sc_hd__buf_1
Xrebuffer325 _05090_ VGND VGND VPWR VPWR net3243 sky130_fd_sc_hd__buf_2
X_09145_ _02228_ _02223_ _02227_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__nand3_4
Xrebuffer358 _06427_ VGND VGND VPWR VPWR net3276 sky130_fd_sc_hd__dlygate4sd1_1
X_09076_ net472 net595 _01334_ _01335_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__nand4_1
Xrebuffer369 net289 VGND VGND VPWR VPWR net2140 sky130_fd_sc_hd__dlymetal6s2s_1
X_08027_ _01110_ _01111_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__nand2_1
Xfanout2908 net2909 VGND VGND VPWR VPWR net2908 sky130_fd_sc_hd__clkbuf_2
XFILLER_89_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09978_ _02815_ _02822_ _02823_ net667 VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__nand4_4
XFILLER_130_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08929_ _01878_ _01875_ _02012_ net712 net906 VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__o221a_1
XFILLER_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11940_ net1826 net2676 VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__nand2_1
XFILLER_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11871_ _04935_ _04955_ _04932_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__a21oi_2
XFILLER_33_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14590_ clknet_leaf_7_clk net3466 _00412_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_13610_ _06635_ net138 net765 VGND VGND VPWR VPWR _06636_ sky130_fd_sc_hd__o21ai_4
XFILLER_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10822_ _03830_ _03831_ _03832_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__a21oi_1
X_13541_ _06561_ _06565_ _06569_ VGND VGND VPWR VPWR _06570_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_15_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10753_ _03836_ _03837_ _03833_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_15_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13472_ _06500_ _06499_ _06258_ net257 VGND VGND VPWR VPWR _06501_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10684_ _03763_ _03760_ _03762_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__nand3_4
XFILLER_139_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12423_ _05507_ _05508_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__nor2_1
X_12354_ _05438_ _01074_ _01076_ VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__o21a_4
XFILLER_126_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11305_ net1764 net2568 _04272_ _04273_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__a22o_1
XFILLER_141_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12285_ _01051_ _01052_ net251 _01045_ VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__a22o_1
XFILLER_5_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14024_ net2809 VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__inv_2
XFILLER_141_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11236_ net960 net916 _04317_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__o21ai_1
XFILLER_122_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11167_ net1763 net2537 VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_112_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10118_ _03202_ _03203_ _03199_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__nand3b_4
X_11098_ _03942_ _03945_ _04180_ _04181_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__o211ai_1
XFILLER_76_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10049_ net455 net581 _03120_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__and3_1
XFILLER_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13808_ multiplier_inst.overflow_calc_r multiplier_inst.is_zero_r multiplier_inst.is_inf_r
+ multiplier_inst.man_final_r\[22\] VGND VGND VPWR VPWR _06782_ sky130_fd_sc_hd__nor4b_1
XTAP_TAPCELL_ROW_34_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13739_ _06745_ net762 _06746_ _06748_ VGND VGND VPWR VPWR _06749_ sky130_fd_sc_hd__a31o_1
XFILLER_32_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07260_ net2029 net1507 _06950_ _07029_ VGND VGND VPWR VPWR _07031_ sky130_fd_sc_hd__a31oi_1
X_07191_ net2055 net1486 VGND VGND VPWR VPWR _06962_ sky130_fd_sc_hd__nand2_1
XFILLER_129_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09901_ net434 net432 _02976_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__a21o_1
Xfanout505 net506 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__buf_12
Xfanout516 net517 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__buf_1
Xfanout538 net539 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__buf_1
Xfanout527 net528 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_6
X_09832_ net1637 net2436 net2466 net1602 VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__a22oi_4
XFILLER_98_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09763_ net901 _02599_ _02601_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__nand3b_1
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08714_ _01797_ _01791_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__nand2_1
XFILLER_67_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer21 net1039 VGND VGND VPWR VPWR net2939 sky130_fd_sc_hd__buf_6
X_09694_ _02287_ _02289_ _02295_ _02296_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__o2bb2ai_1
Xrebuffer10 _04806_ VGND VGND VPWR VPWR net2928 sky130_fd_sc_hd__dlygate4sd1_1
X_08645_ _01560_ _01724_ _01725_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__nand3_4
Xrebuffer43 _01392_ VGND VGND VPWR VPWR net2961 sky130_fd_sc_hd__clkbuf_2
Xrebuffer54 _03680_ VGND VGND VPWR VPWR net2972 sky130_fd_sc_hd__buf_6
Xrebuffer32 _03821_ VGND VGND VPWR VPWR net2950 sky130_fd_sc_hd__buf_4
Xrebuffer65 _02369_ VGND VGND VPWR VPWR net2983 sky130_fd_sc_hd__dlygate4sd1_1
X_08576_ net687 _01660_ _01642_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__a21o_4
Xrebuffer87 _02106_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_1
XFILLER_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer76 _03226_ VGND VGND VPWR VPWR net2994 sky130_fd_sc_hd__buf_6
X_07527_ _00541_ _00610_ _00608_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_85_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer98 _03692_ VGND VGND VPWR VPWR net3016 sky130_fd_sc_hd__buf_6
XFILLER_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07458_ _00532_ _00542_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__nand2_1
X_07389_ net2110 net1567 VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__nand2_1
Xrebuffer100 _03224_ VGND VGND VPWR VPWR net3018 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer122 _03526_ VGND VGND VPWR VPWR net3040 sky130_fd_sc_hd__buf_6
Xrebuffer111 _04771_ VGND VGND VPWR VPWR net3029 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_108_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer133 _02527_ VGND VGND VPWR VPWR net3051 sky130_fd_sc_hd__buf_6
X_09128_ _02212_ _02211_ _02207_ VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__nand3_4
Xrebuffer155 _04211_ VGND VGND VPWR VPWR net3073 sky130_fd_sc_hd__buf_6
Xrebuffer144 _04814_ VGND VGND VPWR VPWR net3062 sky130_fd_sc_hd__clkbuf_1
XFILLER_136_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer199 _01845_ VGND VGND VPWR VPWR net3117 sky130_fd_sc_hd__buf_1
Xrebuffer177 net151 VGND VGND VPWR VPWR net3095 sky130_fd_sc_hd__buf_6
Xrebuffer188 _02586_ VGND VGND VPWR VPWR net3106 sky130_fd_sc_hd__buf_1
Xrebuffer166 _03269_ VGND VGND VPWR VPWR net3084 sky130_fd_sc_hd__buf_4
X_09059_ net1227 net1187 _02142_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__o21ai_1
Xhold570 mul_res\[11\] VGND VGND VPWR VPWR net3488 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_123_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2705 net2706 VGND VGND VPWR VPWR net2705 sky130_fd_sc_hd__clkbuf_2
Xfanout2716 net2722 VGND VGND VPWR VPWR net2716 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold581 adder_inst.sign_sum_r VGND VGND VPWR VPWR net3499 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12070_ _05109_ net3163 _05120_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__a21o_1
Xfanout2749 net2750 VGND VGND VPWR VPWR net2749 sky130_fd_sc_hd__clkbuf_1
Xfanout2738 net2745 VGND VGND VPWR VPWR net2738 sky130_fd_sc_hd__buf_2
X_11021_ net869 net796 _04100_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__a21oi_2
XFILLER_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12972_ _06011_ net2742 net2705 VGND VGND VPWR VPWR _06013_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11923_ net1158 net1105 net962 net911 _05007_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__o221a_4
X_11854_ net1767 net2673 VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__nand2_1
XFILLER_82_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10805_ _03679_ _03683_ net173 _03885_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__o211ai_2
XFILLER_32_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14573_ clknet_leaf_1_clk net3493 _00395_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
X_11785_ _04700_ net450 VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__nand2_1
X_13524_ net1959 net502 _06552_ VGND VGND VPWR VPWR _06553_ sky130_fd_sc_hd__a21oi_1
X_10736_ net884 _03646_ net571 _03643_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__o211ai_1
X_13455_ _06371_ _06370_ net221 VGND VGND VPWR VPWR _06484_ sky130_fd_sc_hd__a21o_1
X_10667_ net876 _03750_ _03737_ _03740_ net649 VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__o221a_1
X_12406_ _07058_ _07059_ _07052_ _07055_ VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__a211o_1
XFILLER_126_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13386_ net3169 net312 net336 _06346_ _06347_ VGND VGND VPWR VPWR _06415_ sky130_fd_sc_hd__a32o_2
X_10598_ net190 net347 _03469_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__and3_1
XFILLER_5_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12337_ _05420_ _05421_ VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__nand2_1
XFILLER_31_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12268_ _05353_ _05350_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__nand2_1
XFILLER_114_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11219_ _04302_ _04291_ _04304_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__nand3_2
X_14007_ net2802 VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__inv_2
Xoutput90 net90 VGND VGND VPWR VPWR o_res[2] sky130_fd_sc_hd__buf_2
XFILLER_110_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12199_ net1965 net2631 _05262_ _05261_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__a31o_1
XFILLER_110_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08430_ _01445_ _01442_ _01431_ _01446_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__a2bb2o_2
X_08361_ _01442_ _01445_ _01446_ VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__o21ai_1
X_07312_ net1367 net1395 net2163 net2191 VGND VGND VPWR VPWR _07083_ sky130_fd_sc_hd__and4_1
X_08292_ _01217_ net696 _01227_ _01228_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_31_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07243_ _07001_ _07003_ _07011_ _07012_ VGND VGND VPWR VPWR _07014_ sky130_fd_sc_hd__a211o_1
XFILLER_20_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07174_ _06878_ net1262 net1053 VGND VGND VPWR VPWR _06945_ sky130_fd_sc_hd__or3_2
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout313 _06118_ VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__clkbuf_1
XFILLER_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__buf_1
Xfanout357 _01829_ VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__buf_6
XFILLER_87_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout335 net337 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__buf_2
X_09815_ net2945 _02893_ _02894_ _02889_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__a31oi_2
Xfanout346 _03667_ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkbuf_1
Xfanout324 net325 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__buf_8
XFILLER_100_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout379 _06081_ VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09746_ _02563_ net674 _02571_ _02572_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__o2bb2ai_2
X_09677_ _02247_ net816 _02259_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__and3_1
XFILLER_27_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08628_ _01712_ net469 VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__nand2_1
X_08559_ net996 net977 _01245_ _01248_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__o22a_1
XFILLER_23_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11570_ _04653_ net416 VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10521_ _03412_ net368 _03422_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__nand3_4
X_13240_ net1864 _06266_ net336 _06267_ VGND VGND VPWR VPWR _06269_ sky130_fd_sc_hd__nand4_4
XFILLER_6_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10452_ net943 _01366_ _03301_ net803 VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__o211a_1
X_13171_ net1427 net2105 net481 VGND VGND VPWR VPWR _06201_ sky130_fd_sc_hd__mux2_1
X_10383_ _03465_ _03463_ _03466_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__nand3_4
X_12122_ _05204_ _05205_ VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__nand2_1
Xfanout2502 net2503 VGND VGND VPWR VPWR net2502 sky130_fd_sc_hd__clkbuf_1
XFILLER_123_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2513 net2514 VGND VGND VPWR VPWR net2513 sky130_fd_sc_hd__clkbuf_1
X_12053_ _05066_ net247 _04734_ _05052_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout2535 net2551 VGND VGND VPWR VPWR net2535 sky130_fd_sc_hd__buf_6
Xfanout2524 net2525 VGND VGND VPWR VPWR net2524 sky130_fd_sc_hd__buf_4
XFILLER_117_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1834 net1836 VGND VGND VPWR VPWR net1834 sky130_fd_sc_hd__clkbuf_2
Xfanout1801 net1802 VGND VGND VPWR VPWR net1801 sky130_fd_sc_hd__buf_2
Xfanout2546 net2547 VGND VGND VPWR VPWR net2546 sky130_fd_sc_hd__buf_6
XFILLER_2_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2557 net2559 VGND VGND VPWR VPWR net2557 sky130_fd_sc_hd__clkbuf_2
X_11004_ _04083_ _04084_ _04089_ VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__a21oi_1
Xfanout2568 net2570 VGND VGND VPWR VPWR net2568 sky130_fd_sc_hd__clkbuf_2
Xfanout1823 net1824 VGND VGND VPWR VPWR net1823 sky130_fd_sc_hd__clkbuf_2
Xfanout2579 net2580 VGND VGND VPWR VPWR net2579 sky130_fd_sc_hd__clkbuf_2
Xfanout1845 net1847 VGND VGND VPWR VPWR net1845 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1856 net1857 VGND VGND VPWR VPWR net1856 sky130_fd_sc_hd__buf_1
Xfanout1867 net1869 VGND VGND VPWR VPWR net1867 sky130_fd_sc_hd__clkbuf_2
Xfanout1878 net1880 VGND VGND VPWR VPWR net1878 sky130_fd_sc_hd__clkbuf_1
XFILLER_77_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout891 _03260_ VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_5_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1889 net1891 VGND VGND VPWR VPWR net1889 sky130_fd_sc_hd__buf_1
Xfanout880 _03531_ VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__clkbuf_2
XFILLER_133_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12955_ net1058 net2742 net2748 net740 net843 VGND VGND VPWR VPWR _05998_ sky130_fd_sc_hd__o221a_1
XFILLER_92_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_142_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11906_ _04904_ _04990_ VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__nand2_2
X_12886_ net2689 net2763 net2766 net754 VGND VGND VPWR VPWR _05938_ sky130_fd_sc_hd__a22o_1
XFILLER_60_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11837_ net793 _04919_ _04913_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__a21o_1
X_14556_ clknet_leaf_7_clk _00087_ _00378_ VGND VGND VPWR VPWR mul_res\[23\] sky130_fd_sc_hd__dfrtp_1
X_11768_ net1827 net2628 VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__nand2_2
X_13507_ _06140_ net3265 net283 _06509_ VGND VGND VPWR VPWR _06536_ sky130_fd_sc_hd__o211ai_2
X_10719_ _03793_ _03799_ _03798_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__o21ai_2
X_14487_ clknet_leaf_11_clk net3370 _00309_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_11699_ _04203_ _04214_ _04215_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__nand3_2
Xrebuffer1 _05324_ VGND VGND VPWR VPWR net2919 sky130_fd_sc_hd__dlygate4sd1_1
X_13438_ _06228_ net274 net282 _06430_ VGND VGND VPWR VPWR _06467_ sky130_fd_sc_hd__o211ai_2
X_13369_ net338 net3307 _06334_ _06333_ VGND VGND VPWR VPWR _06398_ sky130_fd_sc_hd__o211ai_4
XFILLER_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07930_ _01013_ _01015_ net1332 net2413 VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_54_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07861_ _00946_ _00944_ VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__nand2_1
XFILLER_96_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07792_ net615 _00875_ _00857_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__o21ai_2
XFILLER_110_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09600_ net1604 net1639 net2398 net2431 VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_69_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09531_ _02150_ _02151_ net465 _02132_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__o211ai_2
XFILLER_83_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09462_ net2130 net1950 VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__nand2_1
X_09393_ _02467_ _02476_ _02475_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_82_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08413_ _01463_ _01496_ VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__nand2_2
XFILLER_12_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08344_ net1173 net1167 net1020 _01404_ _01407_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__o32a_1
XFILLER_20_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08275_ _01360_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__inv_2
XFILLER_137_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07226_ net2056 net2032 net1425 net1455 _06941_ VGND VGND VPWR VPWR _06997_ sky130_fd_sc_hd__a41o_1
XFILLER_4_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07157_ net2012 net1284 VGND VGND VPWR VPWR _06928_ sky130_fd_sc_hd__nand2b_4
XFILLER_105_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout110 net112 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_8
Xfanout121 _05527_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
Xfanout1108 _06906_ VGND VGND VPWR VPWR net1108 sky130_fd_sc_hd__buf_2
Xfanout1119 net1122 VGND VGND VPWR VPWR net1119 sky130_fd_sc_hd__buf_4
Xfanout143 net145 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_2
Xfanout132 _05526_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_6
XFILLER_101_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_6
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout187 _06263_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_1
XFILLER_87_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout176 _06529_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_2
Xfanout198 _04607_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__buf_4
XFILLER_101_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09729_ _02801_ _02805_ _02809_ _02810_ VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_2_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12740_ net1316 _05786_ net1297 VGND VGND VPWR VPWR _05802_ sky130_fd_sc_hd__a21oi_1
XFILLER_42_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12671_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] adder_inst.exp_b\[3\] adder_inst.exp_b\[2\]
+ VGND VGND VPWR VPWR _05749_ sky130_fd_sc_hd__or4_1
X_14410_ clknet_leaf_16_clk net3398 _00232_ VGND VGND VPWR VPWR adder_inst.man_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_11622_ _04704_ _04705_ _04706_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_41_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14341_ clknet_leaf_12_clk net48 _00163_ VGND VGND VPWR VPWR adder_inst.exp_b\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11553_ _04634_ _04635_ VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__nand2_1
X_14272_ net2911 VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__inv_2
XFILLER_10_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10504_ net655 net654 _03349_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__a21o_1
X_11484_ net1192 net866 net1145 _04258_ _04516_ VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__o311a_1
X_13223_ net2059 net529 net215 net211 VGND VGND VPWR VPWR _06252_ sky130_fd_sc_hd__a22oi_2
X_10435_ _03270_ net658 _03282_ _03284_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__o2bb2ai_1
X_13154_ net768 net535 net2208 VGND VGND VPWR VPWR _06184_ sky130_fd_sc_hd__a21o_1
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10366_ _03218_ _03445_ _03376_ _03443_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__o2bb2ai_4
X_12105_ _05188_ _05190_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__and2_1
XFILLER_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2332 net2337 VGND VGND VPWR VPWR net2332 sky130_fd_sc_hd__buf_1
X_13085_ _06113_ _06108_ VGND VGND VPWR VPWR _06115_ sky130_fd_sc_hd__nand2_2
Xfanout2321 net2323 VGND VGND VPWR VPWR net2321 sky130_fd_sc_hd__dlymetal6s2s_1
X_10297_ _03169_ _03380_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__nand2_2
Xfanout2343 net2349 VGND VGND VPWR VPWR net2343 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_127_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2365 net2366 VGND VGND VPWR VPWR net2365 sky130_fd_sc_hd__clkbuf_2
Xfanout1631 net1632 VGND VGND VPWR VPWR net1631 sky130_fd_sc_hd__clkbuf_2
Xfanout1620 net1621 VGND VGND VPWR VPWR net1620 sky130_fd_sc_hd__clkbuf_1
Xfanout2354 net2356 VGND VGND VPWR VPWR net2354 sky130_fd_sc_hd__clkbuf_2
Xfanout1642 net1650 VGND VGND VPWR VPWR net1642 sky130_fd_sc_hd__clkbuf_2
X_12036_ _05120_ net3163 _05103_ _05108_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__o2bb2ai_2
Xfanout2376 net2378 VGND VGND VPWR VPWR net2376 sky130_fd_sc_hd__buf_2
Xfanout2387 net2388 VGND VGND VPWR VPWR net2387 sky130_fd_sc_hd__clkbuf_2
Xfanout1664 net1665 VGND VGND VPWR VPWR net1664 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1653 net1656 VGND VGND VPWR VPWR net1653 sky130_fd_sc_hd__clkbuf_1
Xfanout1675 net1679 VGND VGND VPWR VPWR net1675 sky130_fd_sc_hd__buf_1
Xfanout2398 net2399 VGND VGND VPWR VPWR net2398 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_109_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1686 net1690 VGND VGND VPWR VPWR net1686 sky130_fd_sc_hd__buf_1
XFILLER_77_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1697 net1701 VGND VGND VPWR VPWR net1697 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_140_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13987_ net2812 VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__inv_2
X_12938_ net1059 adder_inst.sum_raw_r\[16\] net2755 net739 net843 VGND VGND VPWR VPWR
+ _05983_ sky130_fd_sc_hd__o221a_1
X_12869_ net2771 net1055 net2774 net736 net840 VGND VGND VPWR VPWR _05923_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_64_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14539_ clknet_leaf_0_clk _00100_ _00361_ VGND VGND VPWR VPWR mul_res\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_135_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08060_ net1232 net1188 net825 _01144_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__o211ai_1
XFILLER_108_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08962_ _02037_ net679 _02047_ VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_126_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07913_ _00998_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__inv_2
X_08893_ net1024 net985 _01974_ net819 VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__o211a_4
X_07844_ _00795_ _00796_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__nand2_1
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07775_ net2275 net2302 VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__nand2_2
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09514_ net1218 net1181 VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nor2_1
X_09445_ _02529_ _02530_ _02447_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__a21oi_4
XFILLER_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_135_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09376_ net1414 net2364 _01021_ _01024_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__a22oi_2
XFILLER_137_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08327_ net1020 net921 net1502 net2464 _01408_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__o2111ai_2
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08258_ net612 _01124_ _01151_ _01152_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_125_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07209_ net1343 net2135 _06945_ _06946_ VGND VGND VPWR VPWR _06980_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_95_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08189_ _01265_ net474 _01232_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__a21oi_1
X_10220_ _03305_ _03082_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__nand2_1
XFILLER_106_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10151_ _06877_ net1093 _02712_ _03230_ _03231_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__o311a_1
XFILLER_121_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10082_ _03165_ _03166_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__nand2_1
X_13910_ net132 _05618_ _05613_ VGND VGND VPWR VPWR _06858_ sky130_fd_sc_hd__o21a_1
XFILLER_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13841_ _05290_ _06803_ VGND VGND VPWR VPWR _06804_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_122_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13772_ _06777_ _06250_ VGND VGND VPWR VPWR adder_inst.sum_raw\[23\] sky130_fd_sc_hd__xor2_1
XFILLER_28_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10984_ _04048_ _04049_ _04052_ _04065_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__a31oi_4
X_12723_ net1305 net1301 VGND VGND VPWR VPWR _05785_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12654_ _05717_ _05719_ _05718_ VGND VGND VPWR VPWR _05733_ sky130_fd_sc_hd__a21bo_1
XFILLER_129_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12585_ _05531_ _05532_ _05652_ _06933_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__and4_1
X_11605_ net1156 net1144 _04683_ _04685_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_137_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14324_ clknet_leaf_17_clk net61 _00146_ VGND VGND VPWR VPWR adder_inst.i_b\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11536_ _04127_ _04129_ net423 _04082_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__o211ai_2
X_14255_ net2884 VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__inv_2
Xmax_cap118 _05552_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_6
X_13206_ net528 net1894 _06076_ VGND VGND VPWR VPWR _06236_ sky130_fd_sc_hd__o21ai_4
X_11467_ _04420_ _04552_ VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__nor2_2
X_14186_ net2882 VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__inv_2
XFILLER_98_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11398_ net1208 net1114 _03894_ _04086_ _04085_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__o221ai_4
X_10418_ net2321 net1843 VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__nand2_1
XFILLER_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13137_ net1811 net485 _06165_ VGND VGND VPWR VPWR _06167_ sky130_fd_sc_hd__o21ai_1
X_10349_ net578 _03427_ _03428_ _03429_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__nand4_4
XFILLER_140_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2162 net2166 VGND VGND VPWR VPWR net2162 sky130_fd_sc_hd__buf_1
Xfanout2151 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net2151 sky130_fd_sc_hd__buf_6
X_13068_ net858 _05714_ _06066_ net527 _06094_ VGND VGND VPWR VPWR _06098_ sky130_fd_sc_hd__o221ai_2
Xfanout1450 net1451 VGND VGND VPWR VPWR net1450 sky130_fd_sc_hd__clkbuf_1
XFILLER_97_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2184 net2185 VGND VGND VPWR VPWR net2184 sky130_fd_sc_hd__clkbuf_1
XFILLER_78_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2173 net2174 VGND VGND VPWR VPWR net2173 sky130_fd_sc_hd__clkbuf_2
X_12019_ _05084_ _05086_ _05087_ _05100_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__a31o_1
Xfanout1472 net1474 VGND VGND VPWR VPWR net1472 sky130_fd_sc_hd__clkbuf_2
Xfanout1483 net1484 VGND VGND VPWR VPWR net1483 sky130_fd_sc_hd__clkbuf_1
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1461 net1462 VGND VGND VPWR VPWR net1461 sky130_fd_sc_hd__buf_1
Xfanout1494 net1495 VGND VGND VPWR VPWR net1494 sky130_fd_sc_hd__clkbuf_2
X_07560_ net1448 net1482 net2220 net2243 VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__nand4_2
XFILLER_65_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07491_ _00569_ _00573_ _00574_ _07102_ VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__a31oi_2
X_09230_ _02313_ _02314_ _02310_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__a21oi_4
XFILLER_22_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09161_ net1328 net2638 _02245_ _02246_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__a22o_1
XFILLER_119_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08112_ net2202 net1745 VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__nand2_1
X_09092_ net984 net974 net1680 net2318 _01350_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__o2111ai_2
XFILLER_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08043_ net1802 net1833 VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__nand2_4
XFILLER_128_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09994_ net2311 net1785 net1816 net2287 VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__a22o_1
XFILLER_142_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08945_ net2152 net1683 _02029_ net905 VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__a22o_1
X_08876_ net1440 net1472 net2365 net2381 VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__nand4_2
X_07827_ _00880_ net440 net410 VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__and3_1
XFILLER_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07758_ net1245 net1225 net1030 net995 VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__o22a_1
XFILLER_25_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07689_ _00773_ _00774_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__nand2_1
X_09428_ _02508_ _02510_ net354 VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__o21a_1
XFILLER_40_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09359_ _01938_ _01941_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__nand2_1
XFILLER_138_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12370_ _05447_ _05453_ VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__nor2_1
XFILLER_138_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11321_ net633 _04396_ _04397_ _04398_ _04404_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__a221oi_1
XFILLER_125_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14040_ net2864 VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__inv_2
X_11252_ _04325_ _04326_ _04332_ _04330_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__a22oi_4
XFILLER_121_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10203_ _03264_ _03267_ _03268_ _03274_ _03286_ VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__a32oi_2
X_11183_ _04262_ _04259_ _04252_ _04263_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__o211ai_1
XFILLER_133_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10134_ _03141_ _03146_ _03148_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__a2bb2oi_4
XFILLER_125_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10065_ net583 net584 _02972_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_106_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13824_ _04232_ _04240_ _05537_ VGND VGND VPWR VPWR _06787_ sky130_fd_sc_hd__or3_1
XFILLER_141_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13755_ _06259_ _06261_ _06758_ _06264_ VGND VGND VPWR VPWR _06763_ sky130_fd_sc_hd__a22oi_1
X_10967_ net871 _04031_ _04029_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__a21oi_2
X_13686_ net149 net158 _06691_ _06388_ _06701_ VGND VGND VPWR VPWR _06702_ sky130_fd_sc_hd__a221o_1
X_12706_ adder_inst.is_zero_b_r net3497 VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__or2_1
X_10898_ _03925_ net644 VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__nand2_1
X_12637_ adder_inst.exp_b_r\[5\] net2003 net859 _05714_ VGND VGND VPWR VPWR _05717_
+ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_135_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12568_ _05651_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__inv_2
X_12499_ net123 _05563_ _05582_ _05584_ VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__o211a_4
X_11519_ _04604_ _04599_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__nand2_1
XFILLER_8_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14307_ clknet_leaf_14_clk net14 _00129_ VGND VGND VPWR VPWR adder_inst.i_a\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_14238_ net2902 VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__inv_2
X_14169_ net2841 VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_59_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout709 _05825_ VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__buf_2
XFILLER_79_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08730_ _01813_ _01811_ _01782_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_72_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1291 net1295 VGND VGND VPWR VPWR net1291 sky130_fd_sc_hd__buf_1
XFILLER_94_740 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08661_ _01572_ _01581_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__and2_1
Xfanout1280 adder_inst.exp_b_r\[3\] VGND VGND VPWR VPWR net1280 sky130_fd_sc_hd__clkbuf_1
X_07612_ _00688_ _00693_ _00691_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__o21ai_1
XFILLER_81_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08592_ net2020 net1851 VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_37_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07543_ net1037 net1028 _00530_ _00532_ _00541_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__o2111ai_2
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07474_ net1392 net2254 net2282 net1364 VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__a22o_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09213_ _02282_ _02288_ _02297_ _02286_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__o2bb2ai_1
Xrebuffer304 _02143_ VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_22_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09144_ _02224_ _02225_ _02226_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__nand3_4
Xrebuffer337 _06597_ VGND VGND VPWR VPWR net1493 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer348 net1634 VGND VGND VPWR VPWR net1571 sky130_fd_sc_hd__clkbuf_1
Xrebuffer326 _03892_ VGND VGND VPWR VPWR net1146 sky130_fd_sc_hd__buf_6
Xrebuffer315 net748 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlymetal6s2s_1
X_09075_ net472 net595 _01334_ _01335_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__a22oi_4
Xrebuffer359 net277 VGND VGND VPWR VPWR net3277 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08026_ net2067 net1881 net1906 net2042 VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__a22oi_2
Xfanout2909 net2914 VGND VGND VPWR VPWR net2909 sky130_fd_sc_hd__buf_1
XFILLER_89_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09977_ _02815_ net667 _02827_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__a21o_1
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08928_ net712 _02013_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__nor2_2
X_08859_ _01904_ _01910_ _01943_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__o21ai_1
XFILLER_44_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11870_ _04950_ _04952_ _04935_ VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10821_ net1121 net1114 net1000 _03830_ _03832_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__o311a_1
XFILLER_111_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13540_ _06568_ _06494_ _06493_ VGND VGND VPWR VPWR _06569_ sky130_fd_sc_hd__a21oi_2
X_10752_ _03836_ _03837_ _03833_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_15_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13471_ _06164_ _06172_ net232 _06156_ VGND VGND VPWR VPWR _06500_ sky130_fd_sc_hd__a31oi_1
XFILLER_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12422_ _05501_ _05506_ _05505_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__a21oi_1
X_10683_ _03761_ _03764_ _03766_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__nand3_4
XFILLER_139_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12353_ _05324_ net164 _01073_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_117_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12284_ _01045_ _01051_ _01052_ net251 VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__nand4_1
XFILLER_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11304_ _04272_ _04273_ net1764 net2567 VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__nand4_1
XFILLER_141_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14023_ net2816 VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__inv_2
X_11235_ _04247_ _04318_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_112_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11166_ net961 net923 _04246_ _04244_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_112_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11097_ net567 _03851_ _03414_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__a21o_1
X_10117_ _02958_ _02959_ net1408 net2636 VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__nand4_1
XFILLER_76_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10048_ _03123_ _03125_ _03126_ _03121_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__a31o_4
XFILLER_75_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13807_ net3406 net728 VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_34_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13738_ _06600_ _06741_ _06747_ VGND VGND VPWR VPWR _06748_ sky130_fd_sc_hd__o21a_1
XFILLER_90_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11999_ _04990_ _05081_ _05079_ _05083_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__o22a_2
XFILLER_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13669_ net852 _06686_ _06685_ _06684_ VGND VGND VPWR VPWR _06687_ sky130_fd_sc_hd__a22o_1
X_07190_ net2079 net1452 VGND VGND VPWR VPWR _06961_ sky130_fd_sc_hd__nand2_2
XFILLER_117_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09900_ net434 net432 _02976_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__a21oi_4
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout506 net507 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__buf_8
XFILLER_112_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout539 net540 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__clkbuf_2
Xfanout528 net533 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__buf_6
Xfanout517 _06075_ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__buf_6
X_09831_ _02908_ _02914_ _02913_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__nand3_4
X_09762_ net901 _02598_ _02601_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__o21bai_1
X_08713_ net1024 net968 net1503 net2362 _01794_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__o2111ai_1
XFILLER_39_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer11 _01923_ VGND VGND VPWR VPWR net2929 sky130_fd_sc_hd__dlymetal6s2s_1
X_09693_ _02777_ _02297_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__nand2_1
XFILLER_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08644_ _01723_ _01626_ _01557_ net333 VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__a22oi_2
Xrebuffer33 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net2951 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer55 _04216_ VGND VGND VPWR VPWR net2973 sky130_fd_sc_hd__clkbuf_1
Xrebuffer22 _03892_ VGND VGND VPWR VPWR net2940 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer44 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net2962 sky130_fd_sc_hd__clkbuf_2
XFILLER_26_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08575_ net687 _01660_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__nand2_1
Xrebuffer77 _04174_ VGND VGND VPWR VPWR net2995 sky130_fd_sc_hd__buf_2
Xrebuffer66 _05303_ VGND VGND VPWR VPWR net2984 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer88 _04609_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07526_ _00537_ _00539_ _00608_ _00610_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_85_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer99 _03226_ VGND VGND VPWR VPWR net3017 sky130_fd_sc_hd__buf_2
X_07457_ net1038 net1027 _00536_ _00538_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_22_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07388_ net2105 net2130 VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__nand2_4
Xrebuffer112 _03705_ VGND VGND VPWR VPWR net3030 sky130_fd_sc_hd__buf_2
Xrebuffer101 net3132 VGND VGND VPWR VPWR net3019 sky130_fd_sc_hd__buf_8
XFILLER_22_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09127_ _02208_ _02209_ _02210_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__nand3_2
Xrebuffer134 _03437_ VGND VGND VPWR VPWR net3052 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer123 _03452_ VGND VGND VPWR VPWR net3041 sky130_fd_sc_hd__clkbuf_2
Xrebuffer145 _03227_ VGND VGND VPWR VPWR net3063 sky130_fd_sc_hd__buf_2
Xrebuffer156 _04996_ VGND VGND VPWR VPWR net3074 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_108_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09058_ net2234 net1776 _02142_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__nand3_4
Xrebuffer189 net3106 VGND VGND VPWR VPWR net3107 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer178 _02870_ VGND VGND VPWR VPWR net3096 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer167 _03451_ VGND VGND VPWR VPWR net3085 sky130_fd_sc_hd__buf_6
X_08009_ net2118 net1850 VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__nand2_1
Xhold571 _00002_ VGND VGND VPWR VPWR net3489 sky130_fd_sc_hd__dlygate4sd3_1
Xhold560 _00027_ VGND VGND VPWR VPWR net3478 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2717 net2722 VGND VGND VPWR VPWR net2717 sky130_fd_sc_hd__clkbuf_1
Xfanout2706 net2707 VGND VGND VPWR VPWR net2706 sky130_fd_sc_hd__buf_4
Xfanout2728 net2729 VGND VGND VPWR VPWR net2728 sky130_fd_sc_hd__buf_1
Xfanout2739 net2745 VGND VGND VPWR VPWR net2739 sky130_fd_sc_hd__clkbuf_1
Xhold582 multiplier_inst.exp_final_r\[4\] VGND VGND VPWR VPWR net3500 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11020_ _04100_ net869 net796 VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__and3_1
XFILLER_131_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12971_ net2748 net2710 net2731 _05858_ VGND VGND VPWR VPWR _06012_ sky130_fd_sc_hd__o211a_1
XFILLER_72_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11922_ _04918_ _05005_ net962 net910 VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_122_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11853_ _04854_ _04936_ VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__nand2_1
XFILLER_72_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10804_ _03883_ net345 _03881_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_0_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14572_ clknet_leaf_0_clk net3461 _00394_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
XFILLER_82_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11784_ _04848_ _04868_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nand2_1
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13523_ _06543_ _06545_ net486 VGND VGND VPWR VPWR _06552_ sky130_fd_sc_hd__a21oi_2
XFILLER_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10735_ _03813_ _03818_ _03819_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__nand3_4
XFILLER_41_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13454_ net294 _06431_ _06432_ net223 VGND VGND VPWR VPWR _06483_ sky130_fd_sc_hd__a31o_4
X_10666_ _03746_ _03749_ net876 VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__a21oi_1
X_12405_ net3066 _05490_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__nor2_4
X_13385_ _06413_ _06412_ net294 VGND VGND VPWR VPWR _06414_ sky130_fd_sc_hd__a21o_1
XFILLER_126_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10597_ net3143 _03672_ net1249 net346 VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__a31o_4
X_12336_ _05421_ VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__inv_2
XFILLER_141_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12267_ _01043_ _05352_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_56_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11218_ net939 _01366_ _04303_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__o21ai_1
X_14006_ net2806 VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__inv_2
X_12198_ net1920 net2679 _05267_ _05268_ _05260_ VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__a311o_1
Xoutput80 net80 VGND VGND VPWR VPWR o_res[20] sky130_fd_sc_hd__buf_2
XFILLER_96_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput91 net91 VGND VGND VPWR VPWR o_res[30] sky130_fd_sc_hd__buf_2
X_11149_ _03875_ _03877_ _03878_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__nand3_4
XFILLER_63_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08360_ _01444_ _01433_ _01443_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__nand3_2
XFILLER_51_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07311_ net1394 net2163 net2191 net1367 VGND VGND VPWR VPWR _07082_ sky130_fd_sc_hd__a22o_1
XFILLER_23_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08291_ _01332_ _01322_ net694 VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__a21boi_4
X_07242_ _07001_ _07003_ _07011_ _07012_ VGND VGND VPWR VPWR _07013_ sky130_fd_sc_hd__a211oi_2
X_07173_ net1358 net1385 VGND VGND VPWR VPWR _06944_ sky130_fd_sc_hd__nand2_1
XFILLER_118_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout314 net316 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout303 _06121_ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_6
Xfanout336 _06127_ VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_2
X_09814_ net587 net585 _02890_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__a21oi_1
Xfanout347 _03457_ VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_2
Xfanout325 _03148_ VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__buf_6
Xfanout358 _06137_ VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__buf_4
Xfanout369 _06091_ VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__buf_6
XFILLER_100_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09745_ _02563_ _02577_ net674 VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__and3_1
XFILLER_100_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09676_ net1111 net1103 net1051 net817 VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__o31a_1
X_08627_ _01187_ _01706_ _01707_ _01709_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__nand4_4
XFILLER_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08558_ _01245_ _01248_ _01247_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__o21ai_2
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07509_ _00591_ _00592_ _00593_ VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__a21o_1
X_08489_ net1357 net1384 net2504 net2535 VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_25_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10520_ _03602_ _03601_ _03597_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__nand3_4
XFILLER_10_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10451_ _03299_ net802 net1198 net1180 VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_114_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13170_ net1266 net1263 net480 VGND VGND VPWR VPWR _06200_ sky130_fd_sc_hd__mux2_1
X_10382_ _03226_ _03227_ _03233_ _03235_ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__o2bb2ai_2
X_12121_ _05203_ _05116_ VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__nand2_1
XFILLER_104_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12052_ _05066_ net247 VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__nand2_1
Xfanout2525 net2531 VGND VGND VPWR VPWR net2525 sky130_fd_sc_hd__buf_4
Xfanout2503 net2507 VGND VGND VPWR VPWR net2503 sky130_fd_sc_hd__buf_4
Xfanout2536 net2538 VGND VGND VPWR VPWR net2536 sky130_fd_sc_hd__clkbuf_2
Xfanout2514 net2515 VGND VGND VPWR VPWR net2514 sky130_fd_sc_hd__clkbuf_1
Xfanout1802 net1810 VGND VGND VPWR VPWR net1802 sky130_fd_sc_hd__buf_6
Xfanout2547 net2548 VGND VGND VPWR VPWR net2547 sky130_fd_sc_hd__buf_6
Xfanout2558 net2559 VGND VGND VPWR VPWR net2558 sky130_fd_sc_hd__buf_1
X_11003_ net1678 net2594 VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__nand2_1
Xfanout1813 net1814 VGND VGND VPWR VPWR net1813 sky130_fd_sc_hd__buf_2
Xfanout1824 net1830 VGND VGND VPWR VPWR net1824 sky130_fd_sc_hd__clkbuf_1
Xfanout2569 net2570 VGND VGND VPWR VPWR net2569 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_129_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1835 net1836 VGND VGND VPWR VPWR net1835 sky130_fd_sc_hd__buf_1
Xfanout1846 net1847 VGND VGND VPWR VPWR net1846 sky130_fd_sc_hd__buf_1
Xfanout870 _04103_ VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__clkbuf_1
Xfanout1857 net1862 VGND VGND VPWR VPWR net1857 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1879 net1880 VGND VGND VPWR VPWR net1879 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_51_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1868 net1869 VGND VGND VPWR VPWR net1868 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_5_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout892 _03170_ VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__buf_4
Xfanout881 _03531_ VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_1
XFILLER_133_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12954_ net2718 _05844_ _05995_ _05996_ VGND VGND VPWR VPWR _05997_ sky130_fd_sc_hd__or4_1
XFILLER_92_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_142_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11905_ net2542 net1964 net1987 net2517 VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__a22oi_4
X_12885_ net2771 net1064 net746 _05936_ _05935_ VGND VGND VPWR VPWR _05937_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_44_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11836_ net793 _04919_ net1155 net1112 VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__o2bb2a_1
X_14555_ clknet_leaf_8_clk _00086_ _00377_ VGND VGND VPWR VPWR mul_res\[22\] sky130_fd_sc_hd__dfrtp_1
X_11767_ _04851_ _04852_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__nand2_1
XFILLER_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13506_ net301 net339 net282 _06480_ _06481_ VGND VGND VPWR VPWR _06535_ sky130_fd_sc_hd__o221ai_2
X_10718_ _03783_ _03791_ _03798_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__o21ai_1
X_14486_ clknet_leaf_11_clk net3373 _00308_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_11698_ _04661_ _04663_ _04781_ _04783_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_139_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 _01627_ VGND VGND VPWR VPWR net2920 sky130_fd_sc_hd__clkbuf_2
X_13437_ net273 _06167_ net292 _06465_ VGND VGND VPWR VPWR _06466_ sky130_fd_sc_hd__o211ai_2
X_10649_ _03530_ net880 _03532_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__a21o_1
XFILLER_142_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13368_ net1202 net1692 net491 VGND VGND VPWR VPWR _06397_ sky130_fd_sc_hd__mux2_1
X_12319_ _05354_ _05356_ _05361_ _05362_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_114_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13299_ _06326_ _06327_ VGND VGND VPWR VPWR _06328_ sky130_fd_sc_hd__nand2_1
XFILLER_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07860_ _00898_ _00899_ _00900_ _00894_ VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_95_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07791_ _00866_ _00868_ _00873_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__and3_1
XFILLER_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09530_ net465 _02132_ _02153_ _02154_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_69_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09461_ net2105 net1976 VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__nand2_1
XFILLER_91_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_48_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09392_ _02465_ _02466_ _02474_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_82_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08412_ net1466 net2432 net2463 net1436 VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__a22oi_1
X_08343_ _01417_ _01426_ _01418_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__a21boi_1
X_08274_ _01210_ _01215_ _01355_ _01358_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_22_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07225_ net2056 net1370 net1398 net2084 _06938_ VGND VGND VPWR VPWR _06996_ sky130_fd_sc_hd__a41o_1
XFILLER_20_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07156_ net2011 net1283 VGND VGND VPWR VPWR _06927_ sky130_fd_sc_hd__and2b_1
XFILLER_118_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout122 net124 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_8
XFILLER_121_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout111 net112 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_2
Xfanout1109 net1111 VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__buf_2
Xfanout144 net145 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_6
Xfanout155 _06610_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_6
XFILLER_87_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout188 _06262_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_1
Xfanout177 _06502_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__buf_6
X_07989_ _00937_ _01069_ _00938_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__o21a_1
X_09728_ _02801_ _02805_ _02810_ VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__o21ai_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09659_ _02674_ _02679_ _02739_ _02678_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__o211ai_1
X_12670_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] VGND VGND
+ VPWR VPWR _05748_ sky130_fd_sc_hd__or3_1
XFILLER_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11621_ _04706_ _04703_ _04702_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_41_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_807 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14340_ clknet_leaf_17_clk net47 _00162_ VGND VGND VPWR VPWR adder_inst.i_b\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11552_ _04636_ _04637_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__nand2_1
XFILLER_11_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14271_ net2902 VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__inv_2
XFILLER_109_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11483_ _04482_ _04483_ _04484_ _04491_ VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__a31o_1
X_10503_ _03345_ _03346_ _03341_ net654 VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__o211ai_1
X_13222_ net269 _06195_ _06196_ net288 net230 VGND VGND VPWR VPWR _06251_ sky130_fd_sc_hd__o2111a_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10434_ _03270_ net658 VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__nand2_1
X_13153_ _06182_ VGND VGND VPWR VPWR _06183_ sky130_fd_sc_hd__inv_2
X_10365_ _03446_ _03444_ _03447_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__nand3_4
XFILLER_124_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2300 net2301 VGND VGND VPWR VPWR net2300 sky130_fd_sc_hd__buf_4
X_12104_ _05186_ net2675 net1825 net791 VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__nand4_1
Xfanout2311 net2312 VGND VGND VPWR VPWR net2311 sky130_fd_sc_hd__clkbuf_2
XFILLER_124_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2333 net2334 VGND VGND VPWR VPWR net2333 sky130_fd_sc_hd__clkbuf_2
XFILLER_97_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2344 net2346 VGND VGND VPWR VPWR net2344 sky130_fd_sc_hd__dlymetal6s2s_1
X_13084_ _06109_ _06111_ _06112_ VGND VGND VPWR VPWR _06114_ sky130_fd_sc_hd__nand3_4
X_10296_ net1636 net2495 net2525 net1601 VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__a22oi_2
Xfanout2322 net2323 VGND VGND VPWR VPWR net2322 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_127_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2366 net2367 VGND VGND VPWR VPWR net2366 sky130_fd_sc_hd__buf_1
Xfanout1632 net1633 VGND VGND VPWR VPWR net1632 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_77_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1621 net1629 VGND VGND VPWR VPWR net1621 sky130_fd_sc_hd__buf_1
Xfanout2355 net2357 VGND VGND VPWR VPWR net2355 sky130_fd_sc_hd__clkbuf_2
Xfanout2377 net2378 VGND VGND VPWR VPWR net2377 sky130_fd_sc_hd__buf_1
Xfanout1610 net1612 VGND VGND VPWR VPWR net1610 sky130_fd_sc_hd__buf_1
X_12035_ _05107_ _05105_ _05104_ net3163 _05120_ VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__a32oi_2
Xfanout1665 net1666 VGND VGND VPWR VPWR net1665 sky130_fd_sc_hd__buf_1
Xfanout1654 net1655 VGND VGND VPWR VPWR net1654 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1643 net1644 VGND VGND VPWR VPWR net1643 sky130_fd_sc_hd__clkbuf_2
Xfanout1676 net1677 VGND VGND VPWR VPWR net1676 sky130_fd_sc_hd__buf_4
Xfanout2388 net2389 VGND VGND VPWR VPWR net2388 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2399 net2404 VGND VGND VPWR VPWR net2399 sky130_fd_sc_hd__clkbuf_2
Xfanout1687 net1688 VGND VGND VPWR VPWR net1687 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1698 net1701 VGND VGND VPWR VPWR net1698 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_140_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13986_ net2809 VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__inv_2
X_12937_ net2759 net2733 net833 _05981_ VGND VGND VPWR VPWR _05982_ sky130_fd_sc_hd__a211o_1
XFILLER_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12868_ net2780 net2728 _05920_ _05921_ net833 VGND VGND VPWR VPWR _05922_ sky130_fd_sc_hd__a221o_1
XFILLER_34_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11819_ net2483 net2517 net1960 net1986 VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__nand4_1
X_12799_ net2698 _05852_ _05853_ net742 net836 VGND VGND VPWR VPWR _05861_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_64_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14538_ clknet_leaf_0_clk _00099_ _00360_ VGND VGND VPWR VPWR mul_res\[5\] sky130_fd_sc_hd__dfrtp_1
X_14469_ clknet_leaf_6_clk _00055_ _00291_ VGND VGND VPWR VPWR add_res\[27\] sky130_fd_sc_hd__dfrtp_1
XFILLER_134_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08961_ _02041_ _02043_ _02045_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07912_ _00997_ _00994_ _00996_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__o21ai_2
XFILLER_102_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08892_ _01795_ _01975_ VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__nand2_1
X_07843_ _00928_ _00919_ _00920_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__a21boi_1
XFILLER_111_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07774_ _00858_ _00859_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__nand2_1
XFILLER_72_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09513_ net2230 net2260 net1787 net1818 VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_27_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09444_ _02449_ _02526_ net3051 VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__nand3_4
XFILLER_25_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09375_ _02379_ _02380_ _02382_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__o21ai_1
X_08326_ _01405_ _01406_ net921 net1020 VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_137_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08257_ _01158_ _01124_ net612 VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__nand3_1
XFILLER_137_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07208_ _06977_ _06978_ _06952_ VGND VGND VPWR VPWR _06979_ sky130_fd_sc_hd__nand3_1
X_08188_ net473 net475 _01231_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__a21o_1
X_07139_ net2688 VGND VGND VPWR VPWR _06911_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_95_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10150_ net2977 net349 net896 VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__nand3_1
XFILLER_58_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10081_ net1635 net2462 net2494 net1601 VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__a22oi_1
XFILLER_58_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13840_ _05288_ _05289_ _06802_ VGND VGND VPWR VPWR _06803_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_122_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13771_ net856 _06776_ _06773_ VGND VGND VPWR VPWR _06777_ sky130_fd_sc_hd__o21ai_2
XFILLER_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10983_ _04054_ _04056_ _04064_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__a21o_1
X_12722_ net2785 net2691 net756 net2788 VGND VGND VPWR VPWR _05784_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12653_ _05732_ _05731_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[6\] sky130_fd_sc_hd__and2_4
XFILLER_24_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12584_ _05531_ _05532_ _05664_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__and3_1
X_11604_ net1156 net1144 _04368_ _04682_ _04686_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_137_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14323_ clknet_leaf_17_clk net60 _00145_ VGND VGND VPWR VPWR adder_inst.i_b\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11535_ net423 _04082_ _04127_ _04129_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14254_ net2884 VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__inv_2
XFILLER_139_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13205_ net253 _06207_ _06234_ _06174_ VGND VGND VPWR VPWR _06235_ sky130_fd_sc_hd__o211ai_4
X_11466_ _04451_ _04465_ _04452_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__a21boi_2
XFILLER_124_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14185_ net2857 VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__inv_2
X_10417_ _03494_ _03496_ _03497_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__nand3_4
X_11397_ _04085_ _04088_ _04089_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__a21o_1
XFILLER_140_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13136_ net1811 net484 _06165_ VGND VGND VPWR VPWR _06166_ sky130_fd_sc_hd__o21a_1
XFILLER_3_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10348_ _03425_ _03426_ _03430_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__a21oi_2
XFILLER_112_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2152 net2153 VGND VGND VPWR VPWR net2152 sky130_fd_sc_hd__clkbuf_2
Xfanout2130 net2131 VGND VGND VPWR VPWR net2130 sky130_fd_sc_hd__clkbuf_2
X_13067_ net858 _05714_ _06066_ net527 _06094_ VGND VGND VPWR VPWR _06097_ sky130_fd_sc_hd__o221a_1
Xfanout2141 net2143 VGND VGND VPWR VPWR net2141 sky130_fd_sc_hd__clkbuf_2
XFILLER_3_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10279_ _03351_ net579 net576 VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__and3_1
Xfanout1440 net1442 VGND VGND VPWR VPWR net1440 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2163 net2165 VGND VGND VPWR VPWR net2163 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2185 net2190 VGND VGND VPWR VPWR net2185 sky130_fd_sc_hd__clkbuf_2
Xfanout2174 net2175 VGND VGND VPWR VPWR net2174 sky130_fd_sc_hd__clkbuf_2
X_12018_ _05009_ _05010_ net626 net623 VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__o211ai_2
Xfanout1473 net1474 VGND VGND VPWR VPWR net1473 sky130_fd_sc_hd__buf_1
Xfanout1484 net1485 VGND VGND VPWR VPWR net1484 sky130_fd_sc_hd__clkbuf_1
Xfanout1451 net1456 VGND VGND VPWR VPWR net1451 sky130_fd_sc_hd__buf_1
XFILLER_93_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1462 net1463 VGND VGND VPWR VPWR net1462 sky130_fd_sc_hd__clkbuf_1
XFILLER_65_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1495 net1496 VGND VGND VPWR VPWR net1495 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13969_ net1325 net1995 _06875_ net1321 VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__o31a_1
XFILLER_80_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07490_ _00573_ _00574_ _00569_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09160_ net1380 net2587 net2614 net1352 VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__a22o_1
XFILLER_119_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08111_ net2227 net1711 VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__nand2_1
X_09091_ net1680 net2318 _01350_ _01351_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_32_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08042_ _01125_ _01126_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_12_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09993_ net2311 net1785 VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__nand2_1
XFILLER_135_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08944_ net2098 net2122 net1714 net1749 VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_90_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08875_ _01958_ _01959_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__nand2_1
XFILLER_97_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07826_ _00879_ net440 net410 VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__nand3_1
XFILLER_45_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07757_ net1505 net2277 VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__nand2_1
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07688_ _00425_ net1001 _00605_ _00607_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__o211ai_1
X_09427_ net353 _02509_ _02511_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__nand3b_2
XFILLER_138_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09358_ _02322_ _02439_ _02440_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__nand3_2
XFILLER_100_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08309_ net1651 net2347 net2373 net1616 VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__a22oi_1
XFILLER_126_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09289_ net1385 net2410 net2440 net1358 VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__a22o_1
XFILLER_60_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11320_ _04403_ _04399_ _04402_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11251_ _04329_ _04335_ _04334_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__o21ai_2
XFILLER_140_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10202_ _03282_ _03284_ net658 VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__o21ai_2
X_11182_ net866 _04264_ _04251_ _04266_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__o211ai_2
X_10133_ _03214_ _03217_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__nand2_8
XFILLER_121_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10064_ net581 _03120_ _03129_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_106_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13823_ net1116 net1097 net2927 net322 VGND VGND VPWR VPWR _06786_ sky130_fd_sc_hd__o211a_1
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13754_ net187 _06761_ _06760_ net135 VGND VGND VPWR VPWR _06762_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_71_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10966_ net871 _04031_ _04029_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_139_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13685_ net180 net488 _06380_ _06387_ VGND VGND VPWR VPWR _06701_ sky130_fd_sc_hd__a211oi_1
X_12705_ _05768_ _05771_ _05773_ VGND VGND VPWR VPWR adder_inst.is_inf_a sky130_fd_sc_hd__and3b_1
X_10897_ _03978_ _03977_ _03976_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__nand3_4
XFILLER_31_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12636_ net858 _05714_ VGND VGND VPWR VPWR _05716_ sky130_fd_sc_hd__nor2_1
X_12567_ _05649_ _05650_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__nand2_1
X_14306_ clknet_leaf_14_clk net13 _00128_ VGND VGND VPWR VPWR adder_inst.i_a\[20\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_12_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12498_ _05583_ VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__inv_2
X_11518_ _04568_ _04597_ _04596_ _04566_ VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__a31oi_4
XFILLER_8_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14237_ net2910 VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__inv_2
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11449_ _04521_ net558 VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__nand2_2
XFILLER_125_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14168_ net2853 VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_59_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13119_ _06146_ net789 net302 _06148_ net290 VGND VGND VPWR VPWR _06149_ sky130_fd_sc_hd__o311a_4
XFILLER_86_719 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14099_ net2808 VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_72_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1292 net1295 VGND VGND VPWR VPWR net1292 sky130_fd_sc_hd__clkbuf_1
Xfanout1270 net1271 VGND VGND VPWR VPWR net1270 sky130_fd_sc_hd__buf_1
XFILLER_94_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08660_ _01574_ _01575_ _01576_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__a21boi_1
Xfanout1281 adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR net1281 sky130_fd_sc_hd__buf_6
X_07611_ _00687_ _00696_ _00598_ VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__a21oi_1
XFILLER_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08591_ _01666_ _01676_ _01674_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_37_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07542_ _00529_ _00531_ _00543_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_37_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07473_ net1392 net2254 net2281 net1366 VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__a22oi_1
XFILLER_50_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09212_ _02289_ _02297_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__nand2_1
XFILLER_61_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09143_ _02224_ _02225_ _02226_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__and3_1
Xrebuffer305 _03440_ VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__buf_6
XFILLER_108_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer338 _06315_ VGND VGND VPWR VPWR net1515 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer327 _03659_ VGND VGND VPWR VPWR net1172 sky130_fd_sc_hd__dlymetal6s2s_1
X_09074_ net472 net595 _01336_ _01337_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__o2bb2ai_2
Xrebuffer349 net1758 VGND VGND VPWR VPWR net1634 sky130_fd_sc_hd__clkbuf_2
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08025_ net2066 net1881 VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__nand2_1
XFILLER_122_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09976_ _02815_ _02824_ _02825_ net667 VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__nand4_2
XFILLER_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08927_ net906 _01884_ _02012_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__a21o_1
XFILLER_130_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08858_ _01826_ net357 _01909_ _01911_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__a31oi_4
XFILLER_85_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07809_ _00766_ _00768_ _00891_ _00893_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__o211ai_2
XFILLER_85_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08789_ net2097 net1778 VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__nand2_1
XFILLER_55_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10820_ _03830_ _03831_ net1580 net2625 VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__and4_1
X_10751_ _03624_ _03626_ _03627_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__nand3_1
XFILLER_25_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13470_ net307 net334 _06232_ _06227_ VGND VGND VPWR VPWR _06499_ sky130_fd_sc_hd__a22o_1
XFILLER_13_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12421_ _05501_ _05505_ _05506_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__and3_1
XFILLER_9_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10682_ _03764_ _03761_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__nand2_4
XFILLER_139_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12352_ _05380_ _05437_ _05436_ _05413_ VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__o2bb2a_2
X_12283_ _01045_ _01053_ net251 VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__nand3_1
X_11303_ net961 net919 _04367_ _04370_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__o22a_1
XFILLER_141_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14022_ net2816 VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__inv_2
X_11234_ net2419 net1869 net1900 net2390 VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__a22oi_1
XFILLER_122_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11165_ _04246_ _04244_ _04250_ VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__o21ai_1
XFILLER_121_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11096_ _03414_ net567 _03851_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__nand3_1
X_10116_ net1408 net2636 _02958_ _02959_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__a22oi_1
XFILLER_96_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10047_ _03121_ net455 net582 VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__and3_1
XFILLER_90_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13806_ net3411 net728 VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__and2_1
XFILLER_91_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11998_ _05083_ _05079_ _05082_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__o21ai_1
X_13737_ net217 net194 _06598_ net850 VGND VGND VPWR VPWR _06747_ sky130_fd_sc_hd__o31a_1
X_10949_ _04030_ _04031_ net872 VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__a21oi_1
XFILLER_31_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13668_ _06411_ _06417_ _06419_ _06427_ _06679_ VGND VGND VPWR VPWR _06686_ sky130_fd_sc_hd__o32a_1
X_12619_ net444 net787 _05526_ _05664_ VGND VGND VPWR VPWR _05701_ sky130_fd_sc_hd__or4b_1
XFILLER_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13599_ _06612_ _06626_ VGND VGND VPWR VPWR adder_inst.sum_raw\[1\] sky130_fd_sc_hd__xor2_1
XFILLER_8_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout529 net532 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout507 net508 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__buf_8
X_09830_ _02908_ _02914_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__nand2_1
X_09761_ _02816_ _02819_ net897 VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__o21a_1
X_08712_ net1242 net1201 _01797_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__o21ai_1
XFILLER_39_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer12 _01627_ VGND VGND VPWR VPWR net2930 sky130_fd_sc_hd__buf_2
X_09692_ _02295_ _02296_ _02287_ _02289_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__o211ai_1
XFILLER_82_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08643_ _01559_ _01727_ _01728_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__nand3_4
Xrebuffer45 _02554_ VGND VGND VPWR VPWR net2963 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer34 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net2952 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer23 net2940 VGND VGND VPWR VPWR net2941 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer67 _01054_ VGND VGND VPWR VPWR net2985 sky130_fd_sc_hd__dlygate4sd1_1
X_08574_ _01655_ _01656_ _01644_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__nand3_4
Xrebuffer56 _03657_ VGND VGND VPWR VPWR net2974 sky130_fd_sc_hd__clkbuf_2
Xrebuffer78 _03452_ VGND VGND VPWR VPWR net2996 sky130_fd_sc_hd__buf_6
XFILLER_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer89 _02534_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_85_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07525_ _00537_ _00539_ _00608_ _00610_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__o211a_4
X_07456_ net1245 net1230 _00537_ net1027 net1037 VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__o32a_1
XFILLER_50_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07387_ net1520 net1547 VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__nand2_1
Xrebuffer102 _02230_ VGND VGND VPWR VPWR net3020 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09126_ net408 net407 _01385_ _01387_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__nand4_2
Xrebuffer135 _02165_ VGND VGND VPWR VPWR net3053 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer124 _03821_ VGND VGND VPWR VPWR net3042 sky130_fd_sc_hd__buf_1
Xrebuffer146 _03227_ VGND VGND VPWR VPWR net3064 sky130_fd_sc_hd__buf_8
XFILLER_136_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09057_ net1227 net1187 net949 net997 _01321_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__o221ai_4
Xrebuffer179 _02915_ VGND VGND VPWR VPWR net3097 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer168 _03377_ VGND VGND VPWR VPWR net3086 sky130_fd_sc_hd__buf_8
X_08008_ net715 VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__inv_2
Xhold561 add_res\[18\] VGND VGND VPWR VPWR net3479 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2718 net2721 VGND VGND VPWR VPWR net2718 sky130_fd_sc_hd__buf_4
Xfanout2707 adder_inst.sum_raw_r\[22\] VGND VGND VPWR VPWR net2707 sky130_fd_sc_hd__buf_1
Xhold572 multiplier_inst.exp_final_r\[1\] VGND VGND VPWR VPWR net3490 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold550 adder_inst.i_a\[22\] VGND VGND VPWR VPWR net3468 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 multiplier_inst.man_final_r\[19\] VGND VGND VPWR VPWR net3501 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2729 net2730 VGND VGND VPWR VPWR net2729 sky130_fd_sc_hd__buf_1
XFILLER_131_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09959_ net3144 _02803_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__nand2_4
XFILLER_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12970_ net1079 net2753 net2720 VGND VGND VPWR VPWR _06011_ sky130_fd_sc_hd__a21o_1
XFILLER_66_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11921_ net1919 net2573 net2599 net1890 VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__a22o_1
X_11852_ net1794 net1825 net2627 net2654 VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__nand4_2
X_14571_ clknet_leaf_0_clk net3458 _00393_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
X_10803_ _03886_ _03887_ _03881_ VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__nand3_4
XFILLER_26_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13522_ net774 net542 net1124 VGND VGND VPWR VPWR _06551_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_0_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11783_ _04867_ _04850_ _04848_ VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__a21boi_2
XFILLER_13_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10734_ _03761_ _03767_ _03811_ _03819_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__o211ai_1
X_13453_ net301 net361 _06480_ net233 _06481_ VGND VGND VPWR VPWR _06482_ sky130_fd_sc_hd__o311a_4
X_10665_ _03746_ _03749_ net876 VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__a21o_1
X_12404_ _05461_ _05475_ _05476_ _05485_ _05478_ VGND VGND VPWR VPWR _05490_ sky130_fd_sc_hd__a32o_1
X_13384_ net360 net298 _06210_ _06211_ VGND VGND VPWR VPWR _06413_ sky130_fd_sc_hd__o211ai_2
X_12335_ _02452_ _02456_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__and2_1
X_10596_ _03672_ net3142 _03674_ net345 VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__a31oi_4
XFILLER_142_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12266_ _00941_ _01038_ _01039_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__nand3_1
XFILLER_107_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput70 net70 VGND VGND VPWR VPWR o_res[11] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_56_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11217_ _04012_ _04293_ _04292_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__a21oi_2
X_14005_ net2802 VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__inv_2
X_12197_ _05245_ _05246_ _05257_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__o21ai_1
Xoutput81 net81 VGND VGND VPWR VPWR o_res[21] sky130_fd_sc_hd__buf_2
XFILLER_122_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput92 net92 VGND VGND VPWR VPWR o_res[31] sky130_fd_sc_hd__buf_2
X_11148_ _04231_ _04233_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__nand2_1
XFILLER_1_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11079_ net323 _04163_ _04135_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__a21oi_2
XFILLER_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07310_ net1394 net2163 net2192 net1367 VGND VGND VPWR VPWR _07081_ sky130_fd_sc_hd__a22oi_1
X_08290_ _01331_ _01326_ _01323_ net694 VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_31_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07241_ net2057 net1343 net2033 net1371 VGND VGND VPWR VPWR _07012_ sky130_fd_sc_hd__a22oi_2
XFILLER_32_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07172_ _06941_ _06942_ VGND VGND VPWR VPWR _06943_ sky130_fd_sc_hd__or2_1
XFILLER_133_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout315 net316 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__clkbuf_1
Xfanout337 _06127_ VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09813_ _02892_ _02893_ _02894_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__nand3_1
Xfanout348 _03329_ VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__buf_4
Xfanout359 _06137_ VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09744_ _02827_ _02828_ _02808_ _02814_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__o2bb2ai_2
X_09675_ _02752_ _02756_ _02757_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__nand3_4
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08626_ _01708_ _01710_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__nand2_2
XFILLER_82_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08557_ _01636_ _01641_ _01640_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__o21a_1
X_07508_ _00591_ _00592_ _00593_ VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__nand3_1
X_08488_ net1331 net2562 VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__nand2_1
X_07439_ net2049 net2075 net1630 net1664 VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__and4_1
XFILLER_136_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10450_ net1198 net1180 _03299_ net802 VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__a2bb2oi_1
XTAP_TAPCELL_ROW_114_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09109_ net693 net692 _01369_ _01370_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_98_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10381_ net3111 _03227_ _03234_ _03236_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__nand4_4
XFILLER_136_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12120_ _05113_ _05115_ net3048 _05128_ VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__o211ai_1
XFILLER_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2504 net2506 VGND VGND VPWR VPWR net2504 sky130_fd_sc_hd__clkbuf_2
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12051_ _05135_ _05130_ _05134_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__nand3_4
Xfanout2526 net2531 VGND VGND VPWR VPWR net2526 sky130_fd_sc_hd__buf_1
Xfanout2515 net2520 VGND VGND VPWR VPWR net2515 sky130_fd_sc_hd__buf_2
XFILLER_132_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1803 net1805 VGND VGND VPWR VPWR net1803 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2548 net2549 VGND VGND VPWR VPWR net2548 sky130_fd_sc_hd__buf_6
X_11002_ net1703 net1735 net2536 net2566 VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__nand4_1
Xfanout2559 net2560 VGND VGND VPWR VPWR net2559 sky130_fd_sc_hd__buf_1
Xfanout1825 net1828 VGND VGND VPWR VPWR net1825 sky130_fd_sc_hd__clkbuf_2
Xfanout1814 net1815 VGND VGND VPWR VPWR net1814 sky130_fd_sc_hd__clkbuf_1
Xfanout2537 net2538 VGND VGND VPWR VPWR net2537 sky130_fd_sc_hd__clkbuf_1
XFILLER_131_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1836 net1837 VGND VGND VPWR VPWR net1836 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout860 _05685_ VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__clkbuf_1
Xfanout1847 net1854 VGND VGND VPWR VPWR net1847 sky130_fd_sc_hd__clkbuf_2
Xfanout1858 net1859 VGND VGND VPWR VPWR net1858 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_51_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout893 _03052_ VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__buf_6
Xfanout871 _04026_ VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__buf_1
Xfanout1869 net1871 VGND VGND VPWR VPWR net1869 sky130_fd_sc_hd__buf_4
Xfanout882 _03507_ VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_1
X_12953_ net2754 net2731 _05804_ net2757 VGND VGND VPWR VPWR _05996_ sky130_fd_sc_hd__a22o_1
XFILLER_46_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11904_ net2543 net1964 VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__nand2_1
X_12884_ net2767 net1055 net2769 net736 net840 VGND VGND VPWR VPWR _05936_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_44_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11835_ _04917_ _04919_ _04914_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__a21oi_1
X_14554_ clknet_leaf_5_clk _00085_ _00376_ VGND VGND VPWR VPWR mul_res\[21\] sky130_fd_sc_hd__dfrtp_1
X_11766_ net1827 net2597 VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__nand2_1
X_14485_ clknet_leaf_11_clk net3371 _00307_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_13505_ net502 net175 _06530_ _06531_ VGND VGND VPWR VPWR _06534_ sky130_fd_sc_hd__o211ai_4
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10717_ _03783_ _03791_ net568 _03798_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__a2bb2oi_4
X_13436_ net273 _06229_ VGND VGND VPWR VPWR _06465_ sky130_fd_sc_hd__nand2_2
X_11697_ _04662_ _04660_ _04609_ _04638_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__o2bb2ai_4
Xrebuffer3 _05511_ VGND VGND VPWR VPWR net2921 sky130_fd_sc_hd__dlygate4sd1_1
X_10648_ _03709_ _03713_ net878 VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__o21a_1
X_13367_ _06395_ VGND VGND VPWR VPWR _06396_ sky130_fd_sc_hd__inv_2
X_10579_ _03644_ _03648_ _03611_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__o21ai_2
X_12318_ _05365_ _05356_ _05354_ VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__nand3_1
X_13298_ net217 _06323_ _06324_ net3170 VGND VGND VPWR VPWR _06327_ sky130_fd_sc_hd__or4_1
XFILLER_142_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12249_ _01011_ net477 _01031_ _01033_ VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__nand4_1
XFILLER_110_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07790_ _00866_ _00868_ _00873_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__a21oi_1
XFILLER_37_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09460_ _02088_ net3059 _02534_ _02544_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_69_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08411_ net1436 net1466 net2430 net2463 VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__nand4_2
X_09391_ _02465_ _02466_ _02474_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__a21oi_1
XFILLER_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_16_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
X_08342_ net690 _01427_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__nand2_1
X_08273_ _01356_ _01357_ _01354_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_22_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07224_ _06943_ _06994_ VGND VGND VPWR VPWR _06995_ sky130_fd_sc_hd__nor2_1
X_07155_ net1284 net2012 VGND VGND VPWR VPWR _06926_ sky130_fd_sc_hd__nand2b_1
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_6
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_8
Xfanout145 net146 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_1
XFILLER_114_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout156 net157 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_1
Xfanout134 net137 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_8
X_07988_ _01072_ _00704_ net185 _00817_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__nand4_1
XFILLER_101_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout178 _06502_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_1
Xfanout189 _04987_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ _02552_ _02807_ _02806_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09658_ _02674_ _02679_ _02739_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__o21ai_2
X_08609_ net1040 net954 net2125 net1777 _01689_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__o2111ai_1
XFILLER_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09589_ _02264_ _02265_ _02244_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__nand3_2
X_11620_ _04681_ _04684_ _04685_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__a21oi_2
XFILLER_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11551_ _04632_ _04633_ _04562_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_41_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_819 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10502_ _03347_ _03348_ net655 _03344_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__o211ai_1
XFILLER_137_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14270_ net2902 VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__inv_2
XFILLER_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11482_ _04507_ _04538_ _04539_ _04505_ net344 VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__a32oi_4
XFILLER_109_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13221_ _06241_ _06247_ _06249_ VGND VGND VPWR VPWR _06250_ sky130_fd_sc_hd__o21ba_1
X_10433_ _03501_ _03496_ _03490_ _03516_ net653 VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__a32oi_2
X_13152_ net1513 net2181 net480 VGND VGND VPWR VPWR _06182_ sky130_fd_sc_hd__mux2_1
XFILLER_3_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10364_ net324 _03147_ _03219_ VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__a21o_1
XFILLER_128_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2301 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net2301 sky130_fd_sc_hd__clkbuf_2
X_12103_ _05186_ net2676 net1825 net791 VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__and4_1
Xfanout2334 net2335 VGND VGND VPWR VPWR net2334 sky130_fd_sc_hd__clkbuf_1
XFILLER_105_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13083_ _05713_ _05736_ _06110_ VGND VGND VPWR VPWR _06113_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_53_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2323 net2328 VGND VGND VPWR VPWR net2323 sky130_fd_sc_hd__clkbuf_2
X_10295_ net1601 net1635 net2494 net2525 VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__nand4_2
Xfanout2312 net2313 VGND VGND VPWR VPWR net2312 sky130_fd_sc_hd__buf_1
Xfanout2367 net2368 VGND VGND VPWR VPWR net2367 sky130_fd_sc_hd__buf_2
XFILLER_111_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1622 net1624 VGND VGND VPWR VPWR net1622 sky130_fd_sc_hd__clkbuf_2
Xfanout1633 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net1633 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2345 net2346 VGND VGND VPWR VPWR net2345 sky130_fd_sc_hd__clkbuf_2
Xfanout2356 net2357 VGND VGND VPWR VPWR net2356 sky130_fd_sc_hd__clkbuf_2
Xfanout1600 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net1600 sky130_fd_sc_hd__clkbuf_2
Xfanout1611 net1612 VGND VGND VPWR VPWR net1611 sky130_fd_sc_hd__clkbuf_1
X_12034_ _05116_ _05117_ VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__nor2_2
Xfanout2378 net2379 VGND VGND VPWR VPWR net2378 sky130_fd_sc_hd__buf_2
Xfanout1666 net1667 VGND VGND VPWR VPWR net1666 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1655 net1656 VGND VGND VPWR VPWR net1655 sky130_fd_sc_hd__clkbuf_1
Xfanout1644 net1648 VGND VGND VPWR VPWR net1644 sky130_fd_sc_hd__clkbuf_2
Xfanout2389 net2396 VGND VGND VPWR VPWR net2389 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1688 net1689 VGND VGND VPWR VPWR net1688 sky130_fd_sc_hd__buf_1
Xfanout690 _01418_ VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__buf_2
Xfanout1699 net1700 VGND VGND VPWR VPWR net1699 sky130_fd_sc_hd__clkbuf_2
Xfanout1677 net1678 VGND VGND VPWR VPWR net1677 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_109_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13985_ net2806 VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__inv_2
X_12936_ net2764 net745 net2765 net749 _05980_ VGND VGND VPWR VPWR _05981_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_29_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12867_ net743 net2783 net2785 _05835_ VGND VGND VPWR VPWR _05921_ sky130_fd_sc_hd__o22a_1
XFILLER_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11818_ net2517 net1987 VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__nand2_2
X_14537_ clknet_leaf_20_clk _00098_ _00359_ VGND VGND VPWR VPWR mul_res\[4\] sky130_fd_sc_hd__dfrtp_1
X_12798_ net1058 net2712 VGND VGND VPWR VPWR _05860_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11749_ net2515 net1915 net2539 net1884 VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__a22oi_2
XFILLER_41_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14468_ clknet_leaf_6_clk _00054_ _00290_ VGND VGND VPWR VPWR add_res\[26\] sky130_fd_sc_hd__dfrtp_1
X_13419_ net511 _06445_ _06447_ VGND VGND VPWR VPWR _06448_ sky130_fd_sc_hd__o21a_1
X_14399_ clknet_leaf_10_clk adder_inst.man_a\[23\] _00221_ VGND VGND VPWR VPWR adder_inst.man_a_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_115_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_5_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_08960_ _02041_ _02043_ _02045_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__a21o_1
X_07911_ net1505 net2302 VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__nand2_1
X_08891_ net1528 net1558 net2276 net2302 VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__nand4_1
Xfanout2890 net2894 VGND VGND VPWR VPWR net2890 sky130_fd_sc_hd__clkbuf_2
X_07842_ _00926_ _00927_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__nand2_1
XFILLER_110_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07773_ net1476 net2277 VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__nand2_1
X_09512_ net989 net945 VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__nor2_4
XPHY_EDGE_ROW_3_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09443_ _02526_ _02527_ _02449_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__a21o_1
XFILLER_52_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09374_ _02361_ _02356_ _02360_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__o21ai_1
X_08325_ net2426 net2451 VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__nand2_2
XFILLER_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08256_ net612 _01124_ _01154_ _01156_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_20_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07207_ _06975_ _06976_ _06958_ VGND VGND VPWR VPWR _06978_ sky130_fd_sc_hd__nand3_1
X_08187_ net475 net473 _01231_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__a21oi_1
XFILLER_134_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07138_ net1272 VGND VGND VPWR VPWR _06910_ sky130_fd_sc_hd__inv_2
XFILLER_121_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10080_ net1601 net2494 VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__nand2_1
XFILLER_102_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13770_ _06256_ _06249_ _06775_ _06774_ VGND VGND VPWR VPWR _06776_ sky130_fd_sc_hd__o211a_1
XFILLER_43_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10982_ net1183 net1147 _04059_ _04061_ _04057_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__o311a_1
X_12721_ net1083 net2697 VGND VGND VPWR VPWR _05783_ sky130_fd_sc_hd__nand2_1
XFILLER_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12652_ _05724_ _05728_ _05639_ VGND VGND VPWR VPWR _05732_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11603_ net1156 net1143 _04368_ _04682_ _04686_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__o221a_1
X_12583_ _05576_ net3241 net114 net109 _05666_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__a41o_1
XFILLER_11_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14322_ clknet_leaf_18_clk net59 _00144_ VGND VGND VPWR VPWR adder_inst.i_b\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_11534_ _04125_ _04126_ net423 _04082_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__o211ai_1
X_14253_ net2884 VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__inv_2
XFILLER_11_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11465_ _04547_ _04548_ _04472_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__nand3_4
XFILLER_139_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13204_ _06233_ net377 _06220_ net252 VGND VGND VPWR VPWR _06234_ sky130_fd_sc_hd__nand4_4
X_10416_ _03486_ _03492_ _03497_ _03496_ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__o211ai_2
X_14184_ net2855 VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__inv_2
X_11396_ net973 net910 _04433_ _04435_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__o22a_1
XFILLER_140_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13135_ net774 net541 net2486 VGND VGND VPWR VPWR _06165_ sky130_fd_sc_hd__a21o_1
XFILLER_3_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10347_ _03430_ _03426_ _03425_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__nand3_4
Xfanout2153 net2157 VGND VGND VPWR VPWR net2153 sky130_fd_sc_hd__clkbuf_1
Xfanout2142 net2143 VGND VGND VPWR VPWR net2142 sky130_fd_sc_hd__clkbuf_1
Xfanout2120 net2128 VGND VGND VPWR VPWR net2120 sky130_fd_sc_hd__clkbuf_2
X_13066_ net1085 net1997 net731 _06067_ _06092_ VGND VGND VPWR VPWR _06096_ sky130_fd_sc_hd__o2111ai_1
Xfanout2131 net2139 VGND VGND VPWR VPWR net2131 sky130_fd_sc_hd__clkbuf_1
X_10278_ _03357_ net577 _03351_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__a21o_1
Xfanout1441 net1442 VGND VGND VPWR VPWR net1441 sky130_fd_sc_hd__buf_1
Xfanout2164 net2165 VGND VGND VPWR VPWR net2164 sky130_fd_sc_hd__clkbuf_1
Xfanout2186 net2189 VGND VGND VPWR VPWR net2186 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2175 net2176 VGND VGND VPWR VPWR net2175 sky130_fd_sc_hd__clkbuf_2
Xfanout1430 net1432 VGND VGND VPWR VPWR net1430 sky130_fd_sc_hd__clkbuf_2
X_12017_ _05009_ _05010_ net626 net623 VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__o211a_1
Xfanout1474 net1475 VGND VGND VPWR VPWR net1474 sky130_fd_sc_hd__buf_1
Xfanout1452 net1453 VGND VGND VPWR VPWR net1452 sky130_fd_sc_hd__buf_4
XFILLER_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout2197 net2198 VGND VGND VPWR VPWR net2197 sky130_fd_sc_hd__clkbuf_2
Xfanout1463 net1464 VGND VGND VPWR VPWR net1463 sky130_fd_sc_hd__clkbuf_2
Xfanout1485 net1490 VGND VGND VPWR VPWR net1485 sky130_fd_sc_hd__buf_1
Xfanout1496 net1497 VGND VGND VPWR VPWR net1496 sky130_fd_sc_hd__buf_4
X_13968_ net2015 _05888_ VGND VGND VPWR VPWR _06875_ sky130_fd_sc_hd__nor2_1
XFILLER_93_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12919_ net2690 net2754 net2756 net755 VGND VGND VPWR VPWR _05967_ sky130_fd_sc_hd__a22o_1
X_13899_ net125 _05605_ _05602_ VGND VGND VPWR VPWR _06850_ sky130_fd_sc_hd__a21bo_1
XFILLER_61_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08110_ net2263 net1681 VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__nand2_2
X_09090_ _01350_ _01351_ _01352_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_32_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08041_ net2173 net1801 net1832 net2145 VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__a22oi_4
XFILLER_116_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09992_ net2287 net1816 VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__nand2_1
X_08943_ _02026_ _02027_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08874_ net1472 net2365 net2382 net1440 VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__a22oi_1
XFILLER_96_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07825_ net440 net410 _00879_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__a21o_1
XFILLER_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07756_ net1530 net1561 net2215 net2240 VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__nand4_2
XFILLER_56_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09426_ net353 _02508_ _02510_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__nor3_1
X_07687_ _00604_ _00607_ _00605_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__a21o_1
XFILLER_25_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09357_ _02323_ _02441_ _02442_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__nand3_2
XFILLER_138_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09288_ net1358 net1385 net2410 net2440 VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__nand4_2
X_08308_ _01279_ _01280_ _01346_ _01393_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__nand4_4
XFILLER_138_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08239_ net1012 net958 _01299_ _01301_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_119_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11250_ _04330_ _04331_ _04328_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__a21oi_2
XFILLER_4_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_132_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10201_ _03283_ _03285_ _03273_ _03271_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__a22oi_2
X_11181_ _04266_ _04251_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__nand2_1
XFILLER_121_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10132_ _03214_ _03217_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__and2_4
XFILLER_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_66_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10063_ net581 _03120_ _03129_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__a21o_1
X_13822_ net124 _05541_ _05543_ VGND VGND VPWR VPWR _06785_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_106_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13753_ net188 _06750_ net153 VGND VGND VPWR VPWR _06761_ sky130_fd_sc_hd__a21oi_1
XFILLER_62_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12704_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] adder_inst.exp_a\[2\]
+ VGND VGND VPWR VPWR _05773_ sky130_fd_sc_hd__and4_1
X_10965_ _03744_ _03931_ net1764 net2477 _03930_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__o2111ai_4
X_13684_ _06392_ _06696_ _06697_ _06390_ VGND VGND VPWR VPWR _06700_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_75_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10896_ _03964_ _03975_ _03980_ _03979_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_61_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12635_ net2001 net1275 VGND VGND VPWR VPWR _05715_ sky130_fd_sc_hd__nand2b_1
X_12566_ _05643_ _05645_ net1283 net2011 VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__o211ai_1
X_11517_ _04599_ _04600_ _04565_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__a21o_1
XFILLER_8_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14305_ clknet_leaf_13_clk net11 _00127_ VGND VGND VPWR VPWR adder_inst.i_a\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_12497_ _05434_ _05579_ VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__xor2_2
X_14236_ net2908 VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__inv_2
X_11448_ net558 _04533_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__nand2_2
X_14167_ net2853 VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_59_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11379_ _04418_ _04463_ _04464_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_84_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13118_ net3301 _06147_ VGND VGND VPWR VPWR _06148_ sky130_fd_sc_hd__nand2_4
XFILLER_124_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14098_ net2821 VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__inv_2
XFILLER_140_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13049_ _06054_ net505 net783 _06078_ VGND VGND VPWR VPWR _06079_ sky130_fd_sc_hd__o211ai_4
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1260 net1261 VGND VGND VPWR VPWR net1260 sky130_fd_sc_hd__buf_1
Xfanout1282 adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR net1282 sky130_fd_sc_hd__clkbuf_1
Xfanout1271 _06878_ VGND VGND VPWR VPWR net1271 sky130_fd_sc_hd__buf_2
X_07610_ _00686_ _00694_ _00695_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__nand3_1
Xfanout1293 net1295 VGND VGND VPWR VPWR net1293 sky130_fd_sc_hd__buf_1
X_08590_ net375 _01662_ _01663_ _01671_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__a31o_1
XFILLER_81_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07541_ _00614_ _00624_ _00611_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__a21o_1
XFILLER_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_93_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07472_ _00555_ _00556_ _00554_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_17_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09211_ _02295_ _02296_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__nor2_2
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09142_ _01421_ _01423_ _01424_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__a21o_1
Xrebuffer317 _01921_ VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__buf_6
Xrebuffer339 _06311_ VGND VGND VPWR VPWR net1541 sky130_fd_sc_hd__buf_2
Xrebuffer306 _03453_ VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__buf_6
Xrebuffer328 _03436_ VGND VGND VPWR VPWR net1197 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_135_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09073_ net472 net595 _01338_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nand3_1
XFILLER_135_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08024_ net2040 net1911 VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__nand2_1
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09975_ _03042_ _03059_ _03047_ _03043_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_130_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08926_ net2074 net1778 _02008_ _02009_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__a22oi_2
X_08857_ _01826_ net357 net3083 VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__nand3_1
X_07808_ _00766_ _00768_ _00891_ _00893_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__o211a_1
XFILLER_17_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08788_ net1269 net1259 net952 _01685_ _01688_ VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__o32a_1
X_07739_ net2158 net1626 net1661 net2123 VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__a22oi_2
X_10750_ _03628_ _03834_ _03835_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__nand3_1
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09409_ _02489_ _02490_ _02491_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_101_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10681_ _03762_ _03763_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__nand2_1
X_12420_ _05496_ _05499_ _05497_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__o21ai_1
XFILLER_139_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12351_ _05381_ _05410_ VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__nand2_1
X_12282_ _01045_ net251 _01053_ VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__a21o_1
X_11302_ _04367_ _04370_ _04369_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__o21ai_1
X_14021_ net2816 VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__inv_2
X_11233_ net2390 net2419 net1869 net1900 VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__nand4_2
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11164_ net2419 net2449 net1871 net1901 VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__nand4_1
XFILLER_122_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11095_ net1471 net2664 net566 _03851_ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__a22o_1
X_10115_ _02958_ _02959_ _02960_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__a21o_1
X_10046_ net455 net582 _03121_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__a21oi_1
XFILLER_91_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13805_ net3501 net728 VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__and2_1
X_11997_ net1938 net2600 VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__nand2_1
X_13736_ net155 net160 _06737_ _06302_ _06744_ VGND VGND VPWR VPWR _06746_ sky130_fd_sc_hd__o221ai_1
XFILLER_90_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10948_ net871 _04030_ _04031_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_34_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13667_ net152 _06683_ net762 VGND VGND VPWR VPWR _06685_ sky130_fd_sc_hd__o21a_1
X_10879_ _03961_ _03962_ _03955_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__nand3_2
X_12618_ net119 _05665_ _05699_ VGND VGND VPWR VPWR _05700_ sky130_fd_sc_hd__and3_1
X_13598_ net854 _06623_ _06624_ _06625_ VGND VGND VPWR VPWR _06626_ sky130_fd_sc_hd__a22o_1
X_12549_ _05634_ _05633_ VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__xor2_2
XANTENNA_1 _01022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14219_ net2883 VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__inv_2
XFILLER_132_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout519 net520 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout508 net510 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__buf_6
XFILLER_112_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09760_ _02819_ _02816_ net897 VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__o21ai_4
XFILLER_112_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08711_ _01792_ _01793_ net1024 net968 VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__o2bb2ai_2
X_09691_ _02287_ _02289_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__nand2_1
X_08642_ _01719_ _01721_ _01627_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__o21ai_2
XFILLER_66_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1090 net1092 VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__clkbuf_2
XFILLER_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer24 _06295_ VGND VGND VPWR VPWR net2942 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer35 _02244_ VGND VGND VPWR VPWR net2953 sky130_fd_sc_hd__clkbuf_2
Xrebuffer13 _05315_ VGND VGND VPWR VPWR net2931 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer46 _04551_ VGND VGND VPWR VPWR net2964 sky130_fd_sc_hd__dlymetal6s2s_1
X_08573_ _01655_ _01656_ _01644_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__and3_1
XFILLER_54_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer57 _02888_ VGND VGND VPWR VPWR net2975 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer68 _04134_ VGND VGND VPWR VPWR net2986 sky130_fd_sc_hd__clkbuf_1
Xrebuffer79 _03810_ VGND VGND VPWR VPWR net2997 sky130_fd_sc_hd__buf_1
XFILLER_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07524_ _00535_ _00538_ net1246 net1231 VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07455_ net1037 net1027 net1511 net2194 _00538_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__o2111ai_2
XFILLER_23_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07386_ net1522 net1549 VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__and2_2
Xrebuffer103 _03437_ VGND VGND VPWR VPWR net3021 sky130_fd_sc_hd__buf_2
XFILLER_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer147 _05566_ VGND VGND VPWR VPWR net3065 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer114 _02088_ VGND VGND VPWR VPWR net3032 sky130_fd_sc_hd__dlygate4sd1_1
X_09125_ net408 net407 _01384_ _01386_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__o2bb2ai_1
Xrebuffer125 net203 VGND VGND VPWR VPWR net3043 sky130_fd_sc_hd__clkbuf_2
Xrebuffer136 _04231_ VGND VGND VPWR VPWR net3054 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_136_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer158 _01820_ VGND VGND VPWR VPWR net3076 sky130_fd_sc_hd__dlymetal6s2s_1
X_09056_ _01318_ _01319_ net996 net949 VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__o2bb2ai_4
Xrebuffer169 net3085 VGND VGND VPWR VPWR net3087 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_135_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08007_ net828 _01086_ _01088_ _01090_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__o2bb2ai_2
Xhold540 _00028_ VGND VGND VPWR VPWR net3458 sky130_fd_sc_hd__dlygate4sd3_1
Xhold562 _00009_ VGND VGND VPWR VPWR net3480 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2708 net2709 VGND VGND VPWR VPWR net2708 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold551 adder_inst.i_a\[12\] VGND VGND VPWR VPWR net3469 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold573 multiplier_inst.man_final_r\[14\] VGND VGND VPWR VPWR net3491 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout2719 net2721 VGND VGND VPWR VPWR net2719 sky130_fd_sc_hd__clkbuf_1
XFILLER_89_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold584 adder_inst.sign_a_r VGND VGND VPWR VPWR net3502 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09958_ net1230 net1126 net1035 net927 _02802_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__o221ai_4
X_08909_ _01991_ _01993_ _01992_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__o21ai_2
XFILLER_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09889_ _02972_ _02973_ _02949_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__a21boi_1
XFILLER_122_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11920_ net1919 net2573 net2600 net1891 VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__a22oi_2
XFILLER_72_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11851_ net1796 net1827 net2628 net2653 VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__and4_1
X_14570_ clknet_leaf_0_clk net3478 _00392_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
XFILLER_122_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10802_ _03680_ net1140 net345 net173 VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__a31oi_4
X_11782_ _04867_ _04850_ VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__nand2_2
X_13521_ net774 net541 net1123 VGND VGND VPWR VPWR _06550_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_0_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10733_ net2971 net429 net387 VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__nand3_4
X_13452_ net273 _06167_ _06465_ net282 VGND VGND VPWR VPWR _06481_ sky130_fd_sc_hd__o211ai_2
XFILLER_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10664_ net1183 net1169 _03744_ _03745_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__o22a_1
X_12403_ _05439_ _05440_ _05488_ VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__a21oi_4
X_13383_ net272 _06224_ _06225_ net292 VGND VGND VPWR VPWR _06412_ sky130_fd_sc_hd__o211ai_2
X_10595_ _03674_ _03672_ _03673_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__nand3_4
X_12334_ _05418_ _05419_ VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__nand2b_1
XFILLER_141_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12265_ _02509_ _05327_ _05344_ _05349_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_56_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14004_ net2806 VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__inv_2
XFILLER_141_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11216_ _04295_ _04297_ net1199 net1133 VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__o2bb2ai_1
X_12196_ _05246_ _05245_ _05279_ _05256_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__o211ai_4
Xoutput71 net71 VGND VGND VPWR VPWR o_res[12] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR o_res[3] sky130_fd_sc_hd__buf_2
XFILLER_122_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput82 net82 VGND VGND VPWR VPWR o_res[22] sky130_fd_sc_hd__buf_2
X_11147_ _04228_ _04230_ _04218_ _04203_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_122_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11078_ _04163_ net323 _04135_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__a21o_1
XFILLER_48_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10029_ net1167 net1161 net999 _02919_ _02922_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__o311a_1
XFILLER_36_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13719_ _06593_ _06594_ _06722_ VGND VGND VPWR VPWR _06731_ sky130_fd_sc_hd__a21o_1
XFILLER_31_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07240_ net2057 net1343 net2033 net1370 VGND VGND VPWR VPWR _07011_ sky130_fd_sc_hd__and4_1
X_07171_ net2032 net1425 _06934_ _06940_ VGND VGND VPWR VPWR _06942_ sky130_fd_sc_hd__a31oi_1
Xfanout305 _06120_ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_2
XFILLER_141_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout316 net320 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__buf_1
Xfanout338 _06126_ VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_2
X_09812_ _02896_ _02891_ _02895_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__nand3_2
Xfanout327 _02915_ VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__buf_6
Xfanout349 _03231_ VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__buf_4
X_09743_ _02813_ _02809_ net667 _02827_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_87_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09674_ _02759_ _02756_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__nand2_1
XFILLER_54_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08625_ _01706_ _01707_ _01709_ net611 VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__a22oi_2
X_08556_ _01636_ _01641_ _01640_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__o21ai_2
XFILLER_82_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07507_ _00497_ _00499_ _00585_ _00582_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__a31o_1
XFILLER_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08487_ _01561_ _01569_ _01570_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__nand3b_1
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07438_ net1609 net1644 VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__nand2_1
X_07369_ _00454_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__inv_2
XFILLER_10_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09108_ _01371_ _01372_ net693 net692 VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__o211ai_2
XFILLER_136_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10380_ net2994 net3064 _03237_ _03238_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__o2bb2ai_4
X_09039_ _01306_ _01307_ _01309_ _01298_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__o211a_1
Xfanout2505 net2506 VGND VGND VPWR VPWR net2505 sky130_fd_sc_hd__buf_1
XFILLER_78_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12050_ _05134_ _05135_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__nand2_1
Xfanout2527 net2529 VGND VGND VPWR VPWR net2527 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2516 net2518 VGND VGND VPWR VPWR net2516 sky130_fd_sc_hd__clkbuf_2
Xfanout1804 net1805 VGND VGND VPWR VPWR net1804 sky130_fd_sc_hd__clkbuf_1
XFILLER_77_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2549 net2550 VGND VGND VPWR VPWR net2549 sky130_fd_sc_hd__buf_8
X_11001_ net1703 net1735 net2538 net2565 VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__and4_2
Xfanout1815 net1824 VGND VGND VPWR VPWR net1815 sky130_fd_sc_hd__buf_1
Xfanout2538 net2549 VGND VGND VPWR VPWR net2538 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout850 net853 VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1837 net1838 VGND VGND VPWR VPWR net1837 sky130_fd_sc_hd__clkbuf_2
XFILLER_77_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout861 _05679_ VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1848 net1849 VGND VGND VPWR VPWR net1848 sky130_fd_sc_hd__buf_2
Xfanout1826 net1827 VGND VGND VPWR VPWR net1826 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_51_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout894 _03050_ VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__buf_6
Xfanout872 _04026_ VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__clkbuf_1
Xfanout1859 net1860 VGND VGND VPWR VPWR net1859 sky130_fd_sc_hd__clkbuf_2
Xfanout883 _03507_ VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__clkbuf_1
XFILLER_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12952_ net2758 net1081 net846 _05994_ VGND VGND VPWR VPWR _05995_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_5_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11903_ _04895_ _04985_ net189 VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__or3_1
X_12883_ net2774 net2729 _05934_ _05933_ net833 VGND VGND VPWR VPWR _05935_ sky130_fd_sc_hd__a221o_1
X_11834_ net1155 net1112 _04833_ _04918_ net793 VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__o221a_1
X_14553_ clknet_leaf_6_clk _00084_ _00375_ VGND VGND VPWR VPWR mul_res\[20\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_44_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11765_ net1796 net2626 VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__nand2_1
X_14484_ clknet_leaf_7_clk net3365 _00306_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_13504_ net503 net175 _06530_ _06531_ VGND VGND VPWR VPWR _06533_ sky130_fd_sc_hd__o211a_1
X_11696_ net163 _04634_ _04635_ _04778_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__a31o_1
X_10716_ net568 _03792_ _03798_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_24_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13435_ net1091 net1274 net603 net735 net2489 VGND VGND VPWR VPWR _06464_ sky130_fd_sc_hd__a221o_1
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10647_ _03709_ _03713_ net878 VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__o21ai_2
XFILLER_139_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer4 _03148_ VGND VGND VPWR VPWR net2922 sky130_fd_sc_hd__dlymetal6s2s_1
X_13366_ _06393_ _06394_ VGND VGND VPWR VPWR _06395_ sky130_fd_sc_hd__nand2b_4
X_10578_ _03657_ _03663_ _03662_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__nand3_4
X_12317_ _05385_ _05390_ _05402_ VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__o21ai_1
X_13297_ net217 net3170 _06325_ VGND VGND VPWR VPWR _06326_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12248_ _01011_ net477 _01030_ _01032_ VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_123_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12179_ net1938 net2657 _05219_ _05220_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__a22o_1
XFILLER_68_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08410_ net1465 net2430 VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__nand2_1
X_09390_ _02473_ _02465_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08341_ net691 _01426_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__nand2_1
X_08272_ _01211_ _01212_ _01213_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__a21o_1
XFILLER_60_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07223_ _06948_ _06992_ VGND VGND VPWR VPWR _06994_ sky130_fd_sc_hd__xor2_1
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07154_ net1283 net2011 VGND VGND VPWR VPWR _06925_ sky130_fd_sc_hd__and2b_2
XFILLER_105_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout102 net103 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_8
Xfanout113 net114 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_6
Xfanout124 net127 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_8
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_6
XFILLER_101_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout135 net137 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_6
XFILLER_86_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07987_ _01072_ _00704_ net185 _00817_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__and4_1
Xfanout179 _06486_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_6
XFILLER_47_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09726_ net1013 net930 net2148 net1930 _02550_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_2_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09657_ _02680_ _02740_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__nand2_1
X_08608_ net1253 net1189 _01690_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09588_ net2953 _02265_ _02264_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__a21oi_2
X_08539_ _01540_ _01620_ _01613_ _01617_ VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_41_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11550_ _04632_ _04633_ _04562_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_41_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10501_ net655 net654 _03345_ _03346_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_109_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13220_ net1340 net513 _06248_ VGND VGND VPWR VPWR _06249_ sky130_fd_sc_hd__a21oi_1
X_11481_ _04508_ _04536_ _04537_ _04504_ VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__a31oi_4
X_10432_ net653 _03516_ _03489_ _03502_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_136_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13151_ net299 net361 net267 _06180_ _06179_ VGND VGND VPWR VPWR _06181_ sky130_fd_sc_hd__o221ai_2
X_10363_ _03141_ _03146_ net324 _03219_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__o211ai_2
Xfanout2302 net2304 VGND VGND VPWR VPWR net2302 sky130_fd_sc_hd__clkbuf_2
X_13082_ net858 _06093_ _05736_ _05715_ VGND VGND VPWR VPWR _06112_ sky130_fd_sc_hd__o211ai_1
XFILLER_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12102_ net1829 net2675 net791 _05186_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__a22o_1
XFILLER_124_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2335 net2336 VGND VGND VPWR VPWR net2335 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_53_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2324 net2326 VGND VGND VPWR VPWR net2324 sky130_fd_sc_hd__buf_6
X_10294_ net1602 net2525 VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__nand2_1
X_12033_ _05113_ _05114_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__nor2_1
Xfanout2313 net2320 VGND VGND VPWR VPWR net2313 sky130_fd_sc_hd__buf_4
Xfanout1623 net1624 VGND VGND VPWR VPWR net1623 sky130_fd_sc_hd__buf_1
XFILLER_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2368 net2369 VGND VGND VPWR VPWR net2368 sky130_fd_sc_hd__clkbuf_2
Xfanout2346 net2347 VGND VGND VPWR VPWR net2346 sky130_fd_sc_hd__clkbuf_2
Xfanout1612 net1613 VGND VGND VPWR VPWR net1612 sky130_fd_sc_hd__buf_1
Xfanout1601 net1602 VGND VGND VPWR VPWR net1601 sky130_fd_sc_hd__buf_4
Xfanout2357 net2358 VGND VGND VPWR VPWR net2357 sky130_fd_sc_hd__clkbuf_2
Xfanout1667 adder_inst.man_b_r\[12\] VGND VGND VPWR VPWR net1667 sky130_fd_sc_hd__clkbuf_2
Xfanout1656 net1663 VGND VGND VPWR VPWR net1656 sky130_fd_sc_hd__buf_1
Xfanout1645 net1647 VGND VGND VPWR VPWR net1645 sky130_fd_sc_hd__buf_1
Xfanout2379 net2380 VGND VGND VPWR VPWR net2379 sky130_fd_sc_hd__clkbuf_2
Xfanout1689 net1690 VGND VGND VPWR VPWR net1689 sky130_fd_sc_hd__buf_1
Xfanout680 _01858_ VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__buf_6
Xfanout691 _01417_ VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__buf_6
Xfanout1678 net1679 VGND VGND VPWR VPWR net1678 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_109_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13984_ net2806 VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_29_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12935_ _06915_ net2742 net2731 VGND VGND VPWR VPWR _05980_ sky130_fd_sc_hd__a21oi_1
XFILLER_34_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12866_ _06912_ net2741 net2728 VGND VGND VPWR VPWR _05920_ sky130_fd_sc_hd__a21oi_1
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11817_ _04901_ _04902_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__nand2_2
X_14536_ clknet_leaf_20_clk _00097_ _00358_ VGND VGND VPWR VPWR mul_res\[3\] sky130_fd_sc_hd__dfrtp_1
X_12797_ net2702 net1067 VGND VGND VPWR VPWR _05859_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_64_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11748_ net1883 net2515 net1913 net2539 VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__nand4_2
X_14467_ clknet_leaf_7_clk _00053_ _00289_ VGND VGND VPWR VPWR add_res\[25\] sky130_fd_sc_hd__dfrtp_1
X_11679_ net710 net553 net448 VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__a21bo_1
XFILLER_127_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13418_ net779 net545 net1782 VGND VGND VPWR VPWR _06447_ sky130_fd_sc_hd__a21o_1
X_14398_ clknet_leaf_15_clk net3468 _00220_ VGND VGND VPWR VPWR adder_inst.man_a_r\[22\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_127_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13349_ _06373_ net489 _06374_ _06377_ VGND VGND VPWR VPWR _06378_ sky130_fd_sc_hd__a211oi_4
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07910_ net1529 net1559 net2239 net2275 VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__nand4_2
X_08890_ net1528 net1558 net2275 net2302 VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__and4_1
XFILLER_68_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2891 net2894 VGND VGND VPWR VPWR net2891 sky130_fd_sc_hd__buf_1
X_07841_ _00746_ _00748_ _00923_ _00924_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__nand4_1
Xfanout2880 net2897 VGND VGND VPWR VPWR net2880 sky130_fd_sc_hd__clkbuf_2
X_07772_ net1444 net2304 VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__nand2_1
XFILLER_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09511_ net2260 net1787 net1818 net2231 VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__a22oi_4
XFILLER_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09442_ _02526_ _02527_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__nand2_2
XFILLER_92_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09373_ net464 net608 VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__and2_1
XFILLER_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08324_ net1546 net2430 VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__nand2_1
XFILLER_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08255_ net612 _01124_ _01155_ _01157_ VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__nand4_1
XFILLER_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07206_ _06975_ _06976_ _06958_ VGND VGND VPWR VPWR _06977_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_104_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08186_ _01219_ _01230_ net475 net473 VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_95_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07137_ net1998 VGND VGND VPWR VPWR _06909_ sky130_fd_sc_hd__inv_2
XFILLER_134_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09709_ net249 _02750_ _02747_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__a21oi_2
XFILLER_16_704 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10981_ _04054_ _04056_ _04065_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__and3_1
X_12720_ net1084 net2696 VGND VGND VPWR VPWR _05782_ sky130_fd_sc_hd__and2_1
XFILLER_70_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12651_ _05729_ _05730_ net107 net111 net102 VGND VGND VPWR VPWR _05731_ sky130_fd_sc_hd__o2111ai_4
XFILLER_130_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11602_ _04683_ _04685_ _04681_ VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__o21bai_1
XFILLER_31_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12582_ net119 _05665_ _05663_ _05661_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_137_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_122_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14321_ clknet_leaf_18_clk net58 _00143_ VGND VGND VPWR VPWR adder_inst.i_b\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_11533_ _04584_ net417 net418 VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__a21boi_2
X_14252_ net2883 VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__inv_2
XFILLER_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11464_ _04547_ _04548_ _04472_ VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__a21o_1
X_13203_ _06232_ _06227_ net334 net308 VGND VGND VPWR VPWR _06233_ sky130_fd_sc_hd__nand4_4
X_10415_ _03487_ _03491_ _03495_ _03261_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__a22oi_1
X_14183_ net2857 VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__inv_2
X_11395_ _04433_ _04435_ _04434_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__o21ai_2
XFILLER_124_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2110 net2113 VGND VGND VPWR VPWR net2110 sky130_fd_sc_hd__dlymetal6s2s_1
X_13134_ net3277 _06161_ _06162_ net291 VGND VGND VPWR VPWR _06164_ sky130_fd_sc_hd__o211ai_2
XFILLER_3_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10346_ _03427_ net3137 _03431_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__a21oi_4
XFILLER_140_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2121 net2124 VGND VGND VPWR VPWR net2121 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2132 net2133 VGND VGND VPWR VPWR net2132 sky130_fd_sc_hd__dlymetal6s2s_1
X_13065_ net501 _06066_ VGND VGND VPWR VPWR _06095_ sky130_fd_sc_hd__nand2_2
Xfanout2143 net2147 VGND VGND VPWR VPWR net2143 sky130_fd_sc_hd__buf_1
X_10277_ _03357_ net576 _03351_ VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__a21oi_1
Xfanout2165 net2166 VGND VGND VPWR VPWR net2165 sky130_fd_sc_hd__clkbuf_2
Xfanout1420 net1421 VGND VGND VPWR VPWR net1420 sky130_fd_sc_hd__buf_1
Xfanout2154 net2157 VGND VGND VPWR VPWR net2154 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_78_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2176 net2182 VGND VGND VPWR VPWR net2176 sky130_fd_sc_hd__clkbuf_2
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1431 net1432 VGND VGND VPWR VPWR net1431 sky130_fd_sc_hd__clkbuf_2
X_12016_ net618 _05101_ _05090_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_131_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1475 net1476 VGND VGND VPWR VPWR net1475 sky130_fd_sc_hd__clkbuf_2
Xfanout1442 net1443 VGND VGND VPWR VPWR net1442 sky130_fd_sc_hd__clkbuf_1
Xfanout1453 net1454 VGND VGND VPWR VPWR net1453 sky130_fd_sc_hd__clkbuf_2
Xfanout2187 net2188 VGND VGND VPWR VPWR net2187 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2198 net2199 VGND VGND VPWR VPWR net2198 sky130_fd_sc_hd__buf_1
Xfanout1464 net1470 VGND VGND VPWR VPWR net1464 sky130_fd_sc_hd__clkbuf_2
Xfanout1486 net1487 VGND VGND VPWR VPWR net1486 sky130_fd_sc_hd__clkbuf_2
Xfanout1497 net1498 VGND VGND VPWR VPWR net1497 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13967_ net3444 mul_res\[31\] net2789 VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12918_ _05964_ _05965_ net841 VGND VGND VPWR VPWR _05966_ sky130_fd_sc_hd__and3_1
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13898_ _05577_ _05586_ _05595_ _06847_ _06849_ VGND VGND VPWR VPWR multiplier_inst.man_final\[11\]
+ sky130_fd_sc_hd__o32a_1
X_12849_ _05903_ _05904_ _05905_ net835 VGND VGND VPWR VPWR _05906_ sky130_fd_sc_hd__a211o_1
XFILLER_21_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_140_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14519_ clknet_leaf_1_clk multiplier_inst.man_final\[19\] _00341_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_119_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08040_ net2145 net1834 VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09991_ _03076_ _03070_ _03075_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nand3_4
X_08942_ net2122 net1713 net1749 net2098 VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__a22oi_1
XFILLER_88_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08873_ net1474 net2366 VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__nand2_1
XFILLER_96_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07824_ _00905_ _00906_ _00903_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__nand3_2
X_07755_ net1558 net2239 VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__nand2_1
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07686_ _00761_ _00771_ VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_121_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09425_ net2022 net1779 _00942_ _02505_ _02506_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__a32o_1
XFILLER_52_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09356_ _02330_ _02331_ _02437_ _02438_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__a22o_1
X_09287_ _02022_ _02055_ _02053_ _02050_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__o2bb2ai_1
X_08307_ _01345_ _01390_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__nand2_1
XFILLER_60_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08238_ _01299_ _01301_ _01300_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_119_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08169_ _01203_ _01242_ _01253_ _01254_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__o211a_1
X_10200_ _03283_ _03285_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_132_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11180_ _04258_ _04260_ net1192 net1145 VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_134_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10131_ _03152_ _03156_ _03211_ net431 VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__o211ai_4
X_10062_ _03144_ _03145_ _03140_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__nand3_4
XFILLER_0_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13821_ multiplier_inst.is_nan_r net1318 net3496 VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__and3b_1
XFILLER_141_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13752_ net187 _06604_ net188 VGND VGND VPWR VPWR _06760_ sky130_fd_sc_hd__a21bo_1
XFILLER_56_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12703_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] VGND VGND
+ VPWR VPWR _05772_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_48_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10964_ net1184 net1163 _03929_ _03932_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__o22ai_2
X_13683_ net3175 _06699_ VGND VGND VPWR VPWR adder_inst.sum_raw\[12\] sky130_fd_sc_hd__xor2_2
XFILLER_71_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10895_ _03977_ _03978_ _03976_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_61_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12634_ net2001 net1275 VGND VGND VPWR VPWR _05714_ sky130_fd_sc_hd__and2b_1
X_12565_ net1283 net2011 _05643_ _05645_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__a211o_1
XFILLER_129_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11516_ _04599_ _04600_ _04566_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__a21o_1
X_14304_ clknet_leaf_13_clk net10 _00126_ VGND VGND VPWR VPWR adder_inst.i_a\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_12496_ net123 _05581_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__nand2_8
X_14235_ net2909 VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__inv_2
XFILLER_125_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11447_ _04336_ _04338_ _04524_ _04526_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__o211ai_4
XFILLER_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14166_ net2866 VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__inv_2
X_11378_ _04461_ _04462_ _04458_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_59_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13117_ net1958 net2658 net501 VGND VGND VPWR VPWR _06147_ sky130_fd_sc_hd__mux2_1
X_10329_ net1434 net1464 net2637 net2662 VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__and4_1
XFILLER_140_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14097_ net2821 VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_72_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1250 _06882_ VGND VGND VPWR VPWR net1250 sky130_fd_sc_hd__clkbuf_4
X_13048_ net505 _06059_ VGND VGND VPWR VPWR _06078_ sky130_fd_sc_hd__nand2_4
Xfanout1261 net1262 VGND VGND VPWR VPWR net1261 sky130_fd_sc_hd__buf_1
Xfanout1283 adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR net1283 sky130_fd_sc_hd__buf_6
Xfanout1272 net1273 VGND VGND VPWR VPWR net1272 sky130_fd_sc_hd__buf_8
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1294 net1295 VGND VGND VPWR VPWR net1294 sky130_fd_sc_hd__buf_1
XFILLER_93_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07540_ _00614_ _00624_ _00611_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07471_ _00554_ _00555_ _00556_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__nand3_2
XFILLER_62_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09210_ _02292_ _02293_ _02294_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__and3_1
XFILLER_50_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09141_ net1237 net1149 net1018 net917 _01423_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__o221ai_4
Xrebuffer318 _02543_ VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__buf_6
Xrebuffer307 net369 VGND VGND VPWR VPWR net3225 sky130_fd_sc_hd__buf_4
X_09072_ _02156_ net466 _02125_ _02131_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__o2bb2ai_2
Xrebuffer329 _03681_ VGND VGND VPWR VPWR net1217 sky130_fd_sc_hd__buf_6
XFILLER_135_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08023_ net2092 net1853 VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__nand2_1
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09974_ _03046_ _03044_ _03059_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__a21oi_4
XFILLER_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08925_ _02009_ net1779 net2074 _02008_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__nand4_1
X_08856_ _01937_ _01941_ _01940_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__o21ai_4
X_07807_ net986 _00767_ net1270 net1215 VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_57_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08787_ net1040 net955 _01689_ _01684_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_72_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07738_ net2122 net1661 VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__nand2_1
X_07669_ _00751_ _00752_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__nor2_1
X_09408_ _02489_ _02491_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_101_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10680_ _03525_ _03526_ _03544_ _03546_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__nand4_1
X_09339_ _02420_ _02372_ _02419_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__nand3_1
XFILLER_138_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12350_ _05426_ _05432_ _05433_ VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__o21a_1
X_12281_ _05354_ _05365_ _05355_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__a21oi_1
X_11301_ _04382_ _04377_ _04383_ VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__nand3_4
XFILLER_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14020_ net2816 VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__inv_2
X_11232_ net2390 net1900 VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__nand2_1
X_11163_ net2420 net2448 net1883 net1913 VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__and4_1
X_10114_ net1264 net1101 _02958_ _02959_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_112_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11094_ net566 _03851_ net1471 net2664 VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__nand4_1
XFILLER_0_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10045_ _03123_ _03125_ _03126_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__nand3_2
XFILLER_29_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13804_ net3495 net728 VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__and2_1
XFILLER_29_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11996_ net2542 net1962 net2571 net1987 VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__nand4_2
X_13735_ net1493 _06744_ _06302_ net135 VGND VGND VPWR VPWR _06745_ sky130_fd_sc_hd__a211o_1
X_10947_ _04027_ _04028_ net871 VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_34_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13666_ _06581_ _06682_ _06611_ _06421_ net159 VGND VGND VPWR VPWR _06684_ sky130_fd_sc_hd__o2111ai_1
XTAP_TAPCELL_ROW_14_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12617_ net444 VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__inv_2
X_10878_ _03961_ _03962_ _03955_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__and3_1
X_13597_ net152 net3186 net852 VGND VGND VPWR VPWR _06625_ sky130_fd_sc_hd__a21oi_2
XFILLER_8_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12548_ _07067_ _05513_ _07064_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__a21oi_2
X_12479_ net140 net314 _05556_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__nand3_2
XFILLER_117_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_2 _02699_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14218_ net2869 VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14149_ net2911 VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__inv_2
XFILLER_112_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout509 net510 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__clkbuf_2
XFILLER_140_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08710_ net1531 net1558 net2305 net2331 VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__and4_1
X_09690_ _02758_ _02774_ _02761_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__a21boi_1
Xfanout1091 net1092 VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__buf_1
X_08641_ _01622_ _01623_ _01720_ _01722_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__nand4_4
XFILLER_94_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer25 _06295_ VGND VGND VPWR VPWR net2943 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer36 _05308_ VGND VGND VPWR VPWR net2954 sky130_fd_sc_hd__dlygate4sd1_1
X_08572_ net687 VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__inv_2
XFILLER_82_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer58 _02888_ VGND VGND VPWR VPWR net2976 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer69 _04794_ VGND VGND VPWR VPWR net2987 sky130_fd_sc_hd__buf_1
Xrebuffer47 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net2965 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_85_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07523_ _00535_ _00538_ _00536_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__a21oi_1
XFILLER_62_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07454_ net1037 net1028 _00536_ _00538_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__o211a_1
XFILLER_50_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07385_ _00470_ _00465_ _00428_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__nand3_2
Xrebuffer104 _02107_ VGND VGND VPWR VPWR net3022 sky130_fd_sc_hd__clkbuf_2
XFILLER_41_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer115 _01930_ VGND VGND VPWR VPWR net3033 sky130_fd_sc_hd__buf_1
X_09124_ net408 net407 _01390_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__a21o_1
Xrebuffer137 _02277_ VGND VGND VPWR VPWR net3055 sky130_fd_sc_hd__clkbuf_2
Xrebuffer126 _04237_ VGND VGND VPWR VPWR net3044 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_135_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer148 net3079 VGND VGND VPWR VPWR net3066 sky130_fd_sc_hd__dlymetal6s4s_1
XTAP_TAPCELL_ROW_116_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer159 _01830_ VGND VGND VPWR VPWR net3077 sky130_fd_sc_hd__buf_2
X_09055_ _02109_ net904 _02112_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__a21oi_1
Xhold530 mul_res\[3\] VGND VGND VPWR VPWR net3448 sky130_fd_sc_hd__dlygate4sd3_1
X_08006_ net828 _01086_ _01089_ _01091_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__nand4_2
Xfanout2709 net2713 VGND VGND VPWR VPWR net2709 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold552 add_res\[22\] VGND VGND VPWR VPWR net3470 sky130_fd_sc_hd__dlygate4sd3_1
Xhold563 adder_inst.is_nan_b_r VGND VGND VPWR VPWR net3481 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold541 adder_inst.i_a\[15\] VGND VGND VPWR VPWR net3459 sky130_fd_sc_hd__dlygate4sd3_1
Xhold574 add_res\[8\] VGND VGND VPWR VPWR net3492 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold585 adder_inst.sign_b_r VGND VGND VPWR VPWR net3503 sky130_fd_sc_hd__dlygate4sd3_1
X_09957_ net1230 net1128 net1035 net927 _02802_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__o221a_1
XFILLER_131_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08908_ _01988_ _01989_ _01970_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__a21o_1
XFILLER_58_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09888_ _02972_ net583 net584 VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__nand3_2
X_08839_ _01913_ _01918_ net957 _01754_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__o211ai_4
XFILLER_122_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11850_ net1795 net2654 VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__nand2_1
XFILLER_122_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10801_ _03680_ _03681_ net345 VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__nand3_2
XFILLER_14_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_824 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11781_ _04863_ _04861_ _04866_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__a21oi_4
XFILLER_32_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13520_ net1100 net528 _06543_ _06547_ VGND VGND VPWR VPWR _06549_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_0_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10732_ net386 net387 net429 VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__a21o_4
XFILLER_26_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13451_ net275 _06159_ _06479_ VGND VGND VPWR VPWR _06480_ sky130_fd_sc_hd__o21ai_4
X_10663_ net1762 net2447 VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__nand2_1
XFILLER_139_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12402_ _05479_ _05487_ VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__or2_1
X_13382_ net779 net545 net1724 VGND VGND VPWR VPWR _06411_ sky130_fd_sc_hd__a21oi_1
X_10594_ _03671_ _03661_ _03676_ _03677_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__o211ai_4
X_12333_ _02520_ _02523_ _05416_ _05417_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__nand4_1
XFILLER_5_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12264_ _05330_ _05345_ _05348_ _05328_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__a31oi_1
XFILLER_99_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14003_ net2859 VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_56_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11215_ net1199 net1133 net939 _01366_ _04297_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__o221ai_1
X_12195_ _05245_ _05246_ _05279_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__o21ai_1
Xoutput72 net72 VGND VGND VPWR VPWR o_res[13] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR o_res[4] sky130_fd_sc_hd__buf_2
Xoutput83 net83 VGND VGND VPWR VPWR o_res[23] sky130_fd_sc_hd__buf_2
X_11146_ net3054 VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__inv_2
XFILLER_1_761 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11077_ _04161_ _04162_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__nor2_1
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10028_ _03108_ _03106_ _03109_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__nand3_4
XFILLER_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13718_ _06593_ _06594_ VGND VGND VPWR VPWR _06730_ sky130_fd_sc_hd__and2_1
X_11979_ _04965_ _04967_ _04971_ _04972_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_31_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13649_ _06446_ _06448_ net162 VGND VGND VPWR VPWR _06669_ sky130_fd_sc_hd__o21a_1
XFILLER_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07170_ _06934_ _06940_ net2032 net1425 VGND VGND VPWR VPWR _06941_ sky130_fd_sc_hd__and4_1
Xfanout317 net319 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__buf_1
XFILLER_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout339 _06126_ VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlymetal6s2s_1
X_09811_ _02893_ _02894_ _02892_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__a21oi_1
XFILLER_100_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09742_ _02806_ _02812_ _02811_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_87_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09673_ net249 _02746_ _02753_ _02278_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__a22oi_1
XFILLER_54_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08624_ net611 _01709_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__nand2_1
X_08555_ _01634_ _01635_ _01632_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__a21o_1
XFILLER_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07506_ _00516_ _00589_ _00590_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__nand3_1
XFILLER_63_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08486_ _01571_ _01561_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__nand2_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07437_ net2075 net1630 net1664 net2050 VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__a22oi_4
XFILLER_136_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07368_ _07091_ _00446_ _00453_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__a21oi_1
XFILLER_7_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09107_ _01369_ _01370_ _01359_ net692 VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__o211ai_4
X_07299_ net2051 net2076 net1536 net1565 VGND VGND VPWR VPWR _07070_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_98_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09038_ net3094 _02091_ _02103_ _02107_ _02121_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__a32oi_2
XFILLER_116_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2506 net2507 VGND VGND VPWR VPWR net2506 sky130_fd_sc_hd__buf_1
Xfanout2517 net2518 VGND VGND VPWR VPWR net2517 sky130_fd_sc_hd__buf_4
XFILLER_2_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1805 net1809 VGND VGND VPWR VPWR net1805 sky130_fd_sc_hd__clkbuf_2
Xfanout2528 net2529 VGND VGND VPWR VPWR net2528 sky130_fd_sc_hd__buf_1
X_11000_ net1735 net2566 VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__nand2_1
Xfanout2539 net2540 VGND VGND VPWR VPWR net2539 sky130_fd_sc_hd__clkbuf_2
Xfanout1816 net1818 VGND VGND VPWR VPWR net1816 sky130_fd_sc_hd__clkbuf_2
XFILLER_131_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout840 net842 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__clkbuf_1
XFILLER_104_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout851 net853 VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__buf_1
Xfanout1838 net1839 VGND VGND VPWR VPWR net1838 sky130_fd_sc_hd__clkbuf_2
Xfanout1849 net1852 VGND VGND VPWR VPWR net1849 sky130_fd_sc_hd__clkbuf_2
Xfanout1827 net1828 VGND VGND VPWR VPWR net1827 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_93_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout862 _05679_ VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__clkbuf_1
Xfanout873 _03918_ VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__buf_4
Xfanout884 net885 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__buf_1
X_12951_ _06915_ net1081 VGND VGND VPWR VPWR _05994_ sky130_fd_sc_hd__nand2_1
XFILLER_100_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout895 _03050_ VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__clkbuf_2
XFILLER_45_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12882_ net2776 net1073 net2780 net743 net1078 VGND VGND VPWR VPWR _05934_ sky130_fd_sc_hd__o221a_1
XFILLER_46_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11902_ _04985_ net189 VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__or2_4
XFILLER_18_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11833_ net1890 net1915 net2539 net2575 VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__nand4_2
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14552_ clknet_leaf_6_clk _00082_ _00374_ VGND VGND VPWR VPWR mul_res\[19\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_44_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11764_ _04842_ _04846_ _04847_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__nand3_4
X_14483_ clknet_leaf_7_clk net3364 _00305_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_13503_ net503 net175 _06531_ VGND VGND VPWR VPWR _06532_ sky130_fd_sc_hd__o21ai_4
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11695_ _04638_ _04609_ _04778_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__a21oi_2
XFILLER_14_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10715_ _03583_ _03795_ _03797_ _03793_ VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_24_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13434_ net3183 _06461_ VGND VGND VPWR VPWR _06463_ sky130_fd_sc_hd__xnor2_1
X_10646_ _03706_ _03722_ _03725_ _03726_ VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__o211ai_4
XFILLER_139_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer5 _03598_ VGND VGND VPWR VPWR net2923 sky130_fd_sc_hd__clkbuf_2
X_13365_ _06378_ _06379_ VGND VGND VPWR VPWR _06394_ sky130_fd_sc_hd__and2b_2
X_10577_ net3086 _03379_ _03438_ _03439_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__o2bb2ai_4
X_12316_ _05399_ _05400_ _05391_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__o21ai_1
X_13296_ _06323_ _06324_ VGND VGND VPWR VPWR _06325_ sky130_fd_sc_hd__or2_1
XFILLER_142_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12247_ _00970_ _02338_ _02500_ _02502_ _02503_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__a32o_1
XFILLER_122_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_805 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12178_ net1124 _06904_ net1105 net1099 _05263_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__o41a_1
XFILLER_96_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11129_ net203 _04211_ _04213_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_69_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08340_ _01421_ _01424_ _01422_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__a21oi_2
X_08271_ net989 net974 net2293 net1681 _01211_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__o2111ai_1
XPHY_EDGE_ROW_17_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07222_ _06945_ _06947_ _06988_ _06989_ VGND VGND VPWR VPWR _06993_ sky130_fd_sc_hd__a22oi_1
XFILLER_20_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07153_ net2013 net1285 VGND VGND VPWR VPWR _06924_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_113_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout103 _05612_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_8
XFILLER_87_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_4
Xfanout114 _05627_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_6
Xfanout147 net148 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_8
Xfanout136 _06622_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_8
X_07986_ _00937_ _01070_ _01069_ _00938_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__and4b_1
Xfanout158 _06620_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_86_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout169 _06580_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_47_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09725_ net814 _02551_ _02552_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__a21o_1
XFILLER_28_724 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09656_ _02674_ _02679_ _02708_ net3056 _02678_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__o2111ai_2
XTAP_TAPCELL_ROW_2_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_124_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08607_ _01690_ _01684_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__nand2_1
XFILLER_63_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09587_ net2953 _02265_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__nand2_1
XFILLER_42_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08538_ _01619_ _01621_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__nand2_1
X_08469_ _01491_ net405 net403 VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__nand3_1
XFILLER_11_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10500_ _03542_ _03533_ net651 VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__a21boi_4
XFILLER_137_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11480_ _04563_ _04564_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__nand2_1
XFILLER_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10431_ net652 _03516_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__nand2_1
XFILLER_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13150_ net1491 net2150 net480 VGND VGND VPWR VPWR _06180_ sky130_fd_sc_hd__mux2_2
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10362_ _03141_ _03146_ _03213_ _03216_ net3133 VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__o221a_4
XFILLER_128_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13081_ _05736_ _06110_ _05713_ VGND VGND VPWR VPWR _06111_ sky130_fd_sc_hd__nand3b_1
X_10293_ _03370_ _03372_ _03373_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__nand3_4
X_12101_ net791 _05186_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__nand2_1
Xfanout2303 net2304 VGND VGND VPWR VPWR net2303 sky130_fd_sc_hd__buf_1
Xfanout2314 net2320 VGND VGND VPWR VPWR net2314 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2325 net2326 VGND VGND VPWR VPWR net2325 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_53_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12032_ _05095_ _05098_ _05111_ net864 VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__o22a_1
Xfanout2336 net2337 VGND VGND VPWR VPWR net2336 sky130_fd_sc_hd__clkbuf_2
XFILLER_104_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1624 net1625 VGND VGND VPWR VPWR net1624 sky130_fd_sc_hd__buf_1
Xfanout2369 net2949 VGND VGND VPWR VPWR net2369 sky130_fd_sc_hd__clkbuf_4
Xfanout2347 net2348 VGND VGND VPWR VPWR net2347 sky130_fd_sc_hd__clkbuf_2
Xfanout2358 net2359 VGND VGND VPWR VPWR net2358 sky130_fd_sc_hd__buf_6
Xfanout1613 net1614 VGND VGND VPWR VPWR net1613 sky130_fd_sc_hd__clkbuf_2
Xfanout1602 net1603 VGND VGND VPWR VPWR net1602 sky130_fd_sc_hd__clkbuf_2
XFILLER_120_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout1657 net1658 VGND VGND VPWR VPWR net1657 sky130_fd_sc_hd__buf_2
Xfanout1646 net1647 VGND VGND VPWR VPWR net1646 sky130_fd_sc_hd__buf_1
Xfanout1635 net1636 VGND VGND VPWR VPWR net1635 sky130_fd_sc_hd__buf_4
Xfanout681 _01803_ VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout692 _01360_ VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__clkbuf_2
Xfanout670 _02726_ VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__clkbuf_2
X_13983_ net2802 VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__inv_2
Xfanout1679 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net1679 sky130_fd_sc_hd__buf_6
XFILLER_19_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12934_ _05978_ _05979_ net242 VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_109_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12865_ _05918_ _05919_ net239 VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__o21a_1
X_12796_ net1067 net2716 VGND VGND VPWR VPWR _05858_ sky130_fd_sc_hd__nand2_1
X_11816_ net2517 net1960 VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__nand2_1
XFILLER_14_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14535_ clknet_leaf_20_clk _00094_ _00357_ VGND VGND VPWR VPWR mul_res\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11747_ net1883 net2539 VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__nand2_1
XFILLER_119_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14466_ clknet_leaf_6_clk _00052_ _00288_ VGND VGND VPWR VPWR add_res\[24\] sky130_fd_sc_hd__dfrtp_1
X_11678_ _04759_ _04757_ _04758_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__nand3_2
XFILLER_128_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13417_ net531 _06445_ _06443_ VGND VGND VPWR VPWR _06446_ sky130_fd_sc_hd__o21ai_2
X_14397_ clknet_leaf_15_clk net3467 _00219_ VGND VGND VPWR VPWR adder_inst.man_a_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10629_ net877 net800 _03708_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__a21oi_2
X_13348_ _06362_ _06372_ net521 _06376_ VGND VGND VPWR VPWR _06377_ sky130_fd_sc_hd__a31oi_2
XFILLER_115_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13279_ net264 _06183_ _06306_ net286 VGND VGND VPWR VPWR _06308_ sky130_fd_sc_hd__o211ai_1
XFILLER_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2881 net2887 VGND VGND VPWR VPWR net2881 sky130_fd_sc_hd__buf_2
XFILLER_123_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07840_ _00746_ net829 _00923_ _00924_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__a22o_1
Xfanout2870 net2874 VGND VGND VPWR VPWR net2870 sky130_fd_sc_hd__buf_1
XFILLER_68_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2892 net2894 VGND VGND VPWR VPWR net2892 sky130_fd_sc_hd__clkbuf_2
XFILLER_110_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07771_ _00835_ _00849_ _00852_ _00853_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__o211ai_4
X_09510_ _02589_ _02591_ _02592_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09441_ _02519_ _02523_ _02450_ _02522_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__o211ai_4
XFILLER_91_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09372_ _02452_ _02455_ _02454_ VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__a21o_1
X_08323_ net1525 net2400 VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__nand2_1
XFILLER_20_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08254_ _01336_ _01337_ _01316_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07205_ _06967_ _06972_ _06974_ VGND VGND VPWR VPWR _06976_ sky130_fd_sc_hd__nand3_1
X_08185_ net473 _01231_ net475 VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__and3_1
XFILLER_134_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07136_ net2681 VGND VGND VPWR VPWR _06908_ sky130_fd_sc_hd__inv_2
XFILLER_106_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07969_ _00917_ _01042_ _01044_ _01051_ _01052_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__a32o_1
XFILLER_114_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09708_ _02668_ _02748_ net249 VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10980_ _04057_ _04060_ _04063_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__and3_1
XFILLER_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09639_ _01454_ _02252_ _02254_ _02251_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__o211a_1
XFILLER_130_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12650_ _05724_ _05728_ _05711_ VGND VGND VPWR VPWR _05730_ sky130_fd_sc_hd__o21a_1
XFILLER_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11601_ _04683_ _04685_ net1861 net2545 VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__o211a_1
XFILLER_90_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12581_ _06924_ _05528_ _05664_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__o21a_2
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14320_ clknet_leaf_17_clk net55 _00142_ VGND VGND VPWR VPWR adder_inst.i_b\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11532_ net418 _04617_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__nand2_1
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14251_ net2883 VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__inv_2
XFILLER_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_137_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11463_ _04502_ _04503_ _04543_ _04472_ VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__a31o_1
XFILLER_137_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14182_ net2857 VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__inv_2
X_13202_ _06229_ net3229 net292 _06230_ VGND VGND VPWR VPWR _06232_ sky130_fd_sc_hd__o211ai_4
X_10414_ _03498_ _03499_ _03493_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__nand3_4
XFILLER_124_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13133_ net790 _06161_ net302 _06162_ VGND VGND VPWR VPWR _06163_ sky130_fd_sc_hd__o31a_1
X_11394_ net867 _04142_ _04476_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__o21ai_2
XFILLER_140_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2100 net2102 VGND VGND VPWR VPWR net2100 sky130_fd_sc_hd__dlymetal6s2s_1
X_10345_ _03351_ net579 net578 VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__a21boi_4
XFILLER_124_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2111 net2112 VGND VGND VPWR VPWR net2111 sky130_fd_sc_hd__buf_1
Xfanout2122 net2124 VGND VGND VPWR VPWR net2122 sky130_fd_sc_hd__clkbuf_2
Xfanout2133 net2138 VGND VGND VPWR VPWR net2133 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout2144 net2146 VGND VGND VPWR VPWR net2144 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13064_ net1997 net1085 net731 net606 _06093_ VGND VGND VPWR VPWR _06094_ sky130_fd_sc_hd__o221ai_2
XFILLER_3_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10276_ net579 net576 _03350_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__nand3_2
Xfanout2166 net2167 VGND VGND VPWR VPWR net2166 sky130_fd_sc_hd__buf_1
Xfanout1421 net1426 VGND VGND VPWR VPWR net1421 sky130_fd_sc_hd__buf_2
Xfanout2155 net2156 VGND VGND VPWR VPWR net2155 sky130_fd_sc_hd__buf_2
Xfanout2177 net2179 VGND VGND VPWR VPWR net2177 sky130_fd_sc_hd__buf_4
Xfanout1432 net1433 VGND VGND VPWR VPWR net1432 sky130_fd_sc_hd__clkbuf_1
X_12015_ _05085_ _05088_ _05089_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__nand3_2
Xfanout1410 net1411 VGND VGND VPWR VPWR net1410 sky130_fd_sc_hd__clkbuf_1
Xfanout1443 net1444 VGND VGND VPWR VPWR net1443 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2188 net2189 VGND VGND VPWR VPWR net2188 sky130_fd_sc_hd__clkbuf_2
Xfanout1454 net1455 VGND VGND VPWR VPWR net1454 sky130_fd_sc_hd__clkbuf_2
XFILLER_65_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2199 net2203 VGND VGND VPWR VPWR net2199 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1465 net1467 VGND VGND VPWR VPWR net1465 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_38_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1476 net1477 VGND VGND VPWR VPWR net1476 sky130_fd_sc_hd__clkbuf_2
Xfanout1487 net1488 VGND VGND VPWR VPWR net1487 sky130_fd_sc_hd__clkbuf_1
Xfanout1498 net1499 VGND VGND VPWR VPWR net1498 sky130_fd_sc_hd__buf_4
X_13966_ net3435 mul_res\[30\] net2789 VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13897_ net131 _05593_ _05590_ VGND VGND VPWR VPWR _06849_ sky130_fd_sc_hd__a21oi_1
X_12917_ net2758 net1056 net2761 net737 VGND VGND VPWR VPWR _05965_ sky130_fd_sc_hd__o22a_1
X_12848_ net2779 net2702 net741 net2782 VGND VGND VPWR VPWR _05905_ sky130_fd_sc_hd__a22o_1
X_12779_ _05804_ _06920_ net1068 VGND VGND VPWR VPWR _05841_ sky130_fd_sc_hd__and3_1
X_14518_ clknet_leaf_1_clk multiplier_inst.man_final\[18\] _00340_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[18\] sky130_fd_sc_hd__dfrtp_1
X_14449_ clknet_leaf_0_clk _00065_ _00271_ VGND VGND VPWR VPWR add_res\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_80_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09990_ _02841_ net810 _02843_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__a21o_1
XFILLER_115_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08941_ net2121 net1714 VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__nand2_1
XFILLER_142_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08872_ net1443 net2381 VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07823_ _00904_ _00907_ _00908_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__nand3_2
XFILLER_111_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07754_ _00837_ _00838_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_121_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07685_ _00764_ _00766_ net986 VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__o21ai_2
X_09424_ _02505_ _02506_ _02496_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__a21oi_2
XFILLER_13_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09355_ _02330_ _02331_ _02437_ _02438_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__nand4_1
XFILLER_21_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09286_ _02023_ _02051_ _02052_ net590 _02022_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__a32oi_2
X_08306_ _01281_ _01282_ net408 _01391_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__nand4_4
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08237_ net1228 net1187 _01320_ net950 net997 VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__o32a_1
XFILLER_21_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08168_ net996 net977 net2238 net1685 _01249_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_132_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08099_ net2042 net2019 net1876 net1906 _01178_ VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__a41o_1
X_07119_ net2359 VGND VGND VPWR VPWR _06891_ sky130_fd_sc_hd__inv_2
XFILLER_134_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_132_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10130_ _03157_ net431 _03211_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__and3_1
XFILLER_121_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10061_ _03143_ _03142_ _03139_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__nand3_4
XFILLER_0_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13820_ net3395 net831 net722 VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__a21o_1
X_13751_ _06759_ _06264_ VGND VGND VPWR VPWR adder_inst.sum_raw\[20\] sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_48_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10963_ _03930_ _03933_ _03934_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__a21o_1
X_12702_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _05771_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_48_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13682_ net852 _06696_ _06697_ _06698_ VGND VGND VPWR VPWR _06699_ sky130_fd_sc_hd__a31o_1
X_10894_ net650 _03707_ _03715_ _03717_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__o2bb2ai_2
XTAP_TAPCELL_ROW_61_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12633_ net1275 net2001 VGND VGND VPWR VPWR _05713_ sky130_fd_sc_hd__nand2b_1
XFILLER_34_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12564_ _05644_ _05646_ VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__nand2_1
XFILLER_8_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14303_ clknet_leaf_12_clk net9 _00125_ VGND VGND VPWR VPWR adder_inst.i_a\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_11515_ _04566_ _04599_ _04600_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__nand3_2
X_14234_ net2910 VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__inv_2
Xwire164 _05435_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_1
X_12495_ _05412_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__xnor2_2
XFILLER_116_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11446_ _04336_ _04338_ _04524_ _04526_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__o211a_1
X_14165_ net2866 VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__inv_2
X_11377_ _04453_ _04457_ _04459_ _04460_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__o211ai_4
XFILLER_125_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13116_ net1116 net1097 net499 VGND VGND VPWR VPWR _06146_ sky130_fd_sc_hd__mux2_1
X_10328_ net1471 net2664 VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__nand2_1
X_14096_ net2821 VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__inv_2
XFILLER_124_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13047_ net505 net1924 VGND VGND VPWR VPWR _06077_ sky130_fd_sc_hd__nand2_8
XFILLER_79_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1240 net1241 VGND VGND VPWR VPWR net1240 sky130_fd_sc_hd__clkbuf_1
X_10259_ net807 net892 _03171_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__and3_1
Xfanout1262 net1263 VGND VGND VPWR VPWR net1262 sky130_fd_sc_hd__clkbuf_2
Xfanout1273 net1274 VGND VGND VPWR VPWR net1273 sky130_fd_sc_hd__buf_8
Xfanout1251 _06882_ VGND VGND VPWR VPWR net1251 sky130_fd_sc_hd__buf_2
XFILLER_39_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1295 adder_inst.exp_larger_r\[4\] VGND VGND VPWR VPWR net1295 sky130_fd_sc_hd__buf_1
XFILLER_93_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1284 adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR net1284 sky130_fd_sc_hd__clkbuf_1
XFILLER_66_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13949_ net3432 mul_res\[13\] net2797 VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__mux2_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07470_ net1044 net1010 net1420 net2219 _00490_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__o2111ai_2
XTAP_TAPCELL_ROW_17_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09140_ net1018 net917 net1498 net2499 _01423_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__o2111ai_4
Xrebuffer319 _01666_ VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__clkbuf_2
X_09071_ net466 _02156_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__nand2_1
Xrebuffer308 net3305 VGND VGND VPWR VPWR net3226 sky130_fd_sc_hd__buf_1
X_08022_ _01079_ net1931 net2017 VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__and3_1
XFILLER_135_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09973_ _03056_ _03058_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__nand2_4
X_08924_ _02009_ net1778 net2074 _02008_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__and4_1
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08855_ _01770_ _01771_ _01773_ _01939_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__o211ai_4
XFILLER_69_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07806_ net1270 net1215 net986 _00767_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__a2bb2oi_1
X_08786_ net1269 net1259 net953 net1188 net1252 VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__o32a_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07737_ net2159 net1626 VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__nand2_1
XFILLER_55_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07668_ _00745_ net829 _00749_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__and3_1
XFILLER_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07599_ _00681_ _00682_ _00601_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__nand3_1
X_09407_ _02489_ _02490_ _02491_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_101_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09338_ _02421_ _02415_ _02373_ _02422_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__o211ai_1
XFILLER_138_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09269_ _02350_ _02353_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__nand2_1
X_11300_ _04377_ _04382_ _04383_ VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__and3_1
XFILLER_138_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12280_ _05354_ _05365_ _05355_ VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__a21o_1
XFILLER_119_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11231_ net2448 net1855 VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__nand2_1
XFILLER_136_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11162_ net2450 net1914 VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__nand2_1
XFILLER_136_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10113_ _03198_ _03195_ _03197_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__o21ai_2
XFILLER_121_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11093_ _03910_ _03944_ _03942_ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__a21oi_1
X_10044_ _03128_ _03122_ _03127_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__nand3_1
X_13803_ net3415 net727 VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__and2_1
XFILLER_35_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11995_ net2571 net1989 VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__nand2_1
X_13734_ _06301_ _06299_ VGND VGND VPWR VPWR _06744_ sky130_fd_sc_hd__nand2_1
XFILLER_71_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10946_ _04027_ _04028_ net871 VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__o21a_1
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13665_ _06675_ _06676_ _06682_ _06421_ VGND VGND VPWR VPWR _06683_ sky130_fd_sc_hd__o31a_1
X_10877_ _03961_ _03962_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12616_ _05691_ _05697_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__or2_1
XFILLER_129_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13596_ net155 net161 _06240_ VGND VGND VPWR VPWR _06624_ sky130_fd_sc_hd__o21ai_1
X_12547_ _07018_ _05517_ VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__nand2_1
XFILLER_61_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12478_ net140 net314 _05563_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__a21oi_2
XANTENNA_3 _06072_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14217_ net2855 VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11429_ _04060_ _04061_ _04062_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__a21o_1
XFILLER_125_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14148_ net2903 VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14079_ net2825 VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__inv_2
Xfanout1070 net1071 VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__clkbuf_2
Xfanout1081 net1082 VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__clkbuf_2
X_08640_ _01622_ _01623_ _01722_ _01719_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__a31o_4
Xfanout1092 _06909_ VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__buf_1
XFILLER_94_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer26 _06251_ VGND VGND VPWR VPWR net2944 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_66_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer15 _05313_ VGND VGND VPWR VPWR net2933 sky130_fd_sc_hd__dlygate4sd1_1
X_08571_ _01653_ _01645_ _01654_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__nand3_2
XFILLER_82_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer37 _02850_ VGND VGND VPWR VPWR net2955 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer48 _05210_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_2
Xrebuffer59 net350 VGND VGND VPWR VPWR net2977 sky130_fd_sc_hd__buf_1
XFILLER_35_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07522_ _00605_ _00606_ _00604_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__o21ai_1
XFILLER_81_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07453_ net1037 net1027 _00536_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07384_ _00466_ _00468_ _00467_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__o21bai_1
X_09123_ net408 net407 _01390_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__nand3_1
XFILLER_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer116 _06966_ VGND VGND VPWR VPWR net3034 sky130_fd_sc_hd__buf_1
Xrebuffer138 _02738_ VGND VGND VPWR VPWR net3056 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer127 net3044 VGND VGND VPWR VPWR net3045 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer105 _03328_ VGND VGND VPWR VPWR net3023 sky130_fd_sc_hd__clkbuf_2
XFILLER_136_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_116_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09054_ net903 _02109_ _02112_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__a21o_1
XFILLER_135_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold520 _00016_ VGND VGND VPWR VPWR net3438 sky130_fd_sc_hd__dlygate4sd3_1
X_08005_ net2041 net1928 net1947 net2018 VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__a22o_1
Xhold531 _00025_ VGND VGND VPWR VPWR net3449 sky130_fd_sc_hd__dlygate4sd3_1
Xhold542 mul_res\[7\] VGND VGND VPWR VPWR net3460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold553 _00014_ VGND VGND VPWR VPWR net3471 sky130_fd_sc_hd__dlygate4sd3_1
Xhold575 _00030_ VGND VGND VPWR VPWR net3493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold564 _00034_ VGND VGND VPWR VPWR net3482 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09956_ _03040_ _03039_ _03036_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__nand3_4
XFILLER_112_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08907_ _01802_ _01805_ _01986_ _01990_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_66_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09887_ _02945_ _02943_ _02946_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__nand3_2
X_08838_ _01919_ _01921_ _01754_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__a21o_1
XFILLER_57_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08769_ _01852_ net907 _01848_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__a21o_1
X_10800_ _03681_ _03680_ _03419_ _03666_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__o2bb2ai_4
X_11780_ _04861_ net629 _04857_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__a21oi_2
XFILLER_26_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10731_ _03556_ net386 net429 VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__a21oi_1
X_13450_ net275 _06169_ VGND VGND VPWR VPWR _06479_ sky130_fd_sc_hd__nand2_2
XFILLER_41_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12401_ _05482_ _05484_ VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__xnor2_1
X_10662_ _03744_ _03745_ VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__nand2_2
X_13381_ _06407_ _06408_ _06397_ VGND VGND VPWR VPWR _06410_ sky130_fd_sc_hd__nand3_2
X_10593_ _03661_ _03671_ _03676_ _03677_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__o211a_4
XFILLER_21_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12332_ _02520_ _02523_ _05416_ _05417_ VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__a22oi_1
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12263_ _05329_ _05330_ _05348_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__nand3_2
XFILLER_107_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14002_ net2837 VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__inv_2
X_11214_ _04292_ _04295_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__nand2_2
XFILLER_122_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12194_ _05256_ _05279_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__nor2_2
Xoutput73 net73 VGND VGND VPWR VPWR o_res[14] sky130_fd_sc_hd__buf_2
Xoutput84 net84 VGND VGND VPWR VPWR o_res[24] sky130_fd_sc_hd__buf_2
X_11145_ _04219_ _04230_ _04228_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__nand3b_4
Xoutput95 net95 VGND VGND VPWR VPWR o_res[5] sky130_fd_sc_hd__buf_2
XFILLER_1_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11076_ _04158_ net639 VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__and2_4
X_10027_ _03107_ _03110_ _03111_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__nand3_4
XFILLER_56_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11978_ _04973_ _04974_ _04965_ _04967_ VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__o211ai_2
XFILLER_17_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13717_ _06328_ _06729_ VGND VGND VPWR VPWR adder_inst.sum_raw\[16\] sky130_fd_sc_hd__xnor2_1
X_10929_ net2355 net1934 VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__nand2_1
X_13648_ _06579_ _06668_ VGND VGND VPWR VPWR adder_inst.sum_raw\[8\] sky130_fd_sc_hd__xnor2_4
XFILLER_32_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13579_ _06597_ _06603_ _06280_ VGND VGND VPWR VPWR _06608_ sky130_fd_sc_hd__and3_4
XFILLER_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout318 net319 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__buf_1
XFILLER_113_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout307 net308 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_4
Xfanout329 _02213_ VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__buf_4
X_09810_ _02645_ _02646_ _02651_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__a21o_1
XFILLER_141_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09741_ _02822_ _02823_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_87_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09672_ _02751_ _02754_ _02755_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__nand3_1
XFILLER_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08623_ _01175_ _01176_ _01188_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__nand3_4
Xclkbuf_leaf_19_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08554_ net1590 net2305 _01637_ _01639_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__a22o_1
X_07505_ _00589_ _00590_ _00516_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__a21o_1
X_08485_ _01569_ _01570_ VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__nand2_1
XFILLER_23_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_99_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07436_ _00478_ _00479_ net1250 net1246 VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_50_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_828 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07367_ net1043 net1038 _00452_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__o21ai_1
X_09106_ net693 net692 _01371_ _01372_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07298_ net2079 net1536 VGND VGND VPWR VPWR _07069_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_98_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09037_ _02117_ _02119_ net3022 VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__o21ai_4
Xfanout2518 net2519 VGND VGND VPWR VPWR net2518 sky130_fd_sc_hd__clkbuf_1
XFILLER_2_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2507 net2523 VGND VGND VPWR VPWR net2507 sky130_fd_sc_hd__buf_4
Xfanout1806 net1808 VGND VGND VPWR VPWR net1806 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout2529 net2530 VGND VGND VPWR VPWR net2529 sky130_fd_sc_hd__buf_1
XFILLER_131_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout841 net842 VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__buf_1
Xfanout830 _00443_ VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__buf_1
XFILLER_89_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout852 net857 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__clkbuf_2
Xfanout1839 net1840 VGND VGND VPWR VPWR net1839 sky130_fd_sc_hd__buf_6
Xfanout1828 net1829 VGND VGND VPWR VPWR net1828 sky130_fd_sc_hd__clkbuf_2
Xfanout1817 net1818 VGND VGND VPWR VPWR net1817 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_129_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09939_ _02795_ _02994_ _02993_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__o21ai_1
Xfanout874 _03918_ VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__clkbuf_1
Xfanout885 _03415_ VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__buf_1
Xfanout863 _05027_ VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__clkbuf_2
X_12950_ _05992_ _05993_ net242 VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_51_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout896 _02952_ VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_142_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12881_ net2782 net2750 net2741 VGND VGND VPWR VPWR _05933_ sky130_fd_sc_hd__or3_1
XFILLER_73_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11901_ _04893_ _04986_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__nand2_2
X_11832_ net1915 net2573 VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__nand2_1
X_14551_ clknet_leaf_5_clk _00081_ _00373_ VGND VGND VPWR VPWR mul_res\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11763_ _04848_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__inv_2
X_14482_ clknet_leaf_8_clk adder_inst.is_inf_a _00304_ VGND VGND VPWR VPWR adder_inst.is_inf_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_13502_ net777 net544 net1936 VGND VGND VPWR VPWR _06531_ sky130_fd_sc_hd__a21o_1
XFILLER_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11694_ _04609_ _04634_ _04635_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__nand3_1
X_10714_ _03742_ _03794_ _03582_ _03796_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_24_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13433_ net2522 net516 _06460_ VGND VGND VPWR VPWR _06462_ sky130_fd_sc_hd__o21ai_1
X_10645_ _03706_ _03722_ _03727_ _03728_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_139_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13364_ _06390_ _06392_ VGND VGND VPWR VPWR _06393_ sky130_fd_sc_hd__and2b_1
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12315_ _05399_ _05400_ VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__nor2_1
Xrebuffer6 _03042_ VGND VGND VPWR VPWR net2924 sky130_fd_sc_hd__buf_6
X_10576_ _03379_ net3086 net389 net574 VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__nand4_4
XFILLER_142_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13295_ net2224 net490 VGND VGND VPWR VPWR _06324_ sky130_fd_sc_hd__nor2_1
X_12246_ _00970_ net675 _02500_ _02502_ _02503_ VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__a32oi_4
XFILLER_69_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12177_ net1940 net2681 VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__nand2_1
X_11128_ net203 _04211_ _04213_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__a21o_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11059_ net1550 net2641 net2666 net1523 VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_69_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08270_ net2293 net1680 _01211_ _01212_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__a22o_1
XFILLER_32_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07221_ _06990_ _06991_ VGND VGND VPWR VPWR _06992_ sky130_fd_sc_hd__nand2b_1
X_07152_ net2854 VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__inv_2
XFILLER_9_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_8_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
Xfanout104 net105 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_8
XFILLER_113_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout115 _05577_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_8
Xfanout126 net127 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_6
XFILLER_113_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout137 _06622_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_93_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07985_ _01069_ _01070_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__nand2_1
Xfanout148 _05523_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_6
XFILLER_101_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout159 _06620_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_1
X_09724_ net814 _02551_ _02553_ VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__a21o_1
XFILLER_47_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09655_ _02680_ _02739_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08606_ net1040 net954 _01685_ _01689_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_124_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09586_ _02623_ _02626_ _02627_ net588 _02652_ VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__a32oi_4
X_08537_ net402 _01618_ _01620_ _01540_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__o2bb2ai_4
X_08468_ _01491_ _01548_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__nand2_1
XFILLER_50_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07419_ _00486_ _00503_ net478 VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__o21ai_1
XFILLER_50_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08399_ net713 net689 _01480_ _01481_ VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__a22o_1
XFILLER_11_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10430_ _03511_ _03513_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__nand2_2
XFILLER_136_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10361_ _03147_ net324 _03213_ _03216_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_128_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13080_ _05715_ _06093_ VGND VGND VPWR VPWR _06110_ sky130_fd_sc_hd__nand2_1
X_10292_ _03370_ _03373_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__nand2_4
X_12100_ net1157 net1096 _05174_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__o21ai_2
Xfanout2304 net2305 VGND VGND VPWR VPWR net2304 sky130_fd_sc_hd__clkbuf_4
Xfanout2315 net2317 VGND VGND VPWR VPWR net2315 sky130_fd_sc_hd__clkbuf_2
Xfanout2326 net2327 VGND VGND VPWR VPWR net2326 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_53_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12031_ _05112_ _05114_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__nor2_1
Xfanout2337 net2338 VGND VGND VPWR VPWR net2337 sky130_fd_sc_hd__clkbuf_2
Xfanout2348 net2349 VGND VGND VPWR VPWR net2348 sky130_fd_sc_hd__clkbuf_2
Xfanout2359 net2360 VGND VGND VPWR VPWR net2359 sky130_fd_sc_hd__buf_2
Xfanout1614 net1615 VGND VGND VPWR VPWR net1614 sky130_fd_sc_hd__clkbuf_2
Xfanout1603 net1607 VGND VGND VPWR VPWR net1603 sky130_fd_sc_hd__buf_4
Xfanout1625 net1628 VGND VGND VPWR VPWR net1625 sky130_fd_sc_hd__clkbuf_2
Xfanout1658 net1659 VGND VGND VPWR VPWR net1658 sky130_fd_sc_hd__buf_1
Xfanout660 _03074_ VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__buf_6
Xfanout1636 net1637 VGND VGND VPWR VPWR net1636 sky130_fd_sc_hd__clkbuf_2
Xfanout1647 net1648 VGND VGND VPWR VPWR net1647 sky130_fd_sc_hd__buf_1
XFILLER_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout682 net683 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__clkbuf_2
Xfanout693 _01359_ VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__clkbuf_2
Xfanout671 _02726_ VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__clkbuf_1
X_13982_ net2804 VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__inv_2
Xfanout1669 net1675 VGND VGND VPWR VPWR net1669 sky130_fd_sc_hd__clkbuf_2
X_12933_ net2692 net2748 net2753 net758 VGND VGND VPWR VPWR _05979_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_109_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12864_ net2689 net2769 net754 net2771 VGND VGND VPWR VPWR _05919_ sky130_fd_sc_hd__a22o_1
XFILLER_61_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12795_ net2714 _05844_ _05855_ _05856_ VGND VGND VPWR VPWR _05857_ sky130_fd_sc_hd__or4_1
X_11815_ net2483 net1986 VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__nand2_1
X_14534_ clknet_leaf_20_clk _00083_ _00356_ VGND VGND VPWR VPWR mul_res\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_64_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11746_ net1918 net2540 VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__nand2_1
XFILLER_14_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14465_ clknet_leaf_7_clk _00051_ _00287_ VGND VGND VPWR VPWR add_res\[23\] sky130_fd_sc_hd__dfrtp_1
X_11677_ _04724_ _04730_ _04756_ VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__o21ai_2
XFILLER_139_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13416_ net222 _06207_ _06444_ VGND VGND VPWR VPWR _06445_ sky130_fd_sc_hd__o21ai_4
X_14396_ clknet_leaf_15_clk net3408 _00218_ VGND VGND VPWR VPWR adder_inst.man_a_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_10628_ _03710_ _03711_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__nand2_1
XFILLER_127_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13347_ net772 net539 net1632 VGND VGND VPWR VPWR _06376_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10559_ _03621_ _03637_ _03641_ _03642_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__o211ai_1
X_13278_ net785 _06180_ net414 net3169 net312 VGND VGND VPWR VPWR _06307_ sky130_fd_sc_hd__o2111ai_4
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12229_ _05314_ _03893_ _04242_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__nor3_4
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout2882 net2886 VGND VGND VPWR VPWR net2882 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2871 net2873 VGND VGND VPWR VPWR net2871 sky130_fd_sc_hd__buf_2
Xfanout2860 net2861 VGND VGND VPWR VPWR net2860 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_68_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout2893 net2894 VGND VGND VPWR VPWR net2893 sky130_fd_sc_hd__clkbuf_2
XFILLER_111_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07770_ _00854_ _00855_ _00851_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__nand3_1
XFILLER_96_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09440_ _02450_ _02524_ _02525_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__nand3b_4
XFILLER_64_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09371_ _02452_ _02455_ _02454_ VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__a21oi_2
X_08322_ net1556 net2402 net2432 net1527 VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__a22o_1
XFILLER_138_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08253_ net595 _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__nand2_1
X_07204_ _06971_ _06973_ _06967_ VGND VGND VPWR VPWR _06975_ sky130_fd_sc_hd__o21bai_1
X_08184_ _01231_ _01265_ _01261_ _01266_ VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__o2bb2ai_4
XFILLER_20_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07135_ net2657 VGND VGND VPWR VPWR _06907_ sky130_fd_sc_hd__inv_2
XFILLER_133_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_126_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07968_ _01044_ _00917_ _01042_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__a21o_1
XFILLER_102_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09707_ _02791_ _02792_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__nand2_2
XFILLER_28_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07899_ _00984_ _00981_ VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__nor2_1
XFILLER_82_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09638_ net1405 net2589 _02251_ _02253_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__a22o_1
X_09569_ net461 net588 _02653_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__a21o_1
XFILLER_43_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12580_ _05662_ _05661_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__nor2_1
XFILLER_70_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11600_ net1885 net2519 net1914 net2481 VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__a22o_1
XFILLER_142_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11531_ _04580_ _04582_ net417 VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_137_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14250_ net2855 VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__inv_2
X_11462_ _04502_ _04503_ _04541_ _04542_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__nand4_2
X_14181_ net2856 VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__inv_2
X_13201_ net273 _06229_ _06230_ VGND VGND VPWR VPWR _06231_ sky130_fd_sc_hd__o21ai_2
X_10413_ net806 net890 net2249 net1925 VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__nand4_4
X_11393_ _04477_ _04478_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__nand2_1
XFILLER_125_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13132_ net1542 _06157_ _06158_ VGND VGND VPWR VPWR _06162_ sky130_fd_sc_hd__nand3_1
X_10344_ net3039 _03355_ net3150 _03350_ net578 VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__a32oi_4
XPHY_EDGE_ROW_36_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout2101 net2102 VGND VGND VPWR VPWR net2101 sky130_fd_sc_hd__clkbuf_1
Xfanout2134 net2138 VGND VGND VPWR VPWR net2134 sky130_fd_sc_hd__clkbuf_1
Xfanout2123 net2124 VGND VGND VPWR VPWR net2123 sky130_fd_sc_hd__buf_1
Xfanout2112 net2113 VGND VGND VPWR VPWR net2112 sky130_fd_sc_hd__clkbuf_1
X_13063_ _06061_ _06054_ _06065_ net3203 VGND VGND VPWR VPWR _06093_ sky130_fd_sc_hd__o22ai_2
XFILLER_3_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10275_ net579 net576 _03350_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__and3_1
Xfanout1400 net1401 VGND VGND VPWR VPWR net1400 sky130_fd_sc_hd__buf_1
Xfanout2167 net2951 VGND VGND VPWR VPWR net2167 sky130_fd_sc_hd__clkbuf_2
Xfanout1422 net1425 VGND VGND VPWR VPWR net1422 sky130_fd_sc_hd__clkbuf_2
Xfanout2156 net2157 VGND VGND VPWR VPWR net2156 sky130_fd_sc_hd__buf_1
Xfanout2145 net2146 VGND VGND VPWR VPWR net2145 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12014_ _05099_ _05097_ _05098_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__a21oi_1
Xfanout1411 net1412 VGND VGND VPWR VPWR net1411 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_120_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout1444 net1445 VGND VGND VPWR VPWR net1444 sky130_fd_sc_hd__clkbuf_1
Xfanout2189 net2190 VGND VGND VPWR VPWR net2189 sky130_fd_sc_hd__clkbuf_2
Xfanout1455 net1456 VGND VGND VPWR VPWR net1455 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout2178 net2179 VGND VGND VPWR VPWR net2178 sky130_fd_sc_hd__buf_1
Xfanout1466 net1467 VGND VGND VPWR VPWR net1466 sky130_fd_sc_hd__buf_1
Xfanout1433 net1434 VGND VGND VPWR VPWR net1433 sky130_fd_sc_hd__clkbuf_2
Xfanout1488 net1489 VGND VGND VPWR VPWR net1488 sky130_fd_sc_hd__clkbuf_2
Xfanout490 net497 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__buf_1
Xfanout1477 net1492 VGND VGND VPWR VPWR net1477 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1499 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net1499 sky130_fd_sc_hd__buf_6
X_13965_ net3418 mul_res\[29\] net2790 VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__mux2_1
XFILLER_65_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13896_ _05586_ _05595_ net115 VGND VGND VPWR VPWR _06848_ sky130_fd_sc_hd__or3_4
X_12916_ _06914_ net1063 net1057 _05963_ net1068 VGND VGND VPWR VPWR _05964_ sky130_fd_sc_hd__o2111ai_1
XFILLER_80_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12847_ net2783 net1067 net1061 _05845_ VGND VGND VPWR VPWR _05904_ sky130_fd_sc_hd__a31o_1
X_12778_ _05839_ _05837_ net2700 VGND VGND VPWR VPWR _05840_ sky130_fd_sc_hd__a21oi_2
X_14517_ clknet_leaf_4_clk multiplier_inst.man_final\[17\] _00339_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[17\] sky130_fd_sc_hd__dfrtp_1
X_11729_ net2450 net1986 VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__nand2_1
X_14448_ clknet_leaf_4_clk _00064_ _00270_ VGND VGND VPWR VPWR add_res\[6\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_54_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14379_ clknet_leaf_11_clk net3349 _00201_ VGND VGND VPWR VPWR adder_inst.man_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_6_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08940_ net2096 net1749 VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__nand2_1
X_08871_ net1416 net2411 VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout2690 net2691 VGND VGND VPWR VPWR net2690 sky130_fd_sc_hd__buf_1
X_07822_ net599 _00730_ _00753_ _00754_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_111_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07753_ net1561 net2214 net2244 net1529 VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__a22oi_4
X_07684_ _00767_ net1687 net2076 net986 VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__nand4_2
XFILLER_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09423_ _02504_ _02507_ VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__or2_1
XFILLER_80_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09354_ _02437_ _02438_ _02332_ VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__a21o_1
XFILLER_12_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08305_ net407 _01385_ _01387_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__nand3_1
X_09285_ _02366_ net353 _02336_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__a21o_1
XFILLER_119_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08236_ net1226 net1190 _01320_ net950 net997 VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__o32ai_4
XTAP_TAPCELL_ROW_31_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08167_ _01247_ _01249_ net1228 net1214 VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07118_ net1736 VGND VGND VPWR VPWR _06890_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_132_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08098_ _01179_ net942 _01178_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__o21ai_1
XFILLER_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10060_ _03143_ _03139_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__nand2_4
XFILLER_102_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13750_ net763 _06758_ _06752_ VGND VGND VPWR VPWR _06759_ sky130_fd_sc_hd__o21ai_2
XFILLER_55_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10962_ net1163 net1192 _03744_ _03931_ _03930_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__o221ai_4
X_12701_ _05760_ _05769_ _05770_ VGND VGND VPWR VPWR adder_inst.is_inf_b sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_48_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13681_ _06584_ net160 net154 _06692_ net760 VGND VGND VPWR VPWR _06698_ sky130_fd_sc_hd__o311a_1
X_10893_ _03719_ _03720_ net650 _03707_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_61_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12632_ net1275 net2001 VGND VGND VPWR VPWR _05712_ sky130_fd_sc_hd__and2b_1
X_12563_ _05643_ _05645_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__nor2_4
XFILLER_129_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12494_ _05431_ _05579_ _05433_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__a21boi_2
X_11514_ _04597_ _04596_ _04568_ VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__nand3_4
X_14302_ clknet_leaf_13_clk net8 _00124_ VGND VGND VPWR VPWR adder_inst.i_a\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_14233_ net2908 VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__inv_2
X_11445_ _04336_ _04338_ _04526_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__o21ai_1
Xwire165 _05316_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_8
XFILLER_124_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14164_ net2866 VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__inv_2
X_11376_ _04427_ _04429_ net1677 net2647 VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__nand4_1
XFILLER_124_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14095_ net2858 VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_59_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13115_ _06142_ net789 net302 _06143_ net283 VGND VGND VPWR VPWR _06145_ sky130_fd_sc_hd__o311a_1
X_10327_ _03393_ _03405_ _03409_ _03410_ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__o211ai_4
X_13046_ net1089 net1273 net602 net3297 net2672 VGND VGND VPWR VPWR _06076_ sky130_fd_sc_hd__a221o_1
X_10258_ _03102_ _03342_ _03337_ _03343_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__o211ai_1
XFILLER_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout1241 net1244 VGND VGND VPWR VPWR net1241 sky130_fd_sc_hd__buf_1
Xfanout1230 _06884_ VGND VGND VPWR VPWR net1230 sky130_fd_sc_hd__buf_2
Xfanout1252 net1254 VGND VGND VPWR VPWR net1252 sky130_fd_sc_hd__clkbuf_2
Xfanout1263 _06880_ VGND VGND VPWR VPWR net1263 sky130_fd_sc_hd__buf_2
Xfanout1274 adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR net1274 sky130_fd_sc_hd__buf_6
X_10189_ net2288 net1843 VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__nand2_1
XFILLER_120_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1296 net1298 VGND VGND VPWR VPWR net1296 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout1285 adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR net1285 sky130_fd_sc_hd__clkbuf_2
X_13948_ net3422 mul_res\[12\] net2795 VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__mux2_1
XFILLER_81_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13879_ _06835_ _06836_ VGND VGND VPWR VPWR multiplier_inst.man_final\[5\] sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_17_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_62_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer309 _06269_ VGND VGND VPWR VPWR net3227 sky130_fd_sc_hd__dlygate4sd1_1
X_09070_ _02147_ _02152_ _02155_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__o21ai_2
X_08021_ _01102_ _01104_ _01092_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__o21ai_1
XFILLER_116_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09972_ net893 net1842 net2260 net895 VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__nand4_4
XFILLER_103_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08923_ _00942_ _02007_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__nand2_1
XFILLER_97_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08854_ _01773_ _01774_ _01939_ _01938_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__a22o_4
XFILLER_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07805_ _00888_ _00884_ _00887_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__o21ai_2
X_08785_ _01869_ _01870_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__nand2_4
XFILLER_85_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07736_ _00759_ _00778_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__xnor2_2
XFILLER_55_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07667_ _00742_ _00743_ _00750_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__and3_1
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07598_ _00680_ _00683_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__nor2_1
X_09406_ _02393_ _02394_ _02417_ _02416_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_101_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_80_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09337_ _02421_ _02415_ _02373_ _02422_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__o211a_1
XFILLER_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09268_ _02351_ _02352_ _02346_ _02349_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__o211ai_2
XFILLER_21_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_134_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08219_ _01300_ _01302_ _01299_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__a21oi_1
XFILLER_126_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09199_ net332 net331 _01549_ _01551_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_105_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11230_ _04298_ _04306_ _04314_ net637 VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_136_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11161_ net2419 net1869 VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__nand2_1
XFILLER_121_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10112_ net1408 net2662 VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__nand2_1
XFILLER_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11092_ _03842_ _04144_ _04145_ _04149_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__or4_1
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10043_ _03125_ _03126_ _03123_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__a21oi_2
X_13802_ net3472 net727 VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__and2_1
XFILLER_75_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11994_ _05077_ _05078_ VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_119_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13733_ _06743_ _06600_ VGND VGND VPWR VPWR adder_inst.sum_raw\[18\] sky130_fd_sc_hd__xnor2_2
X_10945_ net2355 net2391 net1868 net1899 VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__nand4_2
XFILLER_32_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13664_ net443 _06418_ _06420_ VGND VGND VPWR VPWR _06682_ sky130_fd_sc_hd__o21a_1
X_10876_ net987 net931 _03697_ _03696_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_14_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12615_ _05688_ _05689_ _05653_ _05660_ _05659_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_14_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13595_ _06076_ _06235_ _06237_ VGND VGND VPWR VPWR _06623_ sky130_fd_sc_hd__and3_1
X_12546_ _05621_ _05515_ net126 VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__a21o_1
XFILLER_129_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12477_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_128_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14216_ net2860 VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__inv_2
XANTENNA_4 _06089_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11428_ _04060_ _04061_ net1192 net1147 VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__o2bb2ai_1
X_14147_ net2901 VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__inv_2
XFILLER_99_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11359_ _04444_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__inv_2
XFILLER_140_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14078_ net2826 VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__inv_2
XFILLER_79_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13029_ _06057_ net706 VGND VGND VPWR VPWR _06059_ sky130_fd_sc_hd__nand2_8
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout1060 _06921_ VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__clkbuf_2
Xfanout1071 _06919_ VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__buf_1
Xfanout1082 _06916_ VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__buf_1
XFILLER_94_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08570_ net1009 net978 net2212 net1685 _01651_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__o2111ai_4
Xrebuffer27 _02892_ VGND VGND VPWR VPWR net2945 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer16 _05313_ VGND VGND VPWR VPWR net2934 sky130_fd_sc_hd__dlygate4sd1_1
Xfanout1093 net1095 VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_137_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07521_ _00602_ _00603_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__nand2_1
Xrebuffer49 _03682_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_2
Xrebuffer38 adder_inst.man_a_r\[8\] VGND VGND VPWR VPWR net2956 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_35_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07452_ _00533_ _00534_ VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_33_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07383_ net2075 net1597 _00467_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__a21oi_1
X_09122_ net400 _02206_ _02161_ _02163_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__o2bb2ai_1
Xrebuffer106 _02092_ VGND VGND VPWR VPWR net3024 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer128 _03821_ VGND VGND VPWR VPWR net3046 sky130_fd_sc_hd__clkbuf_1
Xrebuffer117 _03440_ VGND VGND VPWR VPWR net3035 sky130_fd_sc_hd__buf_6
XFILLER_135_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09053_ net992 net949 _02137_ _02135_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__o22a_2
Xrebuffer139 net3060 VGND VGND VPWR VPWR net3057 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_135_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold510 add_res\[23\] VGND VGND VPWR VPWR net3428 sky130_fd_sc_hd__dlygate4sd3_1
X_08004_ net2040 net1930 net1951 net2037 VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__a22oi_1
Xhold543 _00029_ VGND VGND VPWR VPWR net3461 sky130_fd_sc_hd__dlygate4sd3_1
Xhold532 multiplier_inst.man_final_r\[5\] VGND VGND VPWR VPWR net3450 sky130_fd_sc_hd__dlygate4sd3_1
Xhold554 multiplier_inst.man_final_r\[16\] VGND VGND VPWR VPWR net3472 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold521 adder_inst.i_a\[13\] VGND VGND VPWR VPWR net3439 sky130_fd_sc_hd__dlygate4sd3_1
Xhold565 mul_res\[1\] VGND VGND VPWR VPWR net3483 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold576 multiplier_inst.exp_final_r\[6\] VGND VGND VPWR VPWR net3494 sky130_fd_sc_hd__dlygate4sd3_1
X_09955_ _03039_ _03040_ _03036_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__and3_2
XFILLER_100_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08906_ _01989_ _01970_ _01988_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__nand3_4
X_09886_ _02970_ _02971_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__nand2_2
XFILLER_106_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08837_ _01921_ _01919_ _01755_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__a21o_1
XFILLER_73_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08768_ net1232 net1212 _01852_ net907 VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__o211ai_2
XFILLER_45_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07719_ _00795_ _00804_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__nand2_1
XFILLER_122_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08699_ _01592_ net2384 net1501 VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_0_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10730_ _03814_ net429 VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__nand2_1
X_10661_ net1791 net2415 net1820 net2387 VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__a22oi_1
XFILLER_41_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12400_ _05482_ _05484_ VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__nand2_1
X_13380_ _06408_ _06407_ _06397_ VGND VGND VPWR VPWR _06409_ sky130_fd_sc_hd__a21oi_4
X_10592_ _03661_ _03671_ _03677_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__o21ai_1
X_12331_ _05399_ _05400_ _05391_ _05392_ VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__o211ai_1
XFILLER_126_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12262_ _05338_ net382 _05342_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__nand3_1
XFILLER_31_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14001_ net2841 VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__inv_2
X_11213_ _04295_ _04297_ _04292_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__a21o_1
XFILLER_122_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_56_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12193_ _05257_ _05275_ _05277_ _05243_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__nand4_4
Xoutput74 net74 VGND VGND VPWR VPWR o_res[15] sky130_fd_sc_hd__buf_2
Xoutput85 net85 VGND VGND VPWR VPWR o_res[25] sky130_fd_sc_hd__buf_2
X_11144_ _04221_ _04224_ _04226_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__nand3_4
Xoutput96 net96 VGND VGND VPWR VPWR o_res[6] sky130_fd_sc_hd__buf_2
XFILLER_122_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11075_ _04143_ _04146_ _04147_ _04156_ _04157_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__o311a_4
X_10026_ _03108_ _03109_ _03106_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__a21oi_1
XFILLER_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11977_ _04965_ _04967_ _04973_ _04974_ VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13716_ net761 _06727_ _06728_ _06724_ VGND VGND VPWR VPWR _06729_ sky130_fd_sc_hd__o31ai_2
X_10928_ net2353 net1934 VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__and2_1
XFILLER_44_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13647_ _06664_ _06667_ net857 VGND VGND VPWR VPWR _06668_ sky130_fd_sc_hd__mux2_4
XFILLER_72_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10859_ _03939_ _03938_ _03937_ _03911_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__a31oi_4
X_13578_ _06257_ _06606_ _06250_ VGND VGND VPWR VPWR _06607_ sky130_fd_sc_hd__and3b_1
XFILLER_9_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12529_ _05479_ _05614_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__xor2_2
XFILLER_117_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout319 net320 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__clkbuf_1
XFILLER_98_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout308 _06120_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_6
XFILLER_141_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09740_ _02824_ _02825_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__nand2_1
.ends
