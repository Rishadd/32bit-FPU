* NGSPICE file created from ALU.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_4 abstract view
.subckt sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_4 abstract view
.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_4 abstract view
.subckt sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_4 abstract view
.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_4 abstract view
.subckt sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41ai_1 abstract view
.subckt sky130_fd_sc_hd__o41ai_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_2 abstract view
.subckt sky130_fd_sc_hd__nor4b_2 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_2 abstract view
.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

.subckt ALU VGND VPWR clk i_a[0] i_a[10] i_a[11] i_a[12] i_a[13] i_a[14] i_a[15] i_a[16]
+ i_a[17] i_a[18] i_a[19] i_a[1] i_a[20] i_a[21] i_a[22] i_a[23] i_a[24] i_a[25] i_a[26]
+ i_a[27] i_a[28] i_a[29] i_a[2] i_a[30] i_a[31] i_a[3] i_a[4] i_a[5] i_a[6] i_a[7]
+ i_a[8] i_a[9] i_b[0] i_b[10] i_b[11] i_b[12] i_b[13] i_b[14] i_b[15] i_b[16] i_b[17]
+ i_b[18] i_b[19] i_b[1] i_b[20] i_b[21] i_b[22] i_b[23] i_b[24] i_b[25] i_b[26] i_b[27]
+ i_b[28] i_b[29] i_b[2] i_b[30] i_b[31] i_b[3] i_b[4] i_b[5] i_b[6] i_b[7] i_b[8]
+ i_b[9] i_vld o_res[0] o_res[10] o_res[11] o_res[12] o_res[13] o_res[14] o_res[15]
+ o_res[16] o_res[17] o_res[18] o_res[19] o_res[1] o_res[20] o_res[21] o_res[22] o_res[23]
+ o_res[24] o_res[25] o_res[26] o_res[27] o_res[28] o_res[29] o_res[2] o_res[30] o_res[31]
+ o_res[3] o_res[4] o_res[5] o_res[6] o_res[7] o_res[8] o_res[9] o_res_vld opcode
+ overflow rst
XANTENNA__7406__A1 _1158_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7963_ adder_inst.sum_raw_r\[8\] net495 _3555_ _3556_ _3473_ VGND VGND VPWR VPWR
+ _3557_ sky130_fd_sc_hd__a221o_1
XANTENNA__7957__A2 net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6914_ _2529_ _2542_ _2543_ VGND VGND VPWR VPWR _2544_ sky130_fd_sc_hd__or3b_1
XANTENNA__4640__A1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout162_A net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7894_ _3384_ net114 VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__and2_1
XFILLER_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6018__A2_N net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5188__D net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6845_ _2440_ _2449_ _2473_ VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__or3_1
XANTENNA_fanout427_A net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6776_ _2401_ _2404_ _2405_ VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__nor3_1
X_9495_ clknet_leaf_20_clk net815 _0405_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
X_8515_ _4082_ _4087_ VGND VGND VPWR VPWR _4088_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_98_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5485__B _1114_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5727_ _1322_ _1324_ _1323_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__o21bai_1
X_8446_ net123 _3937_ VGND VGND VPWR VPWR _4019_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout215_X net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5658_ _1285_ _1286_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__nand3_1
X_8377_ net123 _3901_ _3904_ _3677_ _3732_ VGND VGND VPWR VPWR _3950_ sky130_fd_sc_hd__a221o_1
X_4609_ net203 net363 _4378_ VGND VGND VPWR VPWR _4380_ sky130_fd_sc_hd__and3_1
X_5589_ _1217_ _1218_ net237 net467 VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__and4bb_1
X_7328_ _2750_ _2767_ VGND VGND VPWR VPWR _2958_ sky130_fd_sc_hd__nor2_1
XFILLER_117_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4829__B net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7259_ _2882_ _2884_ VGND VGND VPWR VPWR _2889_ sky130_fd_sc_hd__nor2_1
XFILLER_104_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8317__A net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6384__A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6384__B2 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8987__A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6003__C net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer7 _1513_ VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__buf_4
XFILLER_108_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4960_ _0584_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__xor2_1
XFILLER_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4891_ _0518_ _0519_ _0515_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21o_1
X_6630_ _2247_ _2259_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__nand2_1
X_6561_ _2117_ _2190_ net601 VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__o21a_1
XANTENNA__8897__A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5512_ _1139_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__nand2_1
X_8300_ _3678_ net127 net119 _3871_ VGND VGND VPWR VPWR _3873_ sky130_fd_sc_hd__and4_1
XFILLER_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9280_ clknet_leaf_22_clk adder_inst.sum_raw\[17\] _0190_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_6492_ _2047_ _2121_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__nand2b_4
XANTENNA__6127__A1 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6127__B2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5443_ _1072_ _1071_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nand2b_1
XFILLER_106_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8231_ net134 _3751_ _3800_ net139 VGND VGND VPWR VPWR _3804_ sky130_fd_sc_hd__a211o_1
X_5374_ _0999_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__xnor2_1
X_8162_ net257 net399 net158 VGND VGND VPWR VPWR _3736_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_93_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7113_ net238 net431 _2741_ _2742_ VGND VGND VPWR VPWR _2743_ sky130_fd_sc_hd__nand4_1
Xfanout116 _3499_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlymetal6s2s_1
X_8093_ _3342_ _3656_ net645 VGND VGND VPWR VPWR _3667_ sky130_fd_sc_hd__nand3_1
Xfanout127 net128 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_2
Xfanout138 _3709_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_6
XFILLER_99_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout105 net108 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_12
XFILLER_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout149 _3694_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_8
XFILLER_113_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5102__A2 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7044_ _2672_ _2673_ VGND VGND VPWR VPWR _2674_ sky130_fd_sc_hd__or2_1
XANTENNA__4665__A net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout377_A net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8995_ net513 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__inv_2
XANTENNA__7976__A adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7946_ adder_inst.sum_raw_r\[4\] net170 VGND VGND VPWR VPWR _3542_ sky130_fd_sc_hd__or2_1
XFILLER_43_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7877_ net196 _3388_ VGND VGND VPWR VPWR _3483_ sky130_fd_sc_hd__xnor2_1
XFILLER_82_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5169__A2 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6828_ net310 net318 net464 net471 VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_102_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7563__B1 _3189_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_21_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6759_ _2386_ _2387_ _2381_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__a21bo_1
X_9478_ clknet_leaf_29_clk net836 _0388_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
X_8429_ net156 _3998_ _4001_ VGND VGND VPWR VPWR _4002_ sky130_fd_sc_hd__a21oi_1
XFILLER_136_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold170 adder_inst.i_b\[17\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 adder_inst.i_a\[13\] VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold181 adder_inst.i_b\[10\] VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_77_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_leaf_31_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7094__A2 net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6790__A net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6357__A1 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_78_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6357__B2 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8510__A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6109__B2 net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6030__A net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7609__A1 _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5090_ _0717_ _0718_ _0688_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21oi_4
XPHY_EDGE_ROW_87_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7800_ net197 adder_inst.exp_larger_r\[1\] VGND VGND VPWR VPWR _3406_ sky130_fd_sc_hd__or2_2
XFILLER_92_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8780_ _2548_ _2551_ VGND VGND VPWR VPWR _4287_ sky130_fd_sc_hd__or2_1
XFILLER_18_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5992_ _1620_ _1284_ _1621_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__nor3_4
X_7731_ _3351_ _3352_ VGND VGND VPWR VPWR adder_inst.man_b\[23\] sky130_fd_sc_hd__or2_1
XFILLER_91_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4943_ _0530_ _0566_ _0565_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21o_1
XANTENNA__4932__B net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7662_ _3154_ _3156_ _3284_ _3285_ VGND VGND VPWR VPWR _3290_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_96_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5747__C net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9401_ clknet_leaf_10_clk net749 _0311_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_4874_ net386 net263 net269 net380 VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a22o_1
X_6613_ _2241_ _2242_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__nor2_1
XFILLER_32_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7593_ _1153_ _3222_ _1082_ VGND VGND VPWR VPWR _3223_ sky130_fd_sc_hd__a21oi_1
X_9332_ clknet_leaf_3_clk net730 _0242_ VGND VGND VPWR VPWR adder_inst.man_b_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_6544_ _2155_ _2157_ _2171_ _2172_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__or4_4
XFILLER_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9263_ clknet_leaf_24_clk adder_inst.sum_raw\[0\] _0173_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[0\]
+ sky130_fd_sc_hd__dfrtp_4
X_6475_ net249 net479 _1950_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__a21oi_1
X_5426_ _1054_ _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__xnor2_1
XFILLER_118_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8214_ _4358_ _3679_ net654 _3698_ _3765_ VGND VGND VPWR VPWR _3787_ sky130_fd_sc_hd__o41a_1
X_9194_ net543 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_7_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6297__D net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5357_ _0985_ _0436_ _0984_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__a21o_1
XFILLER_102_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8145_ net322 net463 net154 VGND VGND VPWR VPWR _3719_ sky130_fd_sc_hd__mux2_1
XFILLER_59_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8076_ adder_inst.is_zero_r _3439_ VGND VGND VPWR VPWR _3652_ sky130_fd_sc_hd__nor2_1
X_5288_ _0833_ _0834_ _0848_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__o21a_1
XFILLER_114_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout282_X net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7027_ net221 net457 VGND VGND VPWR VPWR _2657_ sky130_fd_sc_hd__nand2_1
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8025__A1 net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8978_ net507 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__inv_2
XFILLER_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4842__B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7929_ _4336_ adder_inst.sum_raw_r\[23\] adder_inst.sum_raw_r\[7\] VGND VGND VPWR
+ VPWR _3528_ sky130_fd_sc_hd__and3_1
XFILLER_90_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5673__B net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input55_A i_b[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9161__A net539 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout491 adder_inst.sum_raw_r\[21\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__clkbuf_4
XANTENNA__8016__A1 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout480 net481 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__buf_2
XFILLER_74_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5848__B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4590_ net203 net345 _4359_ VGND VGND VPWR VPWR _4361_ sky130_fd_sc_hd__and3_1
XFILLER_128_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6260_ _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_90_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5211_ _0836_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__xnor2_1
X_6191_ net407 net412 net315 net321 VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__and4_1
XFILLER_123_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5142_ _0771_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__inv_2
XFILLER_96_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6805__A2 net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5073_ net228 net234 net392 net398 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__and4_1
XANTENNA__4816__A1 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8901_ net515 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8832_ _3270_ _4324_ _4323_ VGND VGND VPWR VPWR multiplier_inst.man_final\[14\] sky130_fd_sc_hd__and3_1
XFILLER_65_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8763_ net844 _4272_ _0104_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__a21o_1
XFILLER_80_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5975_ _1466_ _1468_ _1603_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__a211oi_1
XFILLER_40_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7714_ _3334_ _3337_ VGND VGND VPWR VPWR _3338_ sky130_fd_sc_hd__and2_1
X_8694_ net370 net160 _4026_ _4028_ VGND VGND VPWR VPWR _4247_ sky130_fd_sc_hd__o211a_1
X_4926_ _0537_ _0535_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__or3_4
XANTENNA_fanout242_A net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7645_ adder_inst.exp_a_r\[3\] adder_inst.exp_b_r\[3\] VGND VGND VPWR VPWR _3273_
+ sky130_fd_sc_hd__xor2_4
XANTENNA__8191__A0 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4857_ _0485_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__and2b_1
XFILLER_21_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7576_ _3031_ _3205_ VGND VGND VPWR VPWR _3206_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9315_ clknet_leaf_9_clk net740 _0225_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_2
X_4788_ _4417_ _4552_ _4551_ VGND VGND VPWR VPWR _4559_ sky130_fd_sc_hd__a21o_1
X_6527_ _2077_ _2154_ _2153_ _2139_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__o211a_1
XANTENNA__6589__B net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9246_ clknet_leaf_4_clk net40 _0156_ VGND VGND VPWR VPWR adder_inst.i_b\[16\] sky130_fd_sc_hd__dfrtp_1
X_6458_ _2083_ _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__xnor2_1
X_5409_ _0980_ _0981_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__xnor2_1
X_9177_ net533 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__inv_2
X_6389_ _1947_ _1949_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__xnor2_1
X_8128_ net662 _3701_ VGND VGND VPWR VPWR _3702_ sky130_fd_sc_hd__xor2_1
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8059_ net490 _3634_ _3636_ _3637_ VGND VGND VPWR VPWR _3638_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_110_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7221__A2 net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5535__A2 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7288__A2 net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7123__B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7996__B1 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5859__A net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4913__D net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5760_ net272 net427 _1181_ _1180_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__a31o_1
XFILLER_15_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4711_ net351 net238 net242 net345 VGND VGND VPWR VPWR _4482_ sky130_fd_sc_hd__a22oi_1
X_5691_ _1302_ _1304_ _1303_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__a21bo_1
X_4642_ net369 net239 _4394_ _4395_ VGND VGND VPWR VPWR _4413_ sky130_fd_sc_hd__a22o_1
X_7430_ _4481_ _3058_ VGND VGND VPWR VPWR _3060_ sky130_fd_sc_hd__nor2_1
XANTENNA__6723__A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6723__B2 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4573_ adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR _4345_ sky130_fd_sc_hd__inv_2
X_7361_ _2758_ _2765_ VGND VGND VPWR VPWR _2991_ sky130_fd_sc_hd__nor2_1
XANTENNA__6202__B net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7292_ net206 net212 net449 net454 VGND VGND VPWR VPWR _2922_ sky130_fd_sc_hd__and4_1
X_9100_ net525 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__inv_2
X_6312_ _1844_ _1845_ _1860_ _1861_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__o22a_1
X_9031_ net519 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__inv_2
XFILLER_115_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4938__A net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6243_ _1791_ _1872_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__and2_1
XFILLER_130_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6174_ _1800_ _1801_ _1802_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__or3_1
X_5125_ _0459_ _0602_ _0626_ _0742_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a2bb2o_1
X_5056_ _0682_ _0683_ _0603_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__a21oi_1
XFILLER_85_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5769__A net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout457_A adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_36_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8815_ _3204_ _4314_ VGND VGND VPWR VPWR multiplier_inst.man_final\[7\] sky130_fd_sc_hd__and2_1
XFILLER_37_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout245_X net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7984__A adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8746_ net852 net179 net178 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and3_1
X_5958_ net221 net463 VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__nand2_1
X_4909_ net234 net403 net410 net228 VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a22o_1
XANTENNA__5000__C net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8164__A0 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8677_ net661 _4231_ VGND VGND VPWR VPWR _4232_ sky130_fd_sc_hd__nand2_2
XANTENNA_fanout412_X net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5889_ _1516_ _1517_ _1518_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__nand3_1
XFILLER_126_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7628_ _4370_ net131 net562 _3251_ VGND VGND VPWR VPWR _3258_ sky130_fd_sc_hd__a31o_1
XANTENNA__6714__A1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6714__B2 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7559_ _2983_ _3188_ VGND VGND VPWR VPWR _3189_ sky130_fd_sc_hd__xnor2_2
X_9229_ clknet_leaf_13_clk net25 _0139_ VGND VGND VPWR VPWR adder_inst.i_a\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_136_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4848__A net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input18_A i_a[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5679__A net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5564__D net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6957__B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4908__D net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6973__A net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7788__B adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer17 _1921_ VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__buf_4
Xrebuffer39 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer28 net578 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_85_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6930_ _2559_ VGND VGND VPWR VPWR _2560_ sky130_fd_sc_hd__inv_2
XFILLER_81_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6861_ _2463_ _2465_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5101__B net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8600_ _4164_ net173 _4161_ VGND VGND VPWR VPWR _4165_ sky130_fd_sc_hd__a21oi_2
XFILLER_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5812_ _1439_ _1440_ _1435_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__a21o_1
X_6792_ _2419_ _2420_ _2421_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__or3_1
XFILLER_22_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8531_ _3989_ _4103_ _4094_ VGND VGND VPWR VPWR _4104_ sky130_fd_sc_hd__a21o_1
XFILLER_62_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6944__A1 _2568_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5743_ _1370_ _1371_ _1356_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__a21o_1
XANTENNA__8146__A0 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8462_ net236 net166 VGND VGND VPWR VPWR _4035_ sky130_fd_sc_hd__or2_1
Xrebuffer129 _4022_ VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__buf_1
XFILLER_30_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5674_ net371 net331 net339 net365 VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a22o_1
X_8393_ _3964_ _3965_ VGND VGND VPWR VPWR _3966_ sky130_fd_sc_hd__nand2b_2
X_4625_ net369 net240 _4394_ _4395_ VGND VGND VPWR VPWR _4396_ sky130_fd_sc_hd__nand4_1
X_7413_ _4484_ _4515_ _4531_ VGND VGND VPWR VPWR _3043_ sky130_fd_sc_hd__a21oi_1
XANTENNA__7028__B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7344_ _2968_ _2972_ VGND VGND VPWR VPWR _2974_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_96_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout205_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4668__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7275_ _2826_ _2903_ _2902_ VGND VGND VPWR VPWR _2905_ sky130_fd_sc_hd__a21o_1
XFILLER_131_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9014_ net510 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
X_6226_ _1835_ _1839_ _1838_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__a21oi_1
XFILLER_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6157_ _1690_ _1786_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__and2b_1
X_5108_ _0674_ _0681_ _0736_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nor3_1
XFILLER_111_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6088_ _1716_ _1717_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__nor2_2
X_5039_ net349 net343 net280 net287 VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__nand4_2
XANTENNA_fanout362_X net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5946__B net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8729_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r net198 VGND VGND VPWR VPWR
+ _4269_ sky130_fd_sc_hd__nor3b_1
XFILLER_9_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7112__A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7112__B2 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput75 net75 VGND VGND VPWR VPWR o_res[16] sky130_fd_sc_hd__buf_2
XFILLER_1_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput86 net86 VGND VGND VPWR VPWR o_res[26] sky130_fd_sc_hd__buf_2
Xoutput97 net97 VGND VGND VPWR VPWR o_res[7] sky130_fd_sc_hd__buf_2
XANTENNA__5674__B2 net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5674__A1 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5390_ net582 _1013_ _0986_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a21boi_2
XFILLER_125_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout309 adder_inst.man_b_r\[5\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_4
X_7060_ _2687_ _2688_ _2689_ VGND VGND VPWR VPWR _2690_ sky130_fd_sc_hd__or3_1
XFILLER_101_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6011_ _1640_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__inv_2
XFILLER_39_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7962_ adder_inst.sum_raw_r\[7\] _4341_ net170 adder_inst.sum_raw_r\[6\] net192 VGND
+ VGND VPWR VPWR _3556_ sky130_fd_sc_hd__o221a_1
XFILLER_70_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6913_ _2517_ _2528_ VGND VGND VPWR VPWR _2543_ sky130_fd_sc_hd__or2_1
X_7893_ adder_inst.is_nan_r net198 _3497_ _3498_ VGND VGND VPWR VPWR _3499_ sky130_fd_sc_hd__and4b_1
XFILLER_35_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout155_A _3666_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6844_ _2440_ _2449_ _2473_ VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__nor3_1
XANTENNA__7590__A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6775_ _2350_ _2373_ _2390_ _2400_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__o211a_1
X_9494_ clknet_leaf_20_clk net762 _0404_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
X_8514_ _4083_ _4084_ _4086_ VGND VGND VPWR VPWR _4087_ sky130_fd_sc_hd__o21ai_2
XFILLER_10_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout322_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5726_ _1328_ _1333_ _1327_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a21bo_1
XFILLER_109_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8445_ net124 _4013_ _4016_ net120 VGND VGND VPWR VPWR _4018_ sky130_fd_sc_hd__o31a_1
XFILLER_108_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5657_ net383 net333 net339 net377 VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__a22o_1
XFILLER_117_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_107_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout208_X net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8376_ net252 net165 VGND VGND VPWR VPWR _3949_ sky130_fd_sc_hd__nor2_1
X_4608_ net203 net363 _4378_ VGND VGND VPWR VPWR _4379_ sky130_fd_sc_hd__a21oi_1
X_5588_ net247 net455 net461 net241 VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a22oi_1
X_7327_ _2954_ _2955_ VGND VGND VPWR VPWR _2957_ sky130_fd_sc_hd__xnor2_2
XFILLER_116_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7258_ _2886_ _2887_ VGND VGND VPWR VPWR _2888_ sky130_fd_sc_hd__and2b_1
XFILLER_117_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6209_ _1740_ _1837_ _1836_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__a21o_1
XFILLER_133_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7189_ _0894_ _2805_ _2818_ VGND VGND VPWR VPWR _2819_ sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_51_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8039__A_N net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8317__B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_116_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_107_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6384__A2 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_5_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_125_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer8 _1675_ VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__clkbuf_2
XANTENNA__6003__D net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5692__A net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5895__A1 net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5895__B2 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5867__A net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4890_ _0515_ _0518_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nand3_1
XFILLER_83_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6560_ _2040_ _2116_ _2115_ _2112_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__o211a_1
XANTENNA__5583__B1 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5511_ _1128_ _1138_ _0750_ _0752_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__a211o_1
X_6491_ _2119_ net596 VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__xor2_4
XANTENNA__6127__A2 net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5442_ _1006_ _1008_ _1005_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__o21ba_1
X_8230_ net134 _3712_ _3802_ net137 VGND VGND VPWR VPWR _3803_ sky130_fd_sc_hd__a211o_1
X_5373_ _1000_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__nor2_1
XFILLER_126_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8161_ net168 _3680_ _3693_ _3699_ _3734_ VGND VGND VPWR VPWR _3735_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_93_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8092_ _3342_ net647 VGND VGND VPWR VPWR _3666_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_93_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7112_ net249 net419 net425 net243 VGND VGND VPWR VPWR _2742_ sky130_fd_sc_hd__a22o_1
Xfanout128 _3703_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout106 net108 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_8
XFILLER_59_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7043_ _2655_ _2656_ _2671_ VGND VGND VPWR VPWR _2673_ sky130_fd_sc_hd__o21a_1
Xfanout139 net142 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_2
XANTENNA__4665__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9310__Q adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8852__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout272_A net275 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8994_ net515 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7945_ _3540_ _3541_ net115 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__o21a_1
XFILLER_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout537_A net539 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7876_ adder_inst.exp_larger_r\[6\] _3390_ VGND VGND VPWR VPWR _3482_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_120_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7563__A1 _3176_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6827_ _2422_ _2451_ _2456_ VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__and3_1
XANTENNA__8760__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_102_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5574__B1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6758_ _2381_ _2386_ _2387_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__nand3_1
XFILLER_128_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9477_ clknet_leaf_28_clk net756 _0387_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
X_6689_ _2295_ _2301_ _2300_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__a21oi_1
X_5709_ net414 net290 _1166_ _1164_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_135_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8428_ net423 net157 VGND VGND VPWR VPWR _4001_ sky130_fd_sc_hd__nor2_1
XFILLER_105_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8359_ net435 _3929_ net156 VGND VGND VPWR VPWR _3932_ sky130_fd_sc_hd__mux2_1
Xhold171 adder_inst.i_a\[11\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold160 adder_inst.i_b\[8\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 adder_inst.exp_a\[4\] VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 adder_inst.exp_a\[5\] VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_120_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8028__C1 net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6790__B net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4591__A net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5565__B1 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6109__A2 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5317__B1 net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6030__B net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5991_ _1618_ _1619_ _1510_ _1513_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__a211oi_4
X_7730_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] adder_inst.exp_b\[3\] adder_inst.exp_b\[2\]
+ VGND VGND VPWR VPWR _3352_ sky130_fd_sc_hd__or4_1
X_4942_ _0568_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nand2b_1
XFILLER_45_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7661_ _3280_ _3281_ net103 _3272_ VGND VGND VPWR VPWR _3289_ sky130_fd_sc_hd__and4bb_1
XFILLER_33_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9400_ clknet_leaf_9_clk net733 _0310_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_4873_ net380 net386 net263 net269 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__and4_1
XANTENNA__5747__D net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6612_ _2158_ _2173_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__xnor2_2
XFILLER_32_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7592_ _1156_ _3214_ _1115_ _1135_ VGND VGND VPWR VPWR _3222_ sky130_fd_sc_hd__a211o_1
X_9331_ clknet_leaf_3_clk net699 _0241_ VGND VGND VPWR VPWR adder_inst.man_b_r\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_6543_ _2171_ _2172_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__nor2_1
X_9262_ clknet_leaf_17_clk net66 _0172_ VGND VGND VPWR VPWR opcode_stage1 sky130_fd_sc_hd__dfrtp_2
X_6474_ _2102_ _2027_ _2101_ _2080_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__a211oi_4
X_5425_ net202 net416 VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nand2_1
X_8213_ _4358_ net151 net654 net148 _3762_ VGND VGND VPWR VPWR _3786_ sky130_fd_sc_hd__o41a_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9193_ net544 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__inv_2
XANTENNA__8847__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9305__Q adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5356_ _0436_ _0984_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nand3_1
XFILLER_102_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8144_ _3714_ _3717_ net139 VGND VGND VPWR VPWR _3718_ sky130_fd_sc_hd__mux2_1
XFILLER_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8075_ _3628_ _3651_ net198 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__o21a_1
XFILLER_114_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout487_A net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8148__A net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5287_ _0896_ _0916_ _0810_ _0876_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a211o_2
XFILLER_59_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7026_ _2652_ _2653_ _2654_ VGND VGND VPWR VPWR _2656_ sky130_fd_sc_hd__a21oi_1
XANTENNA__6284__A1 net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout275_X net275 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6891__A net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8977_ net509 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__inv_2
XFILLER_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7928_ adder_inst.sum_raw_r\[6\] net189 net169 adder_inst.sum_raw_r\[5\] net184 VGND
+ VGND VPWR VPWR _3527_ sky130_fd_sc_hd__o221a_1
XANTENNA_fanout442_X net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5300__A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7859_ net197 _3462_ _3464_ VGND VGND VPWR VPWR _3465_ sky130_fd_sc_hd__or3_1
XFILLER_51_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_115_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input48_A i_b[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout492 net494 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_2
XFILLER_93_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout470 net472 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__buf_2
Xfanout481 net482 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__buf_2
XFILLER_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5848__C net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5210_ _0837_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nor2_1
XFILLER_97_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6190_ net418 net308 VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__nand2_1
XFILLER_111_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5141_ _0752_ _0753_ _0766_ _0769_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__o211a_1
X_5072_ _0697_ _0698_ _0699_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a21oi_1
XFILLER_111_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8900_ net515 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__inv_2
XANTENNA__4816__A2 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8831_ _3235_ _3238_ _3241_ net102 VGND VGND VPWR VPWR _4324_ sky130_fd_sc_hd__or4b_4
XFILLER_65_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8762_ net847 _4272_ _0104_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__a21o_1
XFILLER_92_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7713_ _3152_ _3335_ VGND VGND VPWR VPWR _3337_ sky130_fd_sc_hd__nand2_1
X_5974_ _1586_ _1587_ _1602_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__o21a_1
X_8693_ _4109_ net107 net175 VGND VGND VPWR VPWR _4246_ sky130_fd_sc_hd__o21ai_1
X_4925_ _0549_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__xnor2_1
XFILLER_80_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout235_A net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7644_ _3157_ net103 VGND VGND VPWR VPWR multiplier_inst.exp_final\[0\] sky130_fd_sc_hd__xnor2_1
XANTENNA__8191__A1 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4856_ net380 net262 net268 net374 VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a22o_1
XFILLER_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7575_ _0976_ _3200_ VGND VGND VPWR VPWR _3205_ sky130_fd_sc_hd__nor2_1
XANTENNA_clkbuf_leaf_30_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9314_ clknet_leaf_13_clk net721 _0224_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_4787_ _4554_ _4557_ VGND VGND VPWR VPWR _4558_ sky130_fd_sc_hd__nand2b_4
XFILLER_119_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout402_A net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6526_ _2139_ _2153_ _2154_ _2077_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__a211o_1
XFILLER_20_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9245_ clknet_leaf_4_clk net39 _0155_ VGND VGND VPWR VPWR adder_inst.i_b\[15\] sky130_fd_sc_hd__dfrtp_1
X_6457_ _2084_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__nor2_1
X_5408_ _1027_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__nor2_1
X_9176_ net533 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__inv_2
X_6388_ _2012_ _2016_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5701__B1 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8127_ _3653_ _3658_ net161 VGND VGND VPWR VPWR _3701_ sky130_fd_sc_hd__mux2_1
XANTENNA_fanout392_X net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5339_ _0960_ _0967_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__nor3_1
XFILLER_87_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8058_ _4347_ _3408_ _3404_ VGND VGND VPWR VPWR _3637_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_110_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7009_ _2583_ _2638_ VGND VGND VPWR VPWR _2639_ sky130_fd_sc_hd__and2b_1
XFILLER_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6126__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4587__Y _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7123__C net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7996__B2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5859__B net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6420__A1 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6420__B2 net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4710_ net351 net345 net238 net242 VGND VGND VPWR VPWR _4481_ sky130_fd_sc_hd__and4_1
XFILLER_61_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5690_ _1308_ _1313_ _1307_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__a21bo_1
X_4641_ net356 net257 _4410_ _4398_ net269 VGND VGND VPWR VPWR _4412_ sky130_fd_sc_hd__a32o_1
XFILLER_30_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6723__A2 net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4572_ net488 VGND VGND VPWR VPWR _4344_ sky130_fd_sc_hd__inv_2
X_7360_ _2738_ _2771_ _2769_ VGND VGND VPWR VPWR _2990_ sky130_fd_sc_hd__o21ai_2
X_7291_ _2920_ VGND VGND VPWR VPWR _2921_ sky130_fd_sc_hd__inv_2
X_6311_ _1924_ _1925_ _1939_ _1940_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__nand4_4
XFILLER_115_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9030_ net513 VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__inv_2
X_6242_ _1790_ _1870_ _1871_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__and3_1
XFILLER_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4938__B net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6173_ _1800_ _1801_ _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__nor3_1
XANTENNA__7987__A1 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5124_ _0661_ _0746_ _0748_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__o21a_1
XFILLER_57_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout185_A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5055_ _0614_ _0621_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__and2_1
XANTENNA__7987__B2 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8426__A net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5769__B net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8814_ _3199_ _3203_ VGND VGND VPWR VPWR _4314_ sky130_fd_sc_hd__or2_1
XFILLER_26_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout352_A adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8745_ net839 net181 net177 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and3_1
XFILLER_80_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5957_ _1583_ _1584_ _1585_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__a21oi_1
XFILLER_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4908_ net228 net234 net403 net410 VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__and4_1
XANTENNA__5000__D net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8676_ _4048_ _4055_ _4058_ _4216_ _4049_ VGND VGND VPWR VPWR _4231_ sky130_fd_sc_hd__a221oi_2
XFILLER_139_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8164__A1 net404 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7627_ net592 _3230_ _3256_ VGND VGND VPWR VPWR _3257_ sky130_fd_sc_hd__o21ai_2
XANTENNA_fanout238_X net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7048__Y _2678_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5888_ net348 net329 net336 net344 VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__a22o_1
X_4839_ net342 _0466_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a21bo_1
XANTENNA__6714__A2 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout405_X net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7558_ _3003_ _3174_ _3002_ VGND VGND VPWR VPWR _3188_ sky130_fd_sc_hd__o21ba_1
XFILLER_5_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7489_ _3117_ _3118_ VGND VGND VPWR VPWR _3119_ sky130_fd_sc_hd__nand2_1
X_6509_ _2061_ _2137_ _2138_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__nand3_2
X_9228_ clknet_leaf_8_clk net24 _0138_ VGND VGND VPWR VPWR adder_inst.exp_a\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_136_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4848__B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9159_ net547 VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__inv_2
XFILLER_121_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7978__A1 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer88_A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5679__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7415__A net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7969__A1 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6973__B net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7969__B2 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer18 _2009_ VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer29 net604 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_85_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6860_ _2472_ _2489_ VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__nand2_1
XANTENNA__5101__C net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5811_ _1435_ _1439_ _1440_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__and3_1
X_6791_ net328 net453 net334 net448 VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__a22oi_2
X_8530_ _3996_ _4004_ _4102_ _4010_ _3995_ VGND VGND VPWR VPWR _4103_ sky130_fd_sc_hd__a221o_1
XANTENNA__6944__A2 _2573_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5742_ _1356_ _1370_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__nand3_2
XANTENNA__8146__A1 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer108 adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer119 net684 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlymetal6s2s_1
X_8461_ net144 _3844_ _3845_ net123 net121 VGND VGND VPWR VPWR _4034_ sky130_fd_sc_hd__o2111a_1
XFILLER_30_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5673_ net365 net371 net331 net339 VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nand4_1
XFILLER_136_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8392_ _3962_ _3963_ VGND VGND VPWR VPWR _3965_ sky130_fd_sc_hd__nand2_1
X_4624_ net361 net245 net251 net356 VGND VGND VPWR VPWR _4395_ sky130_fd_sc_hd__a22o_1
X_7412_ _3040_ _3041_ VGND VGND VPWR VPWR _3042_ sky130_fd_sc_hd__xor2_1
XANTENNA__7028__C net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4949__A net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7343_ _2968_ _2972_ VGND VGND VPWR VPWR _2973_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_96_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4668__B net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9013_ net510 VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__inv_2
X_7274_ _2826_ _2902_ _2903_ VGND VGND VPWR VPWR _2904_ sky130_fd_sc_hd__nand3_1
XANTENNA__8855__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6225_ _1852_ _1853_ _1854_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__nand3_2
XFILLER_112_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6156_ net237 net480 _1688_ _1689_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__a22o_1
X_5107_ _0674_ _0681_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__o21a_1
XFILLER_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4684__A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6087_ _1622_ _1623_ _1713_ _1715_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__o211a_1
X_5038_ _0665_ _0666_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__xor2_1
XANTENNA_fanout355_X net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6107__C net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8728_ net850 adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR adder_inst.exp_larger\[7\]
+ sky130_fd_sc_hd__or2_1
XFILLER_53_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6989_ net397 net277 net284 net641 VGND VGND VPWR VPWR _2619_ sky130_fd_sc_hd__a22oi_2
XFILLER_41_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8688__A2 net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8659_ _3967_ _4214_ _4215_ VGND VGND VPWR VPWR _4216_ sky130_fd_sc_hd__a21bo_1
XFILLER_31_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput76 net76 VGND VGND VPWR VPWR o_res[17] sky130_fd_sc_hd__buf_2
XFILLER_96_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput87 net87 VGND VGND VPWR VPWR o_res[27] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR o_res[8] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4882__B1 net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input30_A i_a[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8066__A net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7286__A1_N net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6010_ _1299_ _1638_ _1639_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__nand3_1
XFILLER_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7961_ adder_inst.sum_raw_r\[5\] net182 VGND VGND VPWR VPWR _3555_ sky130_fd_sc_hd__or2_1
XFILLER_54_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7892_ adder_inst.is_zero_r adder_inst.is_inf_r VGND VGND VPWR VPWR _3498_ sky130_fd_sc_hd__nor2_1
XFILLER_54_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6912_ _2538_ _2540_ _2541_ VGND VGND VPWR VPWR _2542_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_46_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6843_ _2470_ _2471_ _2467_ VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_122_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6774_ _2402_ _2403_ VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__or2_1
XFILLER_23_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8513_ _4083_ _4085_ VGND VGND VPWR VPWR _4086_ sky130_fd_sc_hd__nand2_1
X_9493_ clknet_leaf_20_clk net788 _0403_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
X_5725_ _1209_ _1352_ _1353_ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_98_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8444_ net126 _3858_ _3939_ net122 VGND VGND VPWR VPWR _4017_ sky130_fd_sc_hd__a211o_1
X_5656_ net630 net326 VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout315_A net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4607_ _4376_ _4377_ VGND VGND VPWR VPWR _4378_ sky130_fd_sc_hd__nor2_1
X_8375_ _3936_ _3947_ VGND VGND VPWR VPWR _3948_ sky130_fd_sc_hd__or2_4
X_5587_ net241 net247 net455 net461 VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__and4_1
XFILLER_117_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7326_ _2955_ _2954_ VGND VGND VPWR VPWR _2956_ sky130_fd_sc_hd__and2b_1
XFILLER_131_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8585__S net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7257_ _0974_ _2801_ _2881_ _2885_ VGND VGND VPWR VPWR _2887_ sky130_fd_sc_hd__a211o_1
XFILLER_132_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6208_ _1740_ _1836_ _1837_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__and3_1
XFILLER_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7188_ _2808_ _2815_ _2816_ _2807_ VGND VGND VPWR VPWR _2818_ sky130_fd_sc_hd__a31o_1
XFILLER_133_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout472_X net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6139_ _1760_ _1765_ _1767_ net607 VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__a211oi_4
XFILLER_45_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8358__A1 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clone23_A _3152_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer9 _1031_ VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_6_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5692__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4589__A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5895__A2 net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__9180__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5867__B net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5583__A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5583__B2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5510_ _0664_ _0667_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__nor2_1
XFILLER_12_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6490_ net597 _2119_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__nand2_1
X_5441_ _1068_ _1069_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6532__B1 net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5372_ _1000_ _1001_ net223 net399 VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__and4bb_1
X_8160_ _3733_ VGND VGND VPWR VPWR _3734_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_93_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8091_ _3341_ net685 VGND VGND VPWR VPWR _3665_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_93_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7111_ net243 net249 net419 net425 VGND VGND VPWR VPWR _2741_ sky130_fd_sc_hd__nand4_1
XFILLER_114_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout107 net108 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_8
XFILLER_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7603__A _1082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7042_ _2655_ _2656_ _2671_ VGND VGND VPWR VPWR _2672_ sky130_fd_sc_hd__nor3_1
XFILLER_86_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4665__C net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8993_ net516 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__inv_2
XANTENNA__8137__C _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7944_ net483 adder_inst.sum_raw_r\[10\] _3538_ _3539_ VGND VGND VPWR VPWR _3541_
+ sky130_fd_sc_hd__a22o_1
XFILLER_70_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout265_A net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7875_ _3435_ _3479_ _3480_ VGND VGND VPWR VPWR _3481_ sky130_fd_sc_hd__or3_1
XFILLER_35_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout432_A net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6826_ _2453_ _2454_ _2452_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_102_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5574__A1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6757_ _2326_ _2375_ _2380_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__a21o_1
XFILLER_109_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout220_X net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5574__B2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5708_ _1334_ _1335_ _1320_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__a21o_1
X_9476_ clknet_leaf_14_clk _0096_ _0386_ VGND VGND VPWR VPWR mul_res\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_137_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8512__A1 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout318_X net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6688_ _2307_ _2317_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__nor2_1
XFILLER_136_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_135_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8427_ net163 _3998_ _3999_ VGND VGND VPWR VPWR _4000_ sky130_fd_sc_hd__a21o_1
X_5639_ _1261_ _1267_ _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__a21oi_2
XFILLER_128_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8358_ net156 _3929_ _3930_ VGND VGND VPWR VPWR _3931_ sky130_fd_sc_hd__o21ai_1
Xhold161 adder_inst.i_a\[19\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold150 adder_inst.i_b\[9\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__8276__A0 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7309_ _2856_ _2860_ VGND VGND VPWR VPWR _2939_ sky130_fd_sc_hd__nor2_1
Xhold172 adder_inst.exp_a\[1\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 adder_inst.exp_b\[7\] VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 adder_inst.i_a\[15\] VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlygate4sd3_1
X_8289_ net135 _3771_ _3807_ net138 VGND VGND VPWR VPWR _3862_ sky130_fd_sc_hd__a211o_1
XFILLER_120_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4872__A net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5262__B1 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4591__B net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5565__A1 net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5565__B2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5317__B2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5317__A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6030__C net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_75_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5990_ _1513_ _1510_ _1618_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__o211a_4
X_4941_ _0568_ _0569_ _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__or3_1
XFILLER_45_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7660_ net572 _3286_ _3287_ VGND VGND VPWR VPWR _3288_ sky130_fd_sc_hd__a21boi_1
X_4872_ net258 net392 VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__nand2_1
XFILLER_17_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7545__A2 _3170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6611_ _2230_ _2240_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__nor2_1
XFILLER_20_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9330_ clknet_leaf_1_clk net709 _0240_ VGND VGND VPWR VPWR adder_inst.man_b_r\[8\]
+ sky130_fd_sc_hd__dfrtp_4
X_7591_ _3210_ _3213_ _3218_ _3220_ VGND VGND VPWR VPWR _3221_ sky130_fd_sc_hd__nor4_2
XANTENNA__6753__B1 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6542_ _2169_ _2170_ _2165_ _2167_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__o211a_1
XANTENNA__6502__A net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9261_ clknet_leaf_13_clk net57 _0171_ VGND VGND VPWR VPWR adder_inst.i_b\[31\] sky130_fd_sc_hd__dfrtp_1
X_6473_ _2080_ _2101_ _2102_ _2027_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__o211a_4
X_9192_ net543 VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__inv_2
X_5424_ _1052_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__nor2_1
X_8212_ net143 net140 net136 _3761_ VGND VGND VPWR VPWR _3785_ sky130_fd_sc_hd__and4_1
X_8143_ _3715_ _3716_ net134 VGND VGND VPWR VPWR _3717_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_130_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5355_ _0421_ _0422_ _0435_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__o21ai_1
XFILLER_99_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5405__X _1035_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8074_ adder_inst.is_zero_r _3443_ VGND VGND VPWR VPWR _3651_ sky130_fd_sc_hd__nor2_1
X_5286_ _0896_ _0912_ _0913_ _0914_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__nand4_1
XFILLER_101_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8863__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7025_ _2652_ _2653_ _2654_ VGND VGND VPWR VPWR _2655_ sky130_fd_sc_hd__and3_1
XFILLER_68_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_4_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5788__A net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6891__B adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout268_X net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4692__A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8976_ net509 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__inv_2
XFILLER_55_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7927_ adder_inst.sum_raw_r\[4\] net492 _3521_ _3525_ _3414_ VGND VGND VPWR VPWR
+ _3526_ sky130_fd_sc_hd__a221o_1
XFILLER_83_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7858_ net497 _3445_ _3428_ VGND VGND VPWR VPWR _3464_ sky130_fd_sc_hd__o21a_1
XANTENNA_fanout435_X net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5300__B net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6809_ _2388_ _2417_ _2432_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__a21o_1
X_7789_ net196 adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _3395_ sky130_fd_sc_hd__or2_2
XFILLER_11_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8497__A0 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9459_ clknet_leaf_26_clk _0077_ _0369_ VGND VGND VPWR VPWR mul_res\[14\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_115_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout493 net494 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__buf_2
Xfanout482 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__clkbuf_4
Xfanout460 adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__clkbuf_4
Xfanout471 net472 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__buf_1
XFILLER_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8421__A0 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5848__D net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7418__A net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_77_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4777__A net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8249__A net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5140_ _0766_ _0769_ _0752_ _0753_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__a211oi_2
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5071_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__inv_2
XFILLER_56_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8830_ _3242_ net102 _3235_ VGND VGND VPWR VPWR _4323_ sky130_fd_sc_hd__a21bo_1
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8761_ net802 _4272_ _0104_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a21o_1
XFILLER_92_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5973_ _1586_ _1587_ _1602_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__nor3_1
XFILLER_25_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7712_ _3335_ VGND VGND VPWR VPWR _3336_ sky130_fd_sc_hd__inv_2
X_4924_ _0552_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__xnor2_1
XFILLER_80_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8692_ _4243_ _4244_ net107 VGND VGND VPWR VPWR _4245_ sky130_fd_sc_hd__o21a_4
XFILLER_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7643_ net613 _3272_ _3271_ _3155_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[1\]
+ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_119_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4855_ net374 net380 net262 net268 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__and4_1
XFILLER_20_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout228_A net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4786_ _4554_ _4555_ _4556_ VGND VGND VPWR VPWR _4557_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_119_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7574_ net109 _3203_ VGND VGND VPWR VPWR _3204_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_31_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9313_ clknet_leaf_13_clk net746 _0223_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_2
X_6525_ _2139_ _2153_ _2154_ _2077_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__a211oi_1
XFILLER_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_132_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9244_ clknet_leaf_1_clk net38 _0154_ VGND VGND VPWR VPWR adder_inst.i_b\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_134_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6456_ _2084_ _2085_ net273 net472 VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__and4bb_1
X_5407_ _1025_ _1026_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__and2_1
XFILLER_88_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9175_ net532 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__inv_2
XANTENNA__4687__A net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6387_ _2016_ _2012_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__and2b_1
XANTENNA__5701__A1 net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5701__B2 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8126_ net151 net149 net148 VGND VGND VPWR VPWR _3700_ sky130_fd_sc_hd__or3_1
X_5338_ net147 _0875_ _0917_ _0959_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__o211a_1
XFILLER_114_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8057_ net501 _4347_ _3401_ _3635_ _3398_ VGND VGND VPWR VPWR _3636_ sky130_fd_sc_hd__o311a_1
XFILLER_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_110_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5269_ _0805_ _0897_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout385_X net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7008_ _2615_ _2637_ VGND VGND VPWR VPWR _2638_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_48_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_39_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5311__A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8959_ net530 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__inv_2
XANTENNA__6126__B net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6965__B1 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input60_A i_b[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8069__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7996__A2 net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7123__D net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout290 net291 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__clkbuf_4
XFILLER_75_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6317__A net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5859__C net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5208__B1 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4640_ net270 _4398_ _4410_ VGND VGND VPWR VPWR _4411_ sky130_fd_sc_hd__a21bo_1
XANTENNA__6184__A1 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7920__A2 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6184__B2 net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4571_ net493 VGND VGND VPWR VPWR _4343_ sky130_fd_sc_hd__inv_2
XANTENNA__6987__A net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6310_ _1937_ _1938_ _1931_ _1934_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__a211o_1
XFILLER_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7290_ _2917_ _2918_ VGND VGND VPWR VPWR _2920_ sky130_fd_sc_hd__xor2_1
XFILLER_131_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8881__B1 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6241_ net247 net475 net481 net242 VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__a22o_1
XFILLER_131_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4938__C net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6172_ _1703_ _1799_ _1798_ _1775_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__o211a_1
X_5123_ _0750_ _0751_ _0668_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o21a_1
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5054_ _0603_ _0682_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__and3_1
XFILLER_97_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5769__C net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8813_ _3194_ _3198_ VGND VGND VPWR VPWR multiplier_inst.man_final\[6\] sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8744_ net849 net181 net177 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__and3_1
XFILLER_80_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout345_A net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5956_ _1583_ _1584_ _1585_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__and3_1
X_8675_ _4230_ _4050_ VGND VGND VPWR VPWR adder_inst.sum_raw\[17\] sky130_fd_sc_hd__xnor2_2
X_4907_ _0522_ _0523_ _0534_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a21oi_1
XFILLER_33_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5887_ net347 net341 net329 net336 VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout512_A net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4838_ net349 net609 net304 net342 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__a22o_1
X_7626_ net592 _3255_ VGND VGND VPWR VPWR _3256_ sky130_fd_sc_hd__nand2_1
XANTENNA__7058__A net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4769_ _4474_ _4477_ _4538_ _4539_ VGND VGND VPWR VPWR _4540_ sky130_fd_sc_hd__o211ai_1
X_7557_ _2952_ _3186_ VGND VGND VPWR VPWR _3187_ sky130_fd_sc_hd__xor2_2
XFILLER_119_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7488_ _3110_ _3113_ _3116_ VGND VGND VPWR VPWR _3118_ sky130_fd_sc_hd__or3_1
XANTENNA__7124__B1 net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout300_X net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6508_ _2054_ _2055_ _2060_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__a21o_1
X_9227_ clknet_leaf_9_clk net22 _0137_ VGND VGND VPWR VPWR adder_inst.exp_a\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_136_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6439_ _2066_ _2068_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__and2b_1
X_9158_ net547 VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_112_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8109_ _3303_ _3341_ _3663_ _3681_ VGND VGND VPWR VPWR _3683_ sky130_fd_sc_hd__or4_4
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9089_ net520 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__inv_2
XFILLER_102_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5041__A net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4880__A net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5610__B1 net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7415__B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6957__D net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5589__C net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer19 _2103_ VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_85_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5886__A net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5101__D net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6790_ net324 net458 VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__nand2_1
X_5810_ _1437_ _1438_ _1436_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__a21bo_1
XFILLER_22_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5741_ _1363_ _1364_ _1369_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21o_1
X_8460_ _4030_ _4032_ VGND VGND VPWR VPWR _4033_ sky130_fd_sc_hd__nand2_1
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer109 net657 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd1_1
X_7411_ net203 net378 _4527_ _4525_ VGND VGND VPWR VPWR _3041_ sky130_fd_sc_hd__a31o_1
X_5672_ net377 net326 VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__and2_1
X_8391_ _3962_ _3963_ VGND VGND VPWR VPWR _3964_ sky130_fd_sc_hd__nor2_1
X_4623_ net356 net361 net246 net252 VGND VGND VPWR VPWR _4394_ sky130_fd_sc_hd__nand4_1
XANTENNA__7028__D net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7342_ _2969_ _2970_ VGND VGND VPWR VPWR _2972_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4949__B net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7273_ _2823_ _2824_ _2825_ VGND VGND VPWR VPWR _2903_ sky130_fd_sc_hd__a21o_1
XFILLER_116_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9012_ net510 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__inv_2
X_6224_ _1782_ _1784_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__xnor2_1
XFILLER_112_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout295_A net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6155_ net253 net468 _1783_ _1781_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__a31o_1
X_5106_ _0729_ _0734_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__xor2_1
XFILLER_100_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4684__B net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6086_ _1713_ _1715_ _1622_ _1623_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__a211oi_1
XANTENNA__8871__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_127_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5037_ _0666_ _0665_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and2b_1
XFILLER_85_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout462_A net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout250_X net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout348_X net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6107__D net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5796__A net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8727_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] net166 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[6\] sky130_fd_sc_hd__mux2_1
XANTENNA__7593__B1 _1082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6988_ net391 net397 net277 net284 VGND VGND VPWR VPWR _2618_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_0_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5939_ _1545_ _1546_ _1568_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__and3_1
X_8658_ _3954_ _3965_ _4012_ _4163_ _3955_ VGND VGND VPWR VPWR _4215_ sky130_fd_sc_hd__o221a_1
XANTENNA_hold305_A multiplier_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8589_ _3925_ _4099_ _4115_ _3924_ VGND VGND VPWR VPWR _4155_ sky130_fd_sc_hd__o211a_1
X_7609_ _4370_ net131 _3151_ _3223_ _3233_ VGND VGND VPWR VPWR _3239_ sky130_fd_sc_hd__a311o_1
XFILLER_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5371__A2 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6320__A1 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput88 net88 VGND VGND VPWR VPWR o_res[28] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR o_res[18] sky130_fd_sc_hd__buf_2
XFILLER_88_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput99 net99 VGND VGND VPWR VPWR o_res[9] sky130_fd_sc_hd__buf_2
XFILLER_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7522__Y _3152_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4882__B2 net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4882__A1 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input23_A i_a[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5831__B1 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7887__A1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7960_ net114 _3554_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__and2_1
XFILLER_55_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7891_ _3389_ _3496_ _3495_ VGND VGND VPWR VPWR _3497_ sky130_fd_sc_hd__a21boi_1
XFILLER_35_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6911_ net328 net334 net470 net478 VGND VGND VPWR VPWR _2541_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_46_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6842_ _2467_ _2470_ _2471_ VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_122_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4951__C net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6773_ net283 net477 _2393_ _2396_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__a211oi_1
X_8512_ net346 net165 _4084_ VGND VGND VPWR VPWR _4085_ sky130_fd_sc_hd__a21o_1
X_9492_ clknet_leaf_21_clk net799 _0402_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5724_ _1193_ _1208_ _1207_ _1200_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_98_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8443_ net139 _3794_ _4014_ _4015_ net125 VGND VGND VPWR VPWR _4016_ sky130_fd_sc_hd__o221a_1
XANTENNA__7607__Y _3237_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5655_ net377 net383 net331 net339 VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__nand4_1
X_8374_ _3945_ _3946_ VGND VGND VPWR VPWR _3947_ sky130_fd_sc_hd__nand2b_2
XANTENNA_fanout210_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4606_ net351 net214 net357 net209 VGND VGND VPWR VPWR _4377_ sky130_fd_sc_hd__a22oi_1
X_7325_ _2900_ _2908_ VGND VGND VPWR VPWR _2955_ sky130_fd_sc_hd__xnor2_2
X_5586_ _1210_ _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__nand2b_1
XANTENNA_fanout308_A net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8866__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9324__Q adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7256_ _2881_ _2885_ _0974_ _2801_ VGND VGND VPWR VPWR _2886_ sky130_fd_sc_hd__o211a_1
XFILLER_132_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4695__A net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7187_ _2815_ _2816_ VGND VGND VPWR VPWR _2817_ sky130_fd_sc_hd__and2_1
X_6207_ _1737_ _1739_ _1738_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__o21ai_1
XFILLER_86_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout298_X net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7071__A net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6138_ _1747_ _1745_ _1766_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__and3_1
XFILLER_133_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6066__B1 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout465_X net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6069_ _1671_ _1673_ _1698_ _1279_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__a211oi_2
XFILLER_38_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6369__A1 net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4589__B net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_48_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5867__C net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5583__A2 net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5440_ _1042_ _1061_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__a21o_1
XFILLER_9_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6060__A net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_57_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6532__A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6532__B2 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5371_ net234 net387 net393 net228 VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a22oi_1
XFILLER_114_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6995__A net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8090_ net642 _3327_ _3662_ _3343_ _3326_ VGND VGND VPWR VPWR _3664_ sky130_fd_sc_hd__a311o_4
XTAP_TAPCELL_ROW_93_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7110_ net255 net419 _2627_ _2626_ VGND VGND VPWR VPWR _2740_ sky130_fd_sc_hd__a31o_1
XFILLER_114_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout108 _4114_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_12
Xfanout119 _3732_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_2
XANTENNA__7603__B _1153_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7041_ _2664_ _2669_ VGND VGND VPWR VPWR _2671_ sky130_fd_sc_hd__xnor2_1
XFILLER_67_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8992_ net515 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__inv_2
XFILLER_95_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4665__D net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7943_ net194 adder_inst.sum_raw_r\[23\] adder_inst.sum_raw_r\[9\] VGND VGND VPWR
+ VPWR _3540_ sky130_fd_sc_hd__and3_1
XFILLER_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout160_A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7874_ adder_inst.exp_larger_r\[1\] _3383_ _3474_ net485 VGND VGND VPWR VPWR _3480_
+ sky130_fd_sc_hd__a2bb2o_1
XANTENNA_fanout258_A adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6825_ _2452_ _2454_ VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_102_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8450__A net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout425_A net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5574__A2 net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6756_ _2384_ _2385_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_102_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5707_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__inv_2
X_9475_ clknet_leaf_14_clk _0095_ _0385_ VGND VGND VPWR VPWR mul_res\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6687_ _2304_ _2306_ _2298_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__a21oi_1
XFILLER_136_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_135_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8426_ net281 net163 VGND VGND VPWR VPWR _3999_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout213_X net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5638_ _1220_ _1221_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__xnor2_1
XFILLER_117_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8357_ adder_inst.man_b_r\[8\] net162 VGND VGND VPWR VPWR _3930_ sky130_fd_sc_hd__or2_1
X_5569_ _1177_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_1
Xhold140 adder_inst.i_vld_r VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7308_ _2894_ _2936_ VGND VGND VPWR VPWR _2938_ sky130_fd_sc_hd__xor2_1
Xhold162 adder_inst.i_a\[7\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
Xhold151 adder_inst.i_b\[3\] VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 adder_inst.exp_b\[5\] VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 adder_inst.exp_b\[2\] VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlygate4sd3_1
X_8288_ net145 _3858_ _3860_ net124 VGND VGND VPWR VPWR _3861_ sky130_fd_sc_hd__a211o_1
XFILLER_78_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold173 adder_inst.i_a\[0\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_120_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7239_ _2865_ _2867_ _2868_ VGND VGND VPWR VPWR _2869_ sky130_fd_sc_hd__nand3_1
XANTENNA__8028__B2 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4872__B net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5262__B2 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5262__A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4591__C net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5565__A2 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5317__A2 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9191__A net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6030__D net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8019__B2 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8019__A1 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7778__B1 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4940_ net251 net405 net409 net245 VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a22oi_1
X_4871_ _0480_ _0494_ _0499_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a21o_1
XFILLER_33_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7590_ net113 _3200_ _3201_ _3219_ VGND VGND VPWR VPWR _3220_ sky130_fd_sc_hd__o31a_1
X_6610_ _2229_ _2238_ _2239_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__and3_1
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5894__A net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6541_ _2165_ _2167_ _2169_ _2170_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__a211oi_1
XANTENNA__6753__B2 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6753__A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_65_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6502__B net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9260_ clknet_leaf_8_clk net56 _0170_ VGND VGND VPWR VPWR adder_inst.exp_b\[7\] sky130_fd_sc_hd__dfrtp_1
X_6472_ _2009_ _2010_ _2024_ _2025_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__a2bb2o_1
X_9191_ net548 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__inv_2
X_5423_ net217 net403 net410 net207 VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a22oi_1
X_8211_ net136 _3761_ VGND VGND VPWR VPWR _3784_ sky130_fd_sc_hd__and2_1
XFILLER_114_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5354_ _0724_ _0982_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__o21a_1
X_8142_ net316 net457 net154 VGND VGND VPWR VPWR _3716_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_130_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8073_ net199 _3650_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and2_1
XFILLER_114_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5285_ _0896_ _0912_ _0913_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__and4_1
X_7024_ _1574_ _1582_ _1581_ VGND VGND VPWR VPWR _2654_ sky130_fd_sc_hd__a21bo_1
XFILLER_114_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4973__A net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout375_A net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4692__B net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8975_ net507 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout542_A net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7926_ adder_inst.sum_raw_r\[2\] _3405_ _3524_ adder_inst.sum_raw_r\[1\] _3522_ VGND
+ VGND VPWR VPWR _3525_ sky130_fd_sc_hd__o221a_1
XANTENNA__8194__A0 net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7857_ net491 net189 VGND VGND VPWR VPWR _3463_ sky130_fd_sc_hd__nand2_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8180__A adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout330_X net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6808_ _2434_ _2436_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout428_X net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7788_ net484 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3394_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_83_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6739_ _2314_ _2367_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__xnor2_1
X_9458_ clknet_leaf_25_clk _0076_ _0368_ VGND VGND VPWR VPWR mul_res\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8409_ net264 net159 _3978_ _3981_ VGND VGND VPWR VPWR _3982_ sky130_fd_sc_hd__a22oi_2
XFILLER_3_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7524__A net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9389_ clknet_leaf_15_clk adder_inst.exp_larger\[3\] _0299_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_117_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_92_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout450 net451 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_4
XFILLER_120_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout483 net484 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__buf_2
XFILLER_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout472 net473 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__clkbuf_4
Xfanout461 net462 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__buf_2
Xfanout494 adder_inst.sum_raw_r\[20\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7418__B net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4777__B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5070_ _0697_ _0698_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__and3_1
XFILLER_111_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8766__A_N multiplier_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_643 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8760_ net848 _4272_ _0104_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a21o_1
XFILLER_64_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5972_ _1595_ _1600_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__xnor2_1
X_7711_ _3317_ _3333_ VGND VGND VPWR VPWR _3335_ sky130_fd_sc_hd__and2_1
X_4923_ net200 net432 VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
XFILLER_64_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8691_ _4044_ _4231_ VGND VGND VPWR VPWR _4244_ sky130_fd_sc_hd__nor2_1
X_7642_ _4354_ _3157_ VGND VGND VPWR VPWR _3272_ sky130_fd_sc_hd__nor2_1
XFILLER_100_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4854_ net386 net256 VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand2_1
XFILLER_33_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4785_ net374 net244 net250 net368 VGND VGND VPWR VPWR _4556_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_119_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7573_ _3197_ _3202_ net111 VGND VGND VPWR VPWR _3203_ sky130_fd_sc_hd__mux2_1
XFILLER_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9312_ clknet_leaf_16_clk _0035_ _0222_ VGND VGND VPWR VPWR adder_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__8479__A1 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6524_ _2064_ _2065_ _2076_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_132_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9243_ clknet_leaf_1_clk net37 _0153_ VGND VGND VPWR VPWR adder_inst.i_b\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_134_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6455_ net283 net459 net465 net276 VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__a22oi_1
X_5406_ _1030_ net558 VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__xor2_2
X_9174_ net531 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__inv_2
XANTENNA__5701__A2 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6386_ _2013_ _2015_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__nor2_1
XANTENNA__8874__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8727__X adder_inst.exp_larger\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8125_ _3696_ _3697_ VGND VGND VPWR VPWR _3699_ sky130_fd_sc_hd__xnor2_4
XANTENNA_fanout492_A net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5337_ _0964_ _0965_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__xor2_1
XFILLER_0_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8056_ net501 adder_inst.exp_larger_r\[4\] _3399_ VGND VGND VPWR VPWR _3635_ sky130_fd_sc_hd__nand3_1
XFILLER_88_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5268_ _0802_ _0803_ _0804_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__a21o_1
XFILLER_102_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7007_ _2635_ _2636_ VGND VGND VPWR VPWR _2637_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_110_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout280_X net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout378_X net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5199_ _0825_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand2b_1
XFILLER_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8958_ net530 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__inv_2
XFILLER_83_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5311__B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6965__A1 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7909_ adder_inst.sum_raw_r\[0\] net496 _3472_ _3510_ VGND VGND VPWR VPWR _3511_
+ sky130_fd_sc_hd__a31o_1
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6965__B2 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8167__A0 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8889_ net508 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__inv_2
XFILLER_12_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4728__B1 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5039__A net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input53_A i_b[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout280 net281 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_4
XFILLER_59_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_4
XFILLER_74_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5208__A1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6317__B net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5859__D net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5208__B2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8091__Y _3665_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4570_ net490 VGND VGND VPWR VPWR _4342_ sky130_fd_sc_hd__inv_2
XFILLER_128_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6987__B net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_3_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6240_ net253 net475 _1868_ _1866_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__a31o_1
XFILLER_112_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4938__D net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6171_ _1778_ _1796_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__nor2_1
XFILLER_124_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5122_ _0668_ _0750_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nor3_2
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5053_ _0674_ _0675_ _0680_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__o21bai_1
XFILLER_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5769__D net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8812_ _3191_ _4312_ _3194_ VGND VGND VPWR VPWR multiplier_inst.man_final\[5\] sky130_fd_sc_hd__o21ba_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8743_ net846 net179 net177 VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__and3_1
X_5955_ _1475_ _1483_ _1482_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout240_A adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8674_ net175 _4224_ _4225_ _4228_ _4229_ VGND VGND VPWR VPWR _4230_ sky130_fd_sc_hd__o32a_4
X_4906_ _0522_ _0523_ _0534_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand3_1
XFILLER_80_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5886_ net354 net325 VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout338_A net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8869__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4837_ net342 _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__and2_1
X_7625_ _3076_ _3254_ VGND VGND VPWR VPWR _3255_ sky130_fd_sc_hd__xor2_1
XANTENNA__7058__B net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout505_A net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4768_ _4536_ _4537_ _4509_ VGND VGND VPWR VPWR _4539_ sky130_fd_sc_hd__o21bai_1
X_7556_ _2983_ _3004_ _3175_ _3023_ VGND VGND VPWR VPWR _3186_ sky130_fd_sc_hd__a31o_1
XFILLER_5_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4699_ _4468_ _4469_ VGND VGND VPWR VPWR _4470_ sky130_fd_sc_hd__nand2_1
X_7487_ _3113_ _3116_ _3110_ VGND VGND VPWR VPWR _3117_ sky130_fd_sc_hd__o21ai_1
XANTENNA__7124__A1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7124__B2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6507_ _2130_ _2135_ _2129_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__a21bo_1
X_9226_ clknet_leaf_9_clk net21 _0136_ VGND VGND VPWR VPWR adder_inst.exp_a\[5\] sky130_fd_sc_hd__dfrtp_1
X_6438_ net301 net443 net448 net294 VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__a22o_1
X_9157_ net538 VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_112_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8108_ _3304_ _3660_ _3303_ VGND VGND VPWR VPWR _3682_ sky130_fd_sc_hd__o21ba_1
X_6369_ net290 net448 _1997_ _1995_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__a31o_1
X_9088_ net520 VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8039_ net501 net499 VGND VGND VPWR VPWR _3623_ sky130_fd_sc_hd__nand2b_1
XFILLER_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6418__A net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5041__B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4880__B net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5610__A1 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5610__B2 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5589__D net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_616 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5740_ _1363_ _1364_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__nand3_1
X_7410_ _4534_ _3038_ VGND VGND VPWR VPWR _3040_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5671_ _1290_ _1292_ _1291_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__o21bai_1
X_8390_ net399 _3960_ net159 VGND VGND VPWR VPWR _3963_ sky130_fd_sc_hd__mux2_1
X_4622_ net131 _4392_ VGND VGND VPWR VPWR _4393_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7341_ _2919_ _2927_ _2969_ VGND VGND VPWR VPWR _2971_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_96_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4949__C net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7272_ _2699_ _2707_ _2706_ VGND VGND VPWR VPWR _2902_ sky130_fd_sc_hd__a21o_1
XFILLER_116_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9011_ net507 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__inv_2
X_6223_ _1758_ _1846_ _1851_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__a21o_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6154_ _1781_ _1783_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__and2b_1
X_5105_ _0729_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__nand2_1
XFILLER_58_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6085_ _1708_ _1713_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__nand3b_2
XTAP_TAPCELL_ROW_127_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5036_ _0651_ _0653_ _0650_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__o21ba_1
XFILLER_85_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4684__C net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout455_A net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7593__A1 _1153_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6987_ net400 net273 VGND VGND VPWR VPWR _2617_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5796__B net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8726_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] net166 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[5\] sky130_fd_sc_hd__mux2_1
XFILLER_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout243_X net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5938_ _1566_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_0_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8657_ _3988_ _4213_ _4200_ VGND VGND VPWR VPWR _4214_ sky130_fd_sc_hd__o21ai_1
X_5869_ _1498_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__inv_2
XFILLER_139_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout410_X net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8588_ _3921_ _3923_ VGND VGND VPWR VPWR _4154_ sky130_fd_sc_hd__or2_1
X_7608_ _3217_ _3237_ net112 VGND VGND VPWR VPWR _3238_ sky130_fd_sc_hd__mux2_1
XFILLER_119_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7539_ net618 _3160_ _3168_ VGND VGND VPWR VPWR _3169_ sky130_fd_sc_hd__a21o_1
XFILLER_134_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9209_ clknet_leaf_6_clk net3 _0119_ VGND VGND VPWR VPWR adder_inst.i_a\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_134_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6320__A2 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput89 net89 VGND VGND VPWR VPWR o_res[29] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR o_res[19] sky130_fd_sc_hd__buf_2
XFILLER_103_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4882__A2 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input16_A i_a[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5831__A1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5831__B2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_2_0__f_clk_X clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7595__C_N _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6058__A net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4578__A_N adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7890_ adder_inst.exp_larger_r\[0\] adder_inst.exp_larger_r\[6\] adder_inst.exp_larger_r\[7\]
+ net485 VGND VGND VPWR VPWR _3496_ sky130_fd_sc_hd__and4b_1
XFILLER_94_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6910_ _2524_ _2539_ VGND VGND VPWR VPWR _2540_ sky130_fd_sc_hd__nor2_1
XFILLER_35_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6841_ _2431_ _2450_ _2466_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_122_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4951__D net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8511_ _3904_ _3979_ net123 VGND VGND VPWR VPWR _4084_ sky130_fd_sc_hd__and3b_2
X_6772_ _2393_ _2396_ net283 net477 VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__o211a_1
X_9491_ clknet_leaf_25_clk net773 _0401_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
X_5723_ _1350_ _1351_ _1316_ _1319_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__o211ai_4
XFILLER_31_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8442_ net655 _3723_ net139 VGND VGND VPWR VPWR _4015_ sky130_fd_sc_hd__o21ai_1
X_5654_ _1282_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__or2_1
X_8373_ _3942_ _3944_ VGND VGND VPWR VPWR _3946_ sky130_fd_sc_hd__nand2_1
X_4605_ net351 net209 net215 net357 VGND VGND VPWR VPWR _4376_ sky130_fd_sc_hd__and4_1
Xhold300 multiplier_inst.man_final_r\[13\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
X_7324_ _2712_ _2734_ _2711_ VGND VGND VPWR VPWR _2954_ sky130_fd_sc_hd__a21o_1
X_5585_ _1211_ _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout203_A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6838__B1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8448__A net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7255_ _2882_ _2884_ VGND VGND VPWR VPWR _2885_ sky130_fd_sc_hd__and2_1
XANTENNA__4695__B net639 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7186_ _2813_ _2814_ _2810_ VGND VGND VPWR VPWR _2816_ sky130_fd_sc_hd__a21o_1
X_6206_ _1820_ _1822_ _1821_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__o21bai_1
XANTENNA_input8_A i_a[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7071__B net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6137_ _1745_ _1747_ _1766_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__a21oi_2
XFILLER_58_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6066__B2 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6066__A1 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6068_ _1269_ _1270_ _1278_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__o21a_1
X_5019_ _0646_ _0647_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__xor2_1
XANTENNA_fanout360_X net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout458_X net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_107_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8763__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6369__A2 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8709_ _4069_ _4070_ VGND VGND VPWR VPWR _4260_ sky130_fd_sc_hd__and2_1
XFILLER_10_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5047__A net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4886__A net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_69_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8093__A _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6606__A net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8754__B1 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_103_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5867__D net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6060__B net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6532__A2 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5370_ net228 net234 net387 net393 VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_112_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7603__C _3222_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7040_ _2664_ _2669_ VGND VGND VPWR VPWR _2670_ sky130_fd_sc_hd__and2_1
XFILLER_86_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8991_ net515 VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__inv_2
XFILLER_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7942_ adder_inst.sum_raw_r\[8\] net189 net169 adder_inst.sum_raw_r\[7\] net184 VGND
+ VGND VPWR VPWR _3539_ sky130_fd_sc_hd__o221a_1
XFILLER_67_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_121_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7873_ net488 _3476_ _3478_ net184 VGND VGND VPWR VPWR _3479_ sky130_fd_sc_hd__o211a_1
XFILLER_51_711 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6824_ net454 net335 net460 net330 VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__a22oi_1
XANTENNA__8450__B net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6755_ net305 net464 VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__nand2_1
X_9474_ clknet_leaf_16_clk _0093_ _0384_ VGND VGND VPWR VPWR mul_res\[29\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout320_A net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5706_ _1320_ _1334_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__nand3_2
XFILLER_109_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8425_ _3678_ _3842_ _3846_ net124 net119 VGND VGND VPWR VPWR _3998_ sky130_fd_sc_hd__a221o_1
Xclkbuf_leaf_30_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
X_6686_ _2261_ _2308_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__xnor2_2
XANTENNA_fanout418_A net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8877__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_130_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5637_ _1265_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__nand2_1
X_8356_ _3677_ _3759_ _3775_ net122 net120 VGND VGND VPWR VPWR _3929_ sky130_fd_sc_hd__o221a_1
XANTENNA_fanout206_X net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5568_ net271 net433 _1175_ _1176_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__o2bb2a_1
Xhold141 adder_inst.i_a\[31\] VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 adder_inst.i_a\[17\] VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
X_8287_ net142 _3797_ _3859_ net145 VGND VGND VPWR VPWR _3860_ sky130_fd_sc_hd__a211oi_1
X_7307_ _2894_ _2936_ VGND VGND VPWR VPWR _2937_ sky130_fd_sc_hd__nor2_1
Xhold163 adder_inst.i_a\[21\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
X_5499_ _1128_ _1119_ _1106_ _1117_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a211oi_4
XFILLER_105_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold185 adder_inst.i_b\[0\] VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlygate4sd3_1
X_7238_ _0953_ _2866_ _2832_ _2830_ VGND VGND VPWR VPWR _2868_ sky130_fd_sc_hd__o211ai_2
Xhold174 adder_inst.i_b\[2\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
Xhold196 adder_inst.exp_a\[3\] VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8028__A2 net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7169_ _2798_ _2797_ VGND VGND VPWR VPWR _2799_ sky130_fd_sc_hd__nor2_4
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6426__A net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_29_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5262__A2 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4591__D net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_21_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_6_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer11_X net560 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7227__B1 net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8027__S net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4870_ _0480_ _0494_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand3_1
XFILLER_60_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5894__B net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7950__A1 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6540_ _2148_ _2150_ _2168_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__and3_1
XFILLER_20_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_12_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_9_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6502__C net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6471_ _2080_ _2081_ _2099_ _2100_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__and4bb_1
X_9190_ net548 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__inv_2
X_5422_ net207 net217 net403 net410 VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and4_1
X_8210_ _3782_ _3783_ VGND VGND VPWR VPWR adder_inst.sum_raw\[0\] sky130_fd_sc_hd__nand2_1
XANTENNA__5713__B1 net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5353_ _4409_ _4411_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__xor2_1
X_8141_ net309 net599 net154 VGND VGND VPWR VPWR _3715_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8072_ _3643_ _3648_ _3649_ _3628_ VGND VGND VPWR VPWR _3650_ sky130_fd_sc_hd__a31o_1
XFILLER_99_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5284_ _0789_ _0895_ _0894_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a21o_1
X_7023_ _2650_ _2651_ _2643_ VGND VGND VPWR VPWR _2653_ sky130_fd_sc_hd__a21o_1
XFILLER_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4973__B net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout368_A net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4692__C net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8974_ net510 VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_104_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7925_ net192 _3445_ VGND VGND VPWR VPWR _3524_ sky130_fd_sc_hd__nand2_1
XFILLER_83_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8194__A1 net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7856_ _4342_ net489 VGND VGND VPWR VPWR _3462_ sky130_fd_sc_hd__nor2_2
XANTENNA_fanout156_X net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6807_ _2436_ _2434_ VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__and2b_1
X_4999_ net239 net393 VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nand2_1
XANTENNA__8180__B _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7787_ net484 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3393_ sky130_fd_sc_hd__nor2_1
XANTENNA__4755__A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4755__B2 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer6_A net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout323_X net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6738_ _2315_ _2367_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__nor2_1
XFILLER_139_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9457_ clknet_leaf_25_clk _0075_ _0367_ VGND VGND VPWR VPWR mul_res\[12\] sky130_fd_sc_hd__dfrtp_1
X_6669_ _2283_ _2290_ _2297_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__and3_1
X_9388_ clknet_leaf_12_clk adder_inst.exp_larger\[2\] _0298_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[2\]
+ sky130_fd_sc_hd__dfrtp_2
XANTENNA__7805__A net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8408_ net159 _3732_ VGND VGND VPWR VPWR _3981_ sky130_fd_sc_hd__nor2_1
XANTENNA__7524__B net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8339_ net145 _3833_ VGND VGND VPWR VPWR _3912_ sky130_fd_sc_hd__nor2_1
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7457__B1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout440 net441 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout484 net486 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_2
Xfanout451 net598 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_4
Xfanout473 net476 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__buf_1
XFILLER_48_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout462 net463 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout495 net496 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__buf_2
XFILLER_86_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5995__A net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__9352__D net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7999__A1 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7999__B2 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_65_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5971_ _1595_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__and2_1
XFILLER_18_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7710_ _3152_ _3317_ _3333_ VGND VGND VPWR VPWR _3334_ sky130_fd_sc_hd__a21o_1
X_8690_ _4031_ _4041_ _4032_ VGND VGND VPWR VPWR _4243_ sky130_fd_sc_hd__o21ai_1
X_4922_ _0550_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nor2_1
XFILLER_52_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7641_ _3157_ _3270_ VGND VGND VPWR VPWR _3271_ sky130_fd_sc_hd__nor2_1
X_4853_ _0475_ _0476_ _0481_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__a21o_1
XFILLER_100_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4784_ net239 net381 VGND VGND VPWR VPWR _4555_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_119_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7572_ _3200_ _3201_ VGND VGND VPWR VPWR _3202_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_31_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9311_ clknet_2_1__leaf_clk adder_inst.man_a\[23\] _0221_ VGND VGND VPWR VPWR adder_inst.man_a_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_6523_ _2139_ _2140_ _2151_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_132_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9242_ clknet_leaf_3_clk net36 _0152_ VGND VGND VPWR VPWR adder_inst.i_b\[12\] sky130_fd_sc_hd__dfrtp_1
X_6454_ net276 net283 net459 net465 VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__and4_1
XFILLER_118_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5405_ _1034_ _1033_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__or2_4
XFILLER_133_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9173_ net531 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__inv_2
X_6385_ _2013_ _2014_ net273 net465 VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__and4bb_1
XFILLER_125_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8100__A1 _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8124_ _3696_ _3697_ VGND VGND VPWR VPWR _3698_ sky130_fd_sc_hd__xor2_1
X_5336_ _0965_ _0964_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8055_ _3395_ _3411_ _3470_ VGND VGND VPWR VPWR _3634_ sky130_fd_sc_hd__o21ba_1
X_5267_ _0884_ _0889_ _0883_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout485_A net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7006_ _2632_ _2634_ _1555_ _1562_ VGND VGND VPWR VPWR _2636_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_110_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5198_ _0825_ _0826_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or3_1
XFILLER_29_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout273_X net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8957_ net530 VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__inv_2
XANTENNA__5311__C net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7908_ adder_inst.sum_raw_r\[1\] net492 _3413_ _3509_ VGND VGND VPWR VPWR _3510_
+ sky130_fd_sc_hd__a31o_1
XFILLER_70_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8167__A1 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8888_ net507 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__inv_2
XFILLER_34_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7839_ net501 _4341_ VGND VGND VPWR VPWR _3445_ sky130_fd_sc_hd__and2_1
XFILLER_12_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4728__B2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4728__A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5039__B net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload0 clknet_2_0__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_8
XFILLER_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input46_A i_b[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout270 adder_inst.man_b_r\[12\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__buf_4
XFILLER_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout281 net282 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_4
Xfanout292 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_6
XFILLER_59_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5208__A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6170_ _1775_ _1798_ _1799_ net129 VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__a211oi_4
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5121_ _0740_ _0741_ _0745_ _0749_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a211oi_1
XFILLER_111_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5052_ _0674_ _0675_ _0680_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or3b_1
XFILLER_93_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8811_ _4312_ _4313_ VGND VGND VPWR VPWR multiplier_inst.man_final\[4\] sky130_fd_sc_hd__nor2_1
XFILLER_38_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8742_ net832 net179 net177 VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__and3_1
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8149__A1 net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5954_ _1581_ _1582_ _1574_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__a21o_1
XFILLER_41_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8673_ _4054_ net683 _4226_ net188 VGND VGND VPWR VPWR _4229_ sky130_fd_sc_hd__a31o_1
X_4905_ _0522_ _0523_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__and3_1
XFILLER_80_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5885_ _1417_ _1420_ _1419_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__o21bai_1
X_4836_ net349 net298 net301 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and3_1
X_7624_ _4542_ _0456_ _3036_ VGND VGND VPWR VPWR _3254_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout233_A net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7555_ _3173_ _3184_ VGND VGND VPWR VPWR _3185_ sky130_fd_sc_hd__or2_1
X_4767_ _4536_ _4537_ _4509_ VGND VGND VPWR VPWR _4538_ sky130_fd_sc_hd__or3b_1
X_6506_ _2129_ _2130_ _2135_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__nand3_1
XFILLER_106_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout400_A net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4698_ _4462_ _4467_ VGND VGND VPWR VPWR _4469_ sky130_fd_sc_hd__or2_1
X_7486_ _3114_ _3115_ VGND VGND VPWR VPWR _3116_ sky130_fd_sc_hd__and2_1
XANTENNA__7124__A2 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9225_ clknet_leaf_9_clk net20 _0135_ VGND VGND VPWR VPWR adder_inst.exp_a\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_105_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6437_ net289 net453 VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__nand2_1
X_9156_ net547 VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__inv_2
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6368_ _1995_ _1997_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__and2b_1
X_8107_ _3304_ _3656_ VGND VGND VPWR VPWR _3681_ sky130_fd_sc_hd__nor2_1
XFILLER_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5319_ net200 net449 VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__nand2_1
X_9087_ net520 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__inv_2
XFILLER_102_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6299_ _1927_ _1928_ net271 net462 VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__and4bb_1
XFILLER_102_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8038_ net491 _3621_ _3428_ VGND VGND VPWR VPWR _3622_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6418__B net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4880__C net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5610__A2 net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_761 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5062__B1 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5670_ _1296_ _1298_ _1295_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a21bo_1
XANTENNA_clkbuf_0_clk_A clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4621_ _4371_ _4388_ _4390_ VGND VGND VPWR VPWR _4392_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_41_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8303__A1 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7340_ _2919_ _2927_ VGND VGND VPWR VPWR _2970_ sky130_fd_sc_hd__nor2_1
XANTENNA__4949__D net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7271_ _2720_ _2727_ VGND VGND VPWR VPWR _2901_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_96_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9010_ net508 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__inv_2
X_6222_ _1758_ _1846_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__nand3_2
XFILLER_131_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6153_ net267 net456 net462 net260 VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__a22o_1
X_5104_ _0730_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6084_ net556 _1712_ _1711_ _1706_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_127_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5035_ _0663_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__nor2_1
XFILLER_25_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout350_A adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout448_A net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6986_ _1532_ _1540_ _1539_ VGND VGND VPWR VPWR _2616_ sky130_fd_sc_hd__a21o_1
X_8725_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] net166 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[4\] sky130_fd_sc_hd__mux2_1
XANTENNA__7593__A2 _3222_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5937_ _1564_ _1565_ _1547_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_0_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8656_ _4009_ _4176_ _4185_ VGND VGND VPWR VPWR _4213_ sky130_fd_sc_hd__o21a_1
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout236_X net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7607_ _1115_ _3236_ VGND VGND VPWR VPWR _3237_ sky130_fd_sc_hd__xnor2_2
X_5868_ _1496_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__or2_1
X_4819_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nor2_1
X_8587_ _4147_ _4146_ _3926_ VGND VGND VPWR VPWR _4153_ sky130_fd_sc_hd__a21o_1
XANTENNA__7085__A net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5799_ _1425_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout403_X net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7538_ _4370_ net131 _3151_ _3167_ VGND VGND VPWR VPWR _3168_ sky130_fd_sc_hd__and4_1
X_7469_ _4375_ _4381_ VGND VGND VPWR VPWR _3099_ sky130_fd_sc_hd__xnor2_2
X_9208_ clknet_leaf_3_clk net2 _0118_ VGND VGND VPWR VPWR adder_inst.i_a\[10\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_56_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4867__B1 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9139_ net527 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__inv_2
Xoutput68 net68 VGND VGND VPWR VPWR o_res[0] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR o_res[1] sky130_fd_sc_hd__buf_2
XFILLER_103_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5831__A2 net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6058__B net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6626__X _2256_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6840_ _2468_ _2469_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_122_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6771_ _2390_ _2400_ _2350_ _2373_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__a211oi_2
X_8510_ net204 net159 VGND VGND VPWR VPWR _4083_ sky130_fd_sc_hd__nand2_1
XANTENNA__7980__C1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5722_ _1316_ _1319_ _1351_ _1350_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__a211o_4
X_9490_ clknet_leaf_25_clk net769 _0400_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
XFILLER_15_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8441_ net655 _3720_ VGND VGND VPWR VPWR _4014_ sky130_fd_sc_hd__and2_1
X_5653_ net215 net480 _1248_ _1247_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a31oi_1
X_8372_ _3942_ _3944_ VGND VGND VPWR VPWR _3945_ sky130_fd_sc_hd__nor2_1
X_4604_ _4374_ net219 net345 VGND VGND VPWR VPWR _4375_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5584_ _1212_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__nor2_1
Xhold301 adder_inst.exp_a_r\[7\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
X_7323_ _2947_ _2948_ VGND VGND VPWR VPWR _2953_ sky130_fd_sc_hd__xor2_1
XANTENNA__8729__A multiplier_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4849__B1 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8448__B net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7254_ _2881_ _2883_ VGND VGND VPWR VPWR _2884_ sky130_fd_sc_hd__nor2_1
XFILLER_104_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7185_ _2810_ _2813_ _2814_ VGND VGND VPWR VPWR _2815_ sky130_fd_sc_hd__nand3_1
X_6205_ _1831_ _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__nand2b_1
XANTENNA_fanout398_A net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5153__A net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6136_ _1668_ _1666_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_51_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6066__A2 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout186_X net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5274__B1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6067_ _1273_ net590 _1695_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__nand4_4
X_5018_ _0646_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__and2_1
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout353_X net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8751__X _0084_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7808__A net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6969_ _2585_ _2598_ VGND VGND VPWR VPWR _2599_ sky130_fd_sc_hd__and2_1
X_8708_ _4110_ net683 _4258_ VGND VGND VPWR VPWR _4259_ sky130_fd_sc_hd__a21oi_2
XANTENNA__6712__A net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8639_ _4196_ net174 _4197_ _4198_ VGND VGND VPWR VPWR _4199_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5047__B net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6829__A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4886__B net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6829__B2 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6159__A net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5063__A net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6606__B net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8754__A1 multiplier_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8990_ net516 VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_124_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7941_ adder_inst.sum_raw_r\[6\] net494 _3414_ _3537_ VGND VGND VPWR VPWR _3538_
+ sky130_fd_sc_hd__a211o_1
X_7872_ net488 _3474_ _3477_ _3472_ VGND VGND VPWR VPWR _3478_ sky130_fd_sc_hd__a22oi_1
XFILLER_51_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8731__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6823_ net324 net466 VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__nand2_1
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6754_ _2382_ _2383_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__and2b_1
X_9473_ clknet_leaf_17_clk _0092_ _0383_ VGND VGND VPWR VPWR mul_res\[28\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6685_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_21_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5705_ _1327_ _1328_ _1333_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a21o_1
XFILLER_136_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8424_ _3995_ _3996_ VGND VGND VPWR VPWR _3997_ sky130_fd_sc_hd__nand2b_1
XANTENNA__5148__A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5636_ _1258_ _1260_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__xnor2_1
XFILLER_136_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_135_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout313_A adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4987__A net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8355_ _3856_ _3896_ _3927_ VGND VGND VPWR VPWR _3928_ sky130_fd_sc_hd__or3_1
X_5567_ _1194_ _1196_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nor2_1
Xhold142 adder_inst.i_b\[31\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
X_5498_ _1119_ _1126_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__nand3_4
X_8286_ net134 _3712_ _3802_ net139 VGND VGND VPWR VPWR _3859_ sky130_fd_sc_hd__a211oi_1
Xhold153 adder_inst.i_b\[6\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
X_7306_ _2911_ _2935_ _2910_ VGND VGND VPWR VPWR _2936_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold175 adder_inst.i_b\[21\] VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold186 adder_inst.i_b\[5\] VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlygate4sd3_1
X_7237_ _2830_ _2832_ _2866_ _0953_ VGND VGND VPWR VPWR _2867_ sky130_fd_sc_hd__a211o_1
Xhold164 adder_inst.i_a\[5\] VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
Xhold197 adder_inst.exp_a\[0\] VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_86_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7168_ _1622_ net636 _2796_ VGND VGND VPWR VPWR _2798_ sky130_fd_sc_hd__nor3_4
XFILLER_58_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7099_ _2713_ _2727_ _2728_ VGND VGND VPWR VPWR _2729_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout470_X net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6119_ _1735_ _1736_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__nand3_4
XFILLER_100_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7538__A _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4897__A net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7227__A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7227__B2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8832__A _3270_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7719__Y _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5894__C net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6502__D net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6470_ _2097_ _2098_ _2095_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__a21o_1
XFILLER_134_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5421_ _1049_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5713__B2 net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5352_ _0980_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__and2_1
X_8140_ _3712_ _3713_ net660 VGND VGND VPWR VPWR _3714_ sky130_fd_sc_hd__mux2_1
X_8071_ adder_inst.exp_larger_r\[5\] net186 _3645_ _3391_ VGND VGND VPWR VPWR _3649_
+ sky130_fd_sc_hd__o31a_1
XFILLER_114_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5283_ _0899_ _0900_ _0911_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__a21o_1
X_7022_ _2643_ _2650_ _2651_ VGND VGND VPWR VPWR _2652_ sky130_fd_sc_hd__nand3_1
XFILLER_110_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8973_ net542 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__inv_2
XANTENNA__4692__D net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7924_ net498 _3446_ VGND VGND VPWR VPWR _3523_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout263_A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7855_ net185 _3459_ _3460_ VGND VGND VPWR VPWR _3461_ sky130_fd_sc_hd__a21o_1
XFILLER_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout430_A net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6806_ _2395_ _2435_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__or2_1
XANTENNA__6262__A net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7786_ net485 adder_inst.exp_larger_r\[6\] _3390_ VGND VGND VPWR VPWR _3392_ sky130_fd_sc_hd__and3_1
X_4998_ net381 net256 _0618_ _0617_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a31o_1
XANTENNA__7941__A2 net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout528_A net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_34_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__9346__Q adder_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4755__A2 net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6737_ _2316_ _2366_ VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__or2_1
XFILLER_139_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9456_ clknet_leaf_26_clk _0074_ _0366_ VGND VGND VPWR VPWR mul_res\[11\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout316_X net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6668_ _2283_ _2290_ _2297_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__a21oi_1
XFILLER_125_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9387_ clknet_leaf_19_clk adder_inst.exp_larger\[1\] _0297_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[1\]
+ sky130_fd_sc_hd__dfrtp_4
X_8407_ net404 net162 _3978_ _3979_ VGND VGND VPWR VPWR _3980_ sky130_fd_sc_hd__a22o_1
X_6599_ _2212_ _2227_ _2228_ _2152_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__a211o_1
X_5619_ _1237_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__xnor2_1
X_8338_ _3906_ _3908_ VGND VGND VPWR VPWR _3911_ sky130_fd_sc_hd__xor2_1
XANTENNA__7093__A net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7457__A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8269_ net126 _3841_ _3838_ VGND VGND VPWR VPWR _3842_ sky130_fd_sc_hd__a21oi_1
XFILLER_78_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7457__B2 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout430 net431 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__clkbuf_4
Xfanout441 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__buf_8
Xfanout463 adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__buf_4
XFILLER_59_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout474 net475 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__buf_2
XANTENNA__6437__A net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout452 net453 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__buf_2
Xfanout485 net486 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__buf_2
XFILLER_101_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout496 net498 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__buf_2
XFILLER_86_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5995__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6347__A net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5970_ _1598_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__xnor2_1
X_4921_ net216 net422 net428 net207 VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a22oi_1
X_4852_ _0475_ _0476_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nand3_1
X_7640_ _3159_ _3268_ VGND VGND VPWR VPWR _3270_ sky130_fd_sc_hd__nand2_2
XFILLER_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4783_ net368 net374 net244 net250 VGND VGND VPWR VPWR _4554_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_119_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7571_ _3029_ _3030_ _3033_ VGND VGND VPWR VPWR _3201_ sky130_fd_sc_hd__and3_1
X_9310_ clknet_leaf_4_clk net714 _0220_ VGND VGND VPWR VPWR adder_inst.man_a_r\[22\]
+ sky130_fd_sc_hd__dfrtp_4
X_6522_ _2139_ _2140_ _2151_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_31_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9241_ clknet_leaf_1_clk net35 _0151_ VGND VGND VPWR VPWR adder_inst.i_b\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6453_ _2015_ _2082_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nor2_1
XFILLER_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5404_ _0455_ _0978_ _1029_ _1032_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__a211oi_1
X_9172_ net531 VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__inv_2
X_8123_ _3344_ _3695_ VGND VGND VPWR VPWR _3697_ sky130_fd_sc_hd__xnor2_4
X_6384_ net283 net453 net459 net276 VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__a22oi_1
XFILLER_130_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5335_ _0843_ _0845_ _0842_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__o21ba_1
XFILLER_125_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8054_ net195 _3416_ VGND VGND VPWR VPWR _3633_ sky130_fd_sc_hd__nand2_1
X_5266_ _0789_ _0894_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout380_A net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7005_ _1555_ _1562_ _2632_ _2634_ VGND VGND VPWR VPWR _2635_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_110_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5197_ net249 net409 net413 net243 VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a22oi_1
XANTENNA_fanout478_A net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8956_ net529 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__inv_2
XFILLER_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5311__D net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout266_X net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_39_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7907_ adder_inst.sum_raw_r\[3\] net487 _3462_ adder_inst.sum_raw_r\[2\] _3394_ VGND
+ VGND VPWR VPWR _3509_ sky130_fd_sc_hd__a221o_1
XFILLER_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8887_ net508 VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__inv_2
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7838_ net197 _3387_ _3401_ VGND VGND VPWR VPWR _3444_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout433_X net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7769_ _3336_ _3347_ VGND VGND VPWR VPWR _3378_ sky130_fd_sc_hd__nor2_1
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9508_ clknet_leaf_16_clk net795 _0418_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
Xclkload1 clknet_2_1__leaf_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__inv_8
XFILLER_109_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5039__C net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9439_ clknet_leaf_14_clk multiplier_inst.exp_final\[4\] _0349_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input39_A i_b[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout282 adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__buf_2
XFILLER_87_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout260 net264 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_4
Xfanout271 net275 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_2
XFILLER_86_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout293 net295 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8618__B1 _3355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6892__A2 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8094__A1 _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5120_ _0745_ _0749_ _0740_ _0741_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__o211a_1
XFILLER_69_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5051_ _0674_ _0675_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nor3b_1
XFILLER_97_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8810_ _3192_ _3185_ VGND VGND VPWR VPWR _4313_ sky130_fd_sc_hd__and2b_1
XFILLER_38_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8741_ net843 net179 net177 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and3_1
XFILLER_52_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8149__A2 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5953_ _1574_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__nand3_1
X_8672_ _4056_ net661 _4227_ VGND VGND VPWR VPWR _4228_ sky130_fd_sc_hd__and3_1
X_4904_ _0531_ _0532_ _0526_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a21bo_1
X_5884_ _1424_ _1429_ _1423_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__a21bo_1
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4835_ net355 net292 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nand2_1
X_7623_ net586 _3247_ _3252_ VGND VGND VPWR VPWR _3253_ sky130_fd_sc_hd__a21oi_1
XANTENNA__7058__D net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4766_ _4534_ _4535_ _4514_ VGND VGND VPWR VPWR _4537_ sky130_fd_sc_hd__o21a_1
X_7554_ net110 _3177_ _3180_ _3182_ VGND VGND VPWR VPWR _3184_ sky130_fd_sc_hd__a211o_1
XANTENNA__4979__B net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout226_A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6505_ _2131_ _2134_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4697_ _4462_ _4467_ VGND VGND VPWR VPWR _4468_ sky130_fd_sc_hd__nand2_1
X_7485_ _3065_ _3112_ VGND VGND VPWR VPWR _3115_ sky130_fd_sc_hd__xor2_1
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9224_ clknet_leaf_9_clk net19 _0134_ VGND VGND VPWR VPWR adder_inst.exp_a\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6436_ net294 net300 net443 net448 VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__and4_1
X_9155_ net545 VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_112_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6367_ net303 net438 net443 net296 VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__a22o_1
X_8106_ _3669_ _3670_ _3675_ _3676_ VGND VGND VPWR VPWR _3680_ sky130_fd_sc_hd__a22o_4
XANTENNA__4894__A1 net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5318_ _0946_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__nor2_1
XFILLER_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9086_ net521 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__inv_2
XFILLER_102_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6298_ net285 net450 net456 net278 VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__a22oi_1
XFILLER_102_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8037_ net192 _3620_ net499 VGND VGND VPWR VPWR _3621_ sky130_fd_sc_hd__a21oi_1
XFILLER_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5249_ net347 net313 net323 net341 VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_54_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout383_X net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8939_ net519 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__inv_2
XANTENNA__4880__D net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4885__A1 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5062__B2 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5062__A1 net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9358__D _0062_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8000__A1 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_692 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5528__X _1158_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4620_ _4388_ _4390_ _4371_ VGND VGND VPWR VPWR _4391_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_41_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7743__X _3362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7270_ _2897_ _2898_ VGND VGND VPWR VPWR _2900_ sky130_fd_sc_hd__xnor2_2
XFILLER_7_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6221_ net271 net456 _1849_ _1847_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__a31o_1
X_6152_ net253 net468 VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__nand2_1
X_5103_ _0731_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__and2b_1
XFILLER_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6083_ _1706_ _1711_ _1712_ net556 VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_127_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5034_ _0659_ _0661_ _0662_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__o21ba_1
XFILLER_97_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8734__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6985_ _2584_ _2612_ VGND VGND VPWR VPWR _2615_ sky130_fd_sc_hd__xnor2_1
X_8724_ net653 adder_inst.exp_a_r\[3\] net166 VGND VGND VPWR VPWR adder_inst.exp_larger\[3\]
+ sky130_fd_sc_hd__mux2_1
XANTENNA_fanout343_A net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5936_ _1547_ _1564_ _1565_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__and3_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8655_ _4212_ _3956_ VGND VGND VPWR VPWR adder_inst.sum_raw\[15\] sky130_fd_sc_hd__xnor2_1
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7606_ _1133_ _3215_ VGND VGND VPWR VPWR _3236_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout510_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5867_ net209 net214 net475 net480 VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__and4_1
XFILLER_21_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6270__A net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout229_X net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4818_ _0445_ _0446_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__nor2_1
X_8586_ _3926_ _4152_ VGND VGND VPWR VPWR adder_inst.sum_raw\[6\] sky130_fd_sc_hd__xnor2_2
X_5798_ _1426_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_138_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8749__X _0081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4749_ net219 net362 VGND VGND VPWR VPWR _4520_ sky130_fd_sc_hd__nand2_1
XANTENNA__7085__B net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7537_ _1718_ _3166_ VGND VGND VPWR VPWR _3167_ sky130_fd_sc_hd__xnor2_2
XFILLER_31_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7468_ _3096_ _3097_ VGND VGND VPWR VPWR _3098_ sky130_fd_sc_hd__xnor2_1
X_9207_ clknet_leaf_3_clk net32 _0117_ VGND VGND VPWR VPWR adder_inst.i_a\[9\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_56_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6419_ net424 net324 VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__nand2_1
XFILLER_89_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4867__B2 net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4867__A1 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7399_ _3027_ _2256_ _3028_ _3005_ _3025_ VGND VGND VPWR VPWR _3029_ sky130_fd_sc_hd__o221a_4
XFILLER_103_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput69 net69 VGND VGND VPWR VPWR o_res[10] sky130_fd_sc_hd__buf_2
X_9138_ net527 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__inv_2
X_9069_ net543 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__inv_2
XFILLER_102_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6241__B1 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer34_X net583 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6058__C net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6355__A net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_122_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6770_ _2390_ _2397_ _2398_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__nand3_1
X_5721_ _1336_ _1338_ _1349_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_98_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8440_ net142 _3797_ _3859_ net125 VGND VGND VPWR VPWR _4013_ sky130_fd_sc_hd__a211oi_1
XANTENNA__4603__A net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5652_ _1254_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__nor2_1
XANTENNA__6090__A net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8371_ net162 _3941_ _3943_ VGND VGND VPWR VPWR _3944_ sky130_fd_sc_hd__o21ai_1
X_4603_ net351 net226 VGND VGND VPWR VPWR _4374_ sky130_fd_sc_hd__and2_2
X_5583_ net247 net450 net456 net241 VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a22oi_1
Xhold302 adder_inst.is_nan_r VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7322_ _2950_ _2890_ VGND VGND VPWR VPWR _2952_ sky130_fd_sc_hd__xnor2_4
XFILLER_7_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4849__B2 net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4849__A1 net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7253_ _0970_ _2802_ net615 _2880_ VGND VGND VPWR VPWR _2883_ sky130_fd_sc_hd__a211oi_2
XFILLER_131_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7184_ _0888_ _2812_ _2811_ VGND VGND VPWR VPWR _2814_ sky130_fd_sc_hd__a21o_1
X_6204_ _1831_ _1832_ _1833_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__or3_4
XFILLER_112_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5153__B adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6135_ _1764_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout293_A net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6066_ net231 net474 net480 net225 VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__a22o_1
X_5017_ net223 net416 _0539_ _0538_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a31o_1
XFILLER_85_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5274__A1 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5274__B2 net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout460_A adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_107_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8707_ _4071_ net108 _4257_ _4076_ _4245_ VGND VGND VPWR VPWR _4258_ sky130_fd_sc_hd__a32o_2
XANTENNA_fanout346_X net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7971__A0 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6968_ _2592_ _2597_ VGND VGND VPWR VPWR _2598_ sky130_fd_sc_hd__xnor2_1
XFILLER_139_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4785__B1 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5919_ net272 net407 VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__nand2_1
XANTENNA__6712__B net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5609__A net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6899_ _2517_ _2528_ VGND VGND VPWR VPWR _2529_ sky130_fd_sc_hd__and2_1
X_8638_ _3977_ _4190_ net174 VGND VGND VPWR VPWR _4198_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_62_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8569_ net187 _4133_ _4134_ _4137_ VGND VGND VPWR VPWR _4138_ sky130_fd_sc_hd__a31o_1
XANTENNA__5047__C net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__9461__D _0079_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4886__C net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6829__A2 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6159__B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5063__B net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input21_A i_a[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5265__A1 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_69_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6606__C net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_124_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7940_ adder_inst.sum_raw_r\[3\] _3524_ _3536_ _3433_ VGND VGND VPWR VPWR _3537_
+ sky130_fd_sc_hd__o211a_1
XFILLER_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7871_ net497 adder_inst.exp_larger_r\[1\] _3404_ _3474_ VGND VGND VPWR VPWR _3477_
+ sky130_fd_sc_hd__a22o_1
XFILLER_94_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6822_ net330 net454 net335 net460 VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__and4_1
XFILLER_90_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6753_ net317 net452 net458 net310 VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__a22o_1
X_9472_ clknet_leaf_17_clk _0091_ _0382_ VGND VGND VPWR VPWR mul_res\[27\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6684_ _2260_ _2309_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_21_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5704_ _1327_ _1328_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout139_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8423_ _3993_ _3994_ VGND VGND VPWR VPWR _3996_ sky130_fd_sc_hd__nand2_1
XANTENNA__5148__B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5635_ _1262_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__or2_1
XFILLER_136_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_1__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4987__B net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8354_ _3911_ _3926_ VGND VGND VPWR VPWR _3927_ sky130_fd_sc_hd__nand2_1
XFILLER_3_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5566_ _1194_ _1195_ net271 net439 VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__and4bb_1
XANTENNA_fanout306_A net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold143 adder_inst.i_vld VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
X_5497_ _1095_ _1118_ _0740_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__o21ai_1
X_8285_ net137 _3801_ _3857_ VGND VGND VPWR VPWR _3858_ sky130_fd_sc_hd__o21a_1
XANTENNA_clkbuf_leaf_1_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7305_ _2930_ _2934_ VGND VGND VPWR VPWR _2935_ sky130_fd_sc_hd__xor2_1
Xhold154 adder_inst.i_a\[20\] VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
Xhold165 adder_inst.i_a\[22\] VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
X_7236_ _0937_ _0938_ _0952_ VGND VGND VPWR VPWR _2866_ sky130_fd_sc_hd__o21a_1
Xhold176 adder_inst.i_b\[1\] VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_44_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold187 adder_inst.i_b\[18\] VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 adder_inst.i_a\[1\] VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_113_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5451__X _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7167_ _1620_ _1622_ _2796_ VGND VGND VPWR VPWR _2797_ sky130_fd_sc_hd__o21a_1
XFILLER_74_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7098_ _2720_ _2721_ _2726_ VGND VGND VPWR VPWR _2728_ sky130_fd_sc_hd__a21o_1
X_6118_ net608 _1746_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__xnor2_2
XFILLER_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout463_X net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6049_ _1355_ _1676_ net557 _1656_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_29_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8197__A0 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7819__A adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_53_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4897__B net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7227__A2 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8188__A0 net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7735__Y _3355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5420_ _0704_ _0706_ _0703_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__o21ba_1
XANTENNA__5713__A2 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5351_ _4548_ _4550_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
XFILLER_99_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4921__B1 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8070_ adder_inst.exp_larger_r\[5\] _3419_ _3421_ _3647_ VGND VGND VPWR VPWR _3648_
+ sky130_fd_sc_hd__a31o_1
XFILLER_99_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5282_ _0899_ _0900_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_130_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7021_ _2648_ _2649_ _2644_ VGND VGND VPWR VPWR _2651_ sky130_fd_sc_hd__a21o_1
XANTENNA__5712__A net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8972_ net540 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__inv_2
XFILLER_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4988__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7923_ _4337_ net496 net492 VGND VGND VPWR VPWR _3522_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7854_ _4346_ net171 _3444_ net485 _3435_ VGND VGND VPWR VPWR _3460_ sky130_fd_sc_hd__a221o_1
XANTENNA_fanout256_A net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7785_ net485 _3390_ VGND VGND VPWR VPWR _3391_ sky130_fd_sc_hd__nand2_1
XFILLER_23_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6805_ net299 net470 net477 net293 VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__a22oi_1
XANTENNA__6262__B net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4997_ _0516_ _0518_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__nand2_1
XANTENNA__5159__A net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6736_ _2362_ _2365_ _2318_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__o21ai_2
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9455_ clknet_leaf_26_clk _0073_ _0365_ VGND VGND VPWR VPWR mul_res\[10\] sky130_fd_sc_hd__dfrtp_1
X_6667_ _2237_ _2296_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__or2_1
X_9386_ clknet_leaf_15_clk adder_inst.exp_larger\[0\] _0296_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_8406_ net166 _3732_ VGND VGND VPWR VPWR _3979_ sky130_fd_sc_hd__nor2_2
XANTENNA_fanout211_X net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout309_X net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6598_ _2139_ _2140_ _2151_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__a21oi_1
X_5618_ _1242_ _1246_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__xnor2_1
XANTENNA__8757__X _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8337_ _3906_ _3908_ VGND VGND VPWR VPWR _3910_ sky130_fd_sc_hd__nor2_1
XANTENNA__7093__B net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5549_ net272 net426 VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8654__A1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7457__A2 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8268_ _3839_ _3840_ VGND VGND VPWR VPWR _3841_ sky130_fd_sc_hd__nor2_1
XFILLER_120_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8199_ _3771_ _3772_ net135 VGND VGND VPWR VPWR _3773_ sky130_fd_sc_hd__mux2_2
X_7219_ _0943_ _2848_ VGND VGND VPWR VPWR _2849_ sky130_fd_sc_hd__nor2_1
Xfanout431 net435 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_2
Xfanout420 net423 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__buf_2
XFILLER_120_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout464 net465 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__buf_2
Xfanout453 net454 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_4
Xfanout475 net476 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__clkbuf_4
XANTENNA__6437__B net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout442 net444 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__clkbuf_4
Xfanout497 net498 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__clkbuf_4
Xfanout486 adder_inst.sum_raw_r\[24\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6028__A2_N net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__9272__Q adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_90_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6347__B net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4920_ net207 net216 net422 net428 VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__and4_1
XFILLER_33_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4851_ _0478_ _0479_ _0477_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__o21bai_1
XANTENNA__7746__X _3364_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4782_ _4417_ _4551_ _4552_ VGND VGND VPWR VPWR _4553_ sky130_fd_sc_hd__nand3_1
X_7570_ _3029_ _3030_ _3033_ VGND VGND VPWR VPWR _3200_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_31_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6521_ _2145_ _2149_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_31_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9240_ clknet_leaf_1_clk net34 _0150_ VGND VGND VPWR VPWR adder_inst.i_b\[10\] sky130_fd_sc_hd__dfrtp_1
X_6452_ net273 net465 _2013_ _2014_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_9_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5403_ _1029_ _1032_ _0455_ _0978_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__o211a_1
X_9171_ net528 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__inv_2
XFILLER_127_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8122_ _3326_ _3688_ _3327_ VGND VGND VPWR VPWR _3696_ sky130_fd_sc_hd__o21a_2
X_6383_ net276 net283 net453 net459 VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__and4_1
XFILLER_130_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5334_ _0961_ _0962_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__xnor2_1
XANTENNA__8737__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7641__B _3270_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8053_ net493 _3454_ _4347_ VGND VGND VPWR VPWR _3632_ sky130_fd_sc_hd__a21o_1
XFILLER_102_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_738 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5265_ net341 net307 _0787_ _0788_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a22o_1
XFILLER_102_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5196_ net238 net419 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__nand2_1
X_7004_ _2630_ _2631_ _2616_ VGND VGND VPWR VPWR _2634_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_110_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8955_ net549 VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_39_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout540_A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout161_X net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7906_ net194 adder_inst.sum_raw_r\[5\] adder_inst.sum_raw_r\[4\] _3383_ VGND VGND
+ VPWR VPWR _3508_ sky130_fd_sc_hd__o22a_1
X_8886_ net508 VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__inv_2
XFILLER_71_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7837_ net185 _3423_ _3440_ _3442_ VGND VGND VPWR VPWR _3443_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout259_X net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7768_ net833 net824 _3377_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__or3_1
XANTENNA__5386__B1 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout426_X net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9507_ clknet_leaf_16_clk net804 _0417_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
X_7699_ _3318_ _3319_ _3323_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[5\] sky130_fd_sc_hd__o21a_1
XANTENNA__5039__D net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload2 clknet_2_2__leaf_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
X_6719_ _2278_ _2321_ _2336_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__a21o_1
X_9438_ clknet_leaf_14_clk multiplier_inst.exp_final\[3\] _0348_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7832__A adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9369_ clknet_leaf_21_clk _0042_ _0279_ VGND VGND VPWR VPWR add_res\[15\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_59_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8139__S net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout250 net251 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_6
XANTENNA_clone81_A net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout261 net264 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
Xfanout272 net275 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_2
Xfanout283 net288 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__buf_2
XFILLER_101_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__clkbuf_2
XFILLER_15_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6183__A net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8838__A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5050_ _0676_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8573__A net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8740_ net838 net179 net177 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__and3_1
X_5952_ _1579_ _1580_ _1575_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__a21o_1
XFILLER_52_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4903_ _0526_ _0531_ net617 VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_9_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8671_ _4054_ _4216_ VGND VGND VPWR VPWR _4227_ sky130_fd_sc_hd__nand2_1
XFILLER_21_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5883_ _1512_ _1511_ _1510_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__nor3_4
X_4834_ _0460_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2b_1
X_7622_ net586 _3251_ VGND VGND VPWR VPWR _3252_ sky130_fd_sc_hd__nor2_1
X_4765_ _4514_ _4534_ _4535_ VGND VGND VPWR VPWR _4536_ sky130_fd_sc_hd__nor3_1
X_7553_ net618 _3180_ _3182_ VGND VGND VPWR VPWR _3183_ sky130_fd_sc_hd__a21o_1
XFILLER_119_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6504_ _2132_ _2133_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__nor2_1
X_9223_ clknet_leaf_9_clk net18 _0133_ VGND VGND VPWR VPWR adder_inst.exp_a\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_107_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4696_ _4465_ _4466_ VGND VGND VPWR VPWR _4467_ sky130_fd_sc_hd__xnor2_1
X_7484_ _3040_ _3041_ _3039_ VGND VGND VPWR VPWR _3114_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout219_A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6868__B1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6435_ _1990_ _2063_ _2062_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__a21o_1
XFILLER_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9154_ net543 VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__inv_2
XFILLER_115_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6366_ net289 net448 VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__nand2_1
XANTENNA__5540__B1 net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9085_ net521 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout490_A net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8105_ _3669_ _3670_ _3675_ _3676_ VGND VGND VPWR VPWR _3679_ sky130_fd_sc_hd__a22oi_2
XANTENNA__4894__A2 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5317_ net212 net437 net444 net205 VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8036_ adder_inst.sum_raw_r\[15\] adder_inst.sum_raw_r\[16\] net501 VGND VGND VPWR
+ VPWR _3620_ sky130_fd_sc_hd__mux2_1
XANTENNA__7293__B1 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6297_ net278 net285 net450 net456 VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__and4_1
XFILLER_130_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5248_ net353 net307 VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout376_X net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5179_ _0789_ _0790_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xor2_1
XFILLER_29_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7596__A1 _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8938_ net513 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__inv_2
XFILLER_84_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8869_ net758 mul_res\[21\] net506 VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__9464__D _0082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer24_A net379 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input51_A i_b[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4885__A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6087__A1 _1622_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7036__B1 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_85_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5062__A2 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7218__A2_N net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5770__B1 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6220_ _1847_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__and2b_1
XFILLER_131_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6151_ net260 net267 net456 net462 VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__and4_1
XFILLER_112_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5102_ net360 net262 net268 net355 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a22o_1
XFILLER_58_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6082_ _1510_ net634 _1512_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_127_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5033_ _0659_ _0661_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nor3b_1
XFILLER_66_730 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6984_ _2584_ _2612_ VGND VGND VPWR VPWR _2614_ sky130_fd_sc_hd__nand2_1
XFILLER_25_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8723_ net658 adder_inst.exp_a_r\[2\] _3665_ VGND VGND VPWR VPWR adder_inst.exp_larger\[2\]
+ sky130_fd_sc_hd__mux2_1
XFILLER_80_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5935_ _1562_ _1563_ _1548_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__a21o_1
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8654_ net187 _4206_ _4207_ _4211_ VGND VGND VPWR VPWR _4212_ sky130_fd_sc_hd__a31o_1
X_5866_ net214 net475 net481 net209 VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__a22oi_1
XANTENNA_fanout336_A net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4817_ _0445_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__and2_1
X_7605_ net592 _3225_ _3226_ _3234_ VGND VGND VPWR VPWR _3235_ sky130_fd_sc_hd__a31o_1
X_8585_ _4148_ _4151_ net173 VGND VGND VPWR VPWR _4152_ sky130_fd_sc_hd__mux2_4
XANTENNA__5167__A net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6270__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5797_ net371 net314 net320 net365 VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_138_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout503_A opcode_stage1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4748_ _4517_ _4518_ VGND VGND VPWR VPWR _4519_ sky130_fd_sc_hd__nor2_1
XANTENNA__7085__C net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7536_ _1810_ _3165_ _1808_ VGND VGND VPWR VPWR _3166_ sky130_fd_sc_hd__a21bo_1
XFILLER_110_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4679_ _4444_ _4449_ VGND VGND VPWR VPWR _4450_ sky130_fd_sc_hd__and2b_1
X_7467_ _3083_ _3085_ _3082_ VGND VGND VPWR VPWR _3097_ sky130_fd_sc_hd__o21bai_2
XFILLER_134_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9206_ clknet_leaf_0_clk net31 _0116_ VGND VGND VPWR VPWR adder_inst.i_a\[8\] sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_56_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6418_ net412 net418 net329 net336 VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__and4_1
XANTENNA__4867__A2 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9137_ net525 VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__inv_2
X_7398_ _3020_ _3022_ _3026_ VGND VGND VPWR VPWR _3028_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6349_ net412 net332 net336 net406 VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__a22oi_2
X_9068_ net546 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__inv_2
XFILLER_103_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8019_ adder_inst.sum_raw_r\[16\] net497 _3432_ adder_inst.sum_raw_r\[13\] VGND VGND
+ VPWR VPWR _3605_ sky130_fd_sc_hd__a22o_1
XFILLER_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6241__A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6241__B2 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6461__A net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_724 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8388__A adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7292__A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5524__B _1153_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6058__D net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6636__A net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8757__B1 net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6355__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_122_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7980__B2 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7980__A1 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5720_ _1336_ _1338_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__and3_4
XPHY_EDGE_ROW_99_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4603__B net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5651_ _1269_ _1279_ _1280_ _1253_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__o211a_1
XANTENNA__6090__B net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8370_ net429 net162 VGND VGND VPWR VPWR _3943_ sky130_fd_sc_hd__nand2_1
X_4602_ _4369_ _4372_ VGND VGND VPWR VPWR _4373_ sky130_fd_sc_hd__nand2_1
X_5582_ net242 net247 net450 net455 VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__and4_1
XFILLER_117_746 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7321_ _2890_ _2950_ VGND VGND VPWR VPWR _2951_ sky130_fd_sc_hd__and2b_1
Xhold303 multiplier_inst.man_final_r\[15\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
X_7252_ _2874_ _2875_ _2878_ VGND VGND VPWR VPWR _2882_ sky130_fd_sc_hd__o21bai_1
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4849__A2 net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6203_ net426 net303 net431 net296 VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__a22oi_1
X_7183_ _0888_ _2811_ _2812_ VGND VGND VPWR VPWR _2813_ sky130_fd_sc_hd__nand3_1
XFILLER_112_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6134_ _1760_ _1761_ _1763_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__and3_1
XANTENNA__8078__A_N adder_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8745__B net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_51_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6065_ _1680_ _1687_ _1693_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__nand3_2
X_5016_ _0644_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5274__A2 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout286_A net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout453_A net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6967_ _2593_ _2596_ VGND VGND VPWR VPWR _2597_ sky130_fd_sc_hd__xnor2_1
XANTENNA__4785__A1 net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8706_ _4065_ _4072_ VGND VGND VPWR VPWR _4257_ sky130_fd_sc_hd__or2_1
X_5918_ _1434_ _1442_ _1441_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__a21o_1
XANTENNA__6281__A net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout241_X net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4785__B2 net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6898_ net317 net478 _2527_ _2525_ VGND VGND VPWR VPWR _2528_ sky130_fd_sc_hd__a31o_1
XANTENNA__6712__C net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8637_ _3972_ _3973_ VGND VGND VPWR VPWR _4197_ sky130_fd_sc_hd__nand2_1
X_5849_ net248 net440 net446 net242 VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__a22o_1
XFILLER_10_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5609__B net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout506_X net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8568_ _4135_ _4115_ _4136_ net173 VGND VGND VPWR VPWR _4137_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_62_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7519_ _3141_ _3144_ _3142_ VGND VGND VPWR VPWR _3149_ sky130_fd_sc_hd__a21o_1
XFILLER_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8499_ _4070_ _4069_ VGND VGND VPWR VPWR _4072_ sky130_fd_sc_hd__and2b_1
XANTENNA__5047__D net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5625__A net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4886__D net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__9296__CLK clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6159__C net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5265__A2 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_4_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input14_A i_a[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6606__D net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5017__A2 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7962__A1 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6191__A net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_24_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_13_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__9275__Q adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4796__D net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7750__A adder_inst.i_a\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6366__A net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_124_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7870_ net491 _3474_ _3475_ adder_inst.exp_larger_r\[1\] _3471_ VGND VGND VPWR VPWR
+ _3476_ sky130_fd_sc_hd__o32a_1
XFILLER_82_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6821_ _2419_ _2421_ _2420_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__o21ai_1
XFILLER_23_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_15_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_50_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6752_ net310 net317 net452 net458 VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__and4_1
X_9471_ clknet_leaf_15_clk _0090_ _0381_ VGND VGND VPWR VPWR mul_res\[26\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5703_ _1329_ _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__xnor2_1
X_6683_ _2311_ _2312_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8422_ _3993_ _3994_ VGND VGND VPWR VPWR _3995_ sky130_fd_sc_hd__nor2_1
XANTENNA__5148__C net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5634_ _1262_ _1263_ net237 net474 VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_135_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8353_ _3920_ _3923_ VGND VGND VPWR VPWR _3926_ sky130_fd_sc_hd__xor2_1
XANTENNA__5192__A1 net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4987__C net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7304_ _2931_ _2932_ VGND VGND VPWR VPWR _2934_ sky130_fd_sc_hd__xor2_1
X_5565_ net285 net426 net433 net278 VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a22oi_1
Xhold144 adder_inst.i_a\[14\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
X_5496_ _1123_ _1124_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__xnor2_2
XFILLER_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8284_ net135 _3746_ _3813_ net140 VGND VGND VPWR VPWR _3857_ sky130_fd_sc_hd__a211o_1
XANTENNA_fanout201_A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold166 adder_inst.i_b\[19\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 adder_inst.i_a\[18\] VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 adder_inst.i_b\[7\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
X_7235_ _2846_ _2864_ _2845_ VGND VGND VPWR VPWR _2865_ sky130_fd_sc_hd__o21bai_1
Xhold199 adder_inst.exp_b\[4\] VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlygate4sd3_1
Xhold188 adder_inst.i_b\[16\] VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlygate4sd3_1
X_7166_ _2790_ _2791_ VGND VGND VPWR VPWR _2796_ sky130_fd_sc_hd__xnor2_1
XANTENNA_input6_A i_a[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6117_ _1741_ _1746_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__nand2b_1
XANTENNA_fanout191_X net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7097_ _2720_ _2721_ _2726_ VGND VGND VPWR VPWR _2727_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout289_X net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6048_ _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_29_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout456_X net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8197__A1 net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7819__B adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7999_ adder_inst.sum_raw_r\[10\] net183 net170 adder_inst.sum_raw_r\[11\] VGND VGND
+ VPWR VPWR _3588_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_64_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4897__C net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8121__A1 _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9311__CLK clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8188__A1 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7935__A1 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5350_ net342 net274 _0609_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and3_1
XANTENNA__4921__B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4921__A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5281_ _0907_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_130_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7020_ _2644_ _2648_ _2649_ VGND VGND VPWR VPWR _2650_ sky130_fd_sc_hd__nand3_1
Xclkbuf_leaf_4_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA__5712__B net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4609__A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8971_ net542 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__inv_2
XFILLER_95_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4988__A1 net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7922_ adder_inst.sum_raw_r\[0\] net495 net182 VGND VGND VPWR VPWR _3521_ sky130_fd_sc_hd__or3_1
XANTENNA__4988__B2 net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_104_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8179__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7853_ net488 _3420_ _3458_ _3457_ VGND VGND VPWR VPWR _3459_ sky130_fd_sc_hd__a31o_1
XFILLER_91_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7784_ adder_inst.exp_larger_r\[0\] _3389_ VGND VGND VPWR VPWR _3390_ sky130_fd_sc_hd__and2_1
X_4996_ _0623_ _0624_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand3_1
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout249_A net563 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6804_ net305 net471 _2427_ _2425_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__a31o_1
XANTENNA__5159__B net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6735_ _2356_ _2364_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__nor2_1
XFILLER_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9454_ clknet_leaf_27_clk _0103_ _0364_ VGND VGND VPWR VPWR mul_res\[9\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout416_A net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6666_ _2235_ _2236_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__nor2_1
X_9385_ clknet_leaf_14_clk _0060_ _0295_ VGND VGND VPWR VPWR add_res\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_136_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8405_ _3728_ _3868_ _3872_ _3678_ VGND VGND VPWR VPWR _3978_ sky130_fd_sc_hd__o22ai_2
X_6597_ _2212_ _2224_ _2225_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__nand3_1
X_5617_ _1246_ _1242_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout204_X net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_811 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8336_ _3906_ _3908_ VGND VGND VPWR VPWR _3909_ sky130_fd_sc_hd__nand2_1
XANTENNA__7093__C net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5548_ _1175_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__nor2_1
XFILLER_132_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8267_ _3711_ _3742_ _3740_ net137 VGND VGND VPWR VPWR _3840_ sky130_fd_sc_hd__o211a_1
XFILLER_3_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5479_ _1098_ _1100_ _1103_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a21o_1
XFILLER_120_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7218_ net220 net437 _0941_ _0942_ VGND VGND VPWR VPWR _2848_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7862__B1 _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8198_ net246 net388 net158 VGND VGND VPWR VPWR _3772_ sky130_fd_sc_hd__mux2_1
Xfanout410 net411 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_4
Xfanout432 net435 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_2
XANTENNA__4676__B1 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout421 net423 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7149_ _2663_ _2670_ _2777_ VGND VGND VPWR VPWR _2779_ sky130_fd_sc_hd__o21ai_1
Xfanout454 adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__buf_2
Xfanout465 net466 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_4
Xfanout443 net444 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout498 adder_inst.sum_raw_r\[19\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__buf_2
Xfanout487 net489 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__buf_2
XFILLER_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout476 adder_inst.man_a_r\[1\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7565__A _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4850_ _0477_ _0478_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__or3_1
XANTENNA_clkbuf_leaf_0_clk_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_119_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4781_ net375 net239 _4415_ _4416_ VGND VGND VPWR VPWR _4552_ sky130_fd_sc_hd__a22o_1
X_6520_ _2145_ _2149_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__nand2b_1
XFILLER_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload20 clknet_leaf_14_clk VGND VGND VPWR VPWR clkload20/Y sky130_fd_sc_hd__inv_4
XFILLER_118_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6451_ _2006_ _2079_ _2078_ _2064_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_132_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5402_ _1031_ _1030_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__and2b_1
X_9170_ net528 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__inv_2
X_6382_ _1929_ _2011_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__nor2_1
X_8121_ _3342_ net646 _3687_ VGND VGND VPWR VPWR _3695_ sky130_fd_sc_hd__a21oi_2
X_5333_ _0919_ _0955_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21o_1
XANTENNA__8636__A2 _4115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8052_ _3628_ _3631_ net198 VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__o21a_1
XFILLER_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5264_ _0890_ _0891_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__and3_1
X_5195_ net243 net249 net409 net413 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and4_1
X_7003_ _2616_ _2630_ _2631_ VGND VGND VPWR VPWR _2633_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_110_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8753__B multiplier_inst.man_final_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8954_ net529 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout366_A net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7905_ net114 _3506_ _3507_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and3_1
XFILLER_71_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8885_ net507 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__inv_2
X_7836_ _3391_ _3441_ _3435_ _3392_ VGND VGND VPWR VPWR _3442_ sky130_fd_sc_hd__a211o_1
XANTENNA_fanout533_A net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7767_ adder_inst.is_zero_a_r adder_inst.is_inf_b_r adder_inst.is_inf_a_r adder_inst.is_zero_b_r
+ VGND VGND VPWR VPWR _3377_ sky130_fd_sc_hd__a22o_1
XANTENNA__5386__B2 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4979_ net350 net280 VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nand2_1
X_9506_ clknet_leaf_16_clk net811 _0416_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
X_7698_ _3323_ VGND VGND VPWR VPWR _3324_ sky130_fd_sc_hd__inv_2
Xclkload3 clknet_leaf_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_2
X_6718_ _2341_ _2346_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__xnor2_1
Xwire118 _2535_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
XANTENNA_fanout321_X net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9437_ clknet_leaf_14_clk multiplier_inst.exp_final\[2\] _0347_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6649_ _2276_ _2277_ _2271_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__a21bo_1
X_9368_ clknet_leaf_25_clk _0041_ _0278_ VGND VGND VPWR VPWR add_res\[14\] sky130_fd_sc_hd__dfrtp_1
X_9299_ clknet_leaf_6_clk net720 _0209_ VGND VGND VPWR VPWR adder_inst.man_a_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_117_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8319_ _3891_ _3889_ VGND VGND VPWR VPWR _3892_ sky130_fd_sc_hd__nand2b_1
XANTENNA__6638__A1 net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6638__B2 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout240 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_4
XFILLER_105_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout251 net252 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_6
Xfanout262 net263 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__clkbuf_4
Xfanout273 net275 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout284 net288 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_2
Xfanout295 net298 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
XANTENNA__5074__B1 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6183__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_2_3__f_clk_X clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7295__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6574__B1 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5301__A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5301__B2 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5951_ _1575_ _1579_ _1580_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__nand3_1
XFILLER_25_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8670_ _4056_ _4106_ VGND VGND VPWR VPWR _4226_ sky130_fd_sc_hd__nand2_1
X_4902_ _0525_ _0513_ _0524_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a21o_1
XFILLER_52_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8554__A1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5882_ _1282_ _1283_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__xnor2_1
X_7621_ _3123_ _3245_ VGND VGND VPWR VPWR _3251_ sky130_fd_sc_hd__xor2_1
X_4833_ _0460_ _0461_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or3_1
XFILLER_60_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4764_ _4487_ _4504_ _4533_ VGND VGND VPWR VPWR _4535_ sky130_fd_sc_hd__and3_1
X_7552_ _4370_ net131 _3151_ _3171_ VGND VGND VPWR VPWR _3182_ sky130_fd_sc_hd__and4_1
XFILLER_21_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7483_ _3065_ _3112_ VGND VGND VPWR VPWR _3113_ sky130_fd_sc_hd__nor2_1
X_6503_ net436 net311 net319 net430 VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__a22oi_1
X_9222_ clknet_leaf_9_clk net17 _0132_ VGND VGND VPWR VPWR adder_inst.exp_a\[1\] sky130_fd_sc_hd__dfrtp_1
X_4695_ net201 net639 VGND VGND VPWR VPWR _4466_ sky130_fd_sc_hd__nand2_1
XANTENNA__6868__A1 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6868__B2 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6434_ _1990_ _2062_ _2063_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__nand3_2
XFILLER_134_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9153_ net544 VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__inv_2
XFILLER_115_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5453__A _1035_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6365_ net296 net303 net438 net443 VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__and4_1
XANTENNA__5540__A1 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5540__B2 net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9084_ net520 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__inv_2
XFILLER_115_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8104_ _3675_ _3676_ VGND VGND VPWR VPWR _3678_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_112_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5316_ net205 net212 net437 net444 VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__and4_1
X_6296_ _1848_ _1850_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__xnor2_2
XFILLER_115_696 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8035_ net484 net487 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3619_ sky130_fd_sc_hd__o21a_1
XFILLER_88_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7293__A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7293__B2 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5247_ net347 net341 net313 net323 VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__and4_1
XFILLER_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout483_A net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5178_ _0794_ _0795_ _0806_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout369_X net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout271_X net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8937_ net513 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
XFILLER_56_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8868_ net782 mul_res\[20\] net506 VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5359__A1 net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7819_ adder_inst.sum_raw_r\[14\] adder_inst.sum_raw_r\[16\] net491 _3424_ VGND VGND
+ VPWR VPWR _3425_ sky130_fd_sc_hd__or4_1
X_8799_ _1974_ _4277_ _4303_ _4305_ _4275_ VGND VGND VPWR VPWR _4306_ sky130_fd_sc_hd__a2111o_1
XFILLER_12_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input44_A i_b[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7036__A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7036__B2 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_137_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5770__B2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5770__A1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__9390__D adder_inst.exp_larger\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5273__A net641 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6150_ _1691_ _1692_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__xnor2_1
X_5101_ net355 net360 net262 net268 VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__and4_1
XFILLER_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6081_ _1706_ _1707_ _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_127_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5032_ _0649_ _0654_ _0648_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6983_ _2584_ _2612_ VGND VGND VPWR VPWR _2613_ sky130_fd_sc_hd__nor2_1
XFILLER_25_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8722_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] net166 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[1\] sky130_fd_sc_hd__mux2_1
XFILLER_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5934_ _1548_ _1562_ _1563_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__nand3_1
XANTENNA__6832__A net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8653_ net106 _4208_ _4210_ net174 VGND VGND VPWR VPWR _4211_ sky130_fd_sc_hd__o211a_1
X_5865_ _1492_ _1493_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__xnor2_1
X_4816_ net200 net399 _4438_ _4436_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a31o_1
X_7604_ _3223_ _3233_ _4370_ net131 net562 VGND VGND VPWR VPWR _3234_ sky130_fd_sc_hd__o2111a_1
XANTENNA_fanout231_A net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8584_ _4099_ _4149_ net105 VGND VGND VPWR VPWR _4151_ sky130_fd_sc_hd__mux2_4
XANTENNA__5167__B net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout329_A net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5796_ net365 net371 net314 net320 VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_138_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4747_ net357 net226 net232 net351 VGND VGND VPWR VPWR _4518_ sky130_fd_sc_hd__a22oi_1
XANTENNA__7085__D net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7535_ _1976_ _3164_ _1973_ VGND VGND VPWR VPWR _3165_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4678_ _4445_ _4448_ VGND VGND VPWR VPWR _4449_ sky130_fd_sc_hd__xnor2_1
X_7466_ _3059_ _3086_ _3089_ _3095_ VGND VGND VPWR VPWR _3096_ sky130_fd_sc_hd__a31oi_2
XFILLER_103_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9205_ clknet_leaf_31_clk net30 _0115_ VGND VGND VPWR VPWR adder_inst.i_a\[7\] sky130_fd_sc_hd__dfrtp_1
X_7397_ _2800_ _3021_ _3005_ VGND VGND VPWR VPWR _3027_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_56_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6417_ _2045_ _2046_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__nand2b_4
XFILLER_134_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9136_ net534 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__inv_2
XFILLER_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6348_ net418 net326 VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__nand2_1
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9067_ net547 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout486_X net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6279_ _1907_ _1825_ _1906_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__a21o_1
X_8018_ net116 _3604_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and2_1
XFILLER_102_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6241__A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6461__B net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_27_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_736 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7292__B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8454__B1 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_804 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5821__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6636__B net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8757__A1 multiplier_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_122_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_5650_ _1250_ _1252_ _1193_ _1209_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__o211ai_1
X_4601_ _4366_ _4368_ VGND VGND VPWR VPWR _4372_ sky130_fd_sc_hd__or2_1
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5581_ net237 net461 VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__nand2_1
XFILLER_30_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7320_ _2892_ _2946_ _2949_ VGND VGND VPWR VPWR _2950_ sky130_fd_sc_hd__o21bai_2
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8693__B1 net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold304 multiplier_inst.man_final_r\[16\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
X_7251_ net615 _2880_ _0970_ _2802_ VGND VGND VPWR VPWR _2881_ sky130_fd_sc_hd__o211a_1
XFILLER_132_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6202_ net290 net441 VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__nand2_1
XFILLER_132_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7182_ _0885_ _0887_ _0886_ VGND VGND VPWR VPWR _2812_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6133_ _1683_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__nor2_1
XFILLER_100_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6064_ _1693_ _1687_ _1680_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__a21o_1
X_5015_ net223 net410 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__nand2_1
XFILLER_100_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout279_A net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7658__A net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout446_A adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6966_ _2594_ _2595_ VGND VGND VPWR VPWR _2596_ sky130_fd_sc_hd__nor2_1
X_8705_ _4074_ _4256_ VGND VGND VPWR VPWR adder_inst.sum_raw\[21\] sky130_fd_sc_hd__xor2_1
XFILLER_81_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5917_ _1457_ _1464_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__nand2_1
XANTENNA__4785__A2 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6897_ _2525_ _2526_ VGND VGND VPWR VPWR _2527_ sky130_fd_sc_hd__nor2_1
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6712__D net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8636_ _4194_ _4115_ _4195_ _3976_ VGND VGND VPWR VPWR _4196_ sky130_fd_sc_hd__o22a_1
X_5848_ net242 net248 net439 net446 VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__nand4_1
XFILLER_21_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5609__C net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8489__A net637 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8567_ _4098_ net683 VGND VGND VPWR VPWR _4136_ sky130_fd_sc_hd__nand2_1
X_5779_ _1388_ _1387_ _1407_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__and4bb_2
XFILLER_108_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7518_ _3129_ _3126_ _3140_ net117 _3147_ VGND VGND VPWR VPWR _3148_ sky130_fd_sc_hd__a2111o_1
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8498_ _4069_ _4070_ VGND VGND VPWR VPWR _4071_ sky130_fd_sc_hd__nand2b_1
XANTENNA__5625__B net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7449_ _3053_ _3055_ _3052_ VGND VGND VPWR VPWR _3079_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9119_ net524 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__inv_2
XANTENNA__6159__D net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5641__A net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7411__A1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6191__B net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9291__Q adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6989__B1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6366__B net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_124_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6820_ _2424_ _2430_ _2429_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__a21o_1
XFILLER_90_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6751_ _2326_ _2375_ _2380_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__nand3_1
X_9470_ clknet_leaf_17_clk _0089_ _0380_ VGND VGND VPWR VPWR mul_res\[25\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5702_ _1330_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__nor2_1
X_6682_ _2258_ _2310_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8421_ net417 _3991_ net157 VGND VGND VPWR VPWR _3994_ sky130_fd_sc_hd__mux2_1
XANTENNA__5148__D net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5633_ net247 net461 net467 net241 VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_135_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8352_ _3920_ _3923_ VGND VGND VPWR VPWR _3925_ sky130_fd_sc_hd__nor2_1
XANTENNA__4630__A net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5564_ net278 net285 net426 net433 VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__and4_1
XFILLER_128_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4987__D net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5192__A2 net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7303_ _2931_ _2932_ VGND VGND VPWR VPWR _2933_ sky130_fd_sc_hd__and2_1
XFILLER_8_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5495_ _1124_ _1123_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8283_ _3831_ _3855_ VGND VGND VPWR VPWR _3856_ sky130_fd_sc_hd__nand2_1
XFILLER_104_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold167 adder_inst.i_a\[10\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 adder_inst.i_b\[13\] VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 adder_inst.i_a\[3\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
X_7234_ _2862_ _2863_ VGND VGND VPWR VPWR _2864_ sky130_fd_sc_hd__or2_1
XFILLER_113_750 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold178 adder_inst.i_b\[15\] VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold189 adder_inst.i_a\[6\] VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlygate4sd3_1
X_7165_ _2793_ _2794_ VGND VGND VPWR VPWR _2795_ sky130_fd_sc_hd__and2b_1
XFILLER_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout396_A net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6116_ _1742_ _1744_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__xnor2_1
XFILLER_112_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7096_ _2722_ _2725_ VGND VGND VPWR VPWR _2726_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6047_ _1656_ _1675_ _1355_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__o211a_4
XTAP_TAPCELL_ROW_29_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout351_X net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7998_ _4339_ net500 net495 VGND VGND VPWR VPWR _3587_ sky130_fd_sc_hd__a21oi_1
XANTENNA__7819__C net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7944__A2 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_64_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout449_X net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7538__D _3167_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6949_ _2575_ _2576_ VGND VGND VPWR VPWR _2579_ sky130_fd_sc_hd__xnor2_1
XFILLER_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7835__B net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8619_ _4005_ _4177_ _4004_ VGND VGND VPWR VPWR _4181_ sky130_fd_sc_hd__o21ba_1
XFILLER_50_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4897__D net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_79_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__9286__Q adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7745__B _3363_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4921__A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7761__A _3363_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5280_ _0907_ _0908_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_130_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4685__B2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4685__A1 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4609__B net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5712__C net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8970_ net542 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__inv_2
XFILLER_95_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4988__A2 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7921_ _3517_ _3518_ _3519_ _3520_ net114 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__o311a_1
XFILLER_67_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7852_ net196 _3406_ adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _3458_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_104_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4625__A net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7783_ net195 adder_inst.exp_larger_r\[5\] _3387_ VGND VGND VPWR VPWR _3389_ sky130_fd_sc_hd__and3_1
X_4995_ _0482_ _0489_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand2_1
X_6803_ _2388_ _2417_ _2432_ VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__nand3_2
XFILLER_11_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6734_ _2361_ _2363_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__nand2_1
XANTENNA__6262__D net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9453_ clknet_leaf_28_clk _0102_ _0363_ VGND VGND VPWR VPWR mul_res\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8404_ _3975_ _3976_ VGND VGND VPWR VPWR _3977_ sky130_fd_sc_hd__or2_2
X_6665_ _2280_ _2294_ _2226_ _2263_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__a211o_1
XFILLER_136_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9384_ clknet_leaf_16_clk _0059_ _0294_ VGND VGND VPWR VPWR add_res\[30\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout409_A net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6596_ _2212_ _2224_ _2225_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__and3_1
X_5616_ _1243_ _1245_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__nor2_1
X_8335_ net154 _3905_ _3907_ VGND VGND VPWR VPWR _3908_ sky130_fd_sc_hd__a21oi_2
XANTENNA__7093__D net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5547_ _1175_ _1176_ net271 net433 VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__and4bb_1
XFILLER_133_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5478_ _1107_ net602 net620 _1086_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__a211oi_2
X_8266_ _3711_ _3750_ _3748_ net139 VGND VGND VPWR VPWR _3839_ sky130_fd_sc_hd__o211a_1
XFILLER_132_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7217_ _2845_ _2846_ VGND VGND VPWR VPWR _2847_ sky130_fd_sc_hd__nor2_1
XFILLER_132_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout399_X net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8197_ net239 net382 net158 VGND VGND VPWR VPWR _3771_ sky130_fd_sc_hd__mux2_1
Xfanout422 net423 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__buf_2
Xfanout411 adder_inst.man_a_r\[12\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__buf_6
XANTENNA__7821__D adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout400 net405 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_74_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4676__A1 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4676__B2 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7148_ _2663_ _2670_ VGND VGND VPWR VPWR _2778_ sky130_fd_sc_hd__nor2_1
Xfanout466 adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__buf_2
Xfanout433 net434 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_2
Xfanout444 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__buf_6
Xfanout455 net456 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__buf_2
Xfanout488 net489 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__clkbuf_4
XFILLER_104_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout499 adder_inst.sum_raw_r\[18\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout477 net479 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_2
X_7079_ _2699_ _2708_ VGND VGND VPWR VPWR _2709_ sky130_fd_sc_hd__xor2_2
XFILLER_86_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8616__S net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6347__D net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8030__A1 net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4780_ net361 net257 _4549_ _4547_ VGND VGND VPWR VPWR _4551_ sky130_fd_sc_hd__a31o_1
XFILLER_60_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload10 clknet_leaf_8_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_118_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6450_ _2064_ _2078_ _2079_ _2006_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__a211oi_4
XFILLER_134_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_132_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload21 clknet_leaf_15_clk VGND VGND VPWR VPWR clkload21/Y sky130_fd_sc_hd__inv_6
X_5401_ _1028_ _0979_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__xnor2_2
X_6381_ net271 net462 _1927_ _1928_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__o2bb2a_1
X_8120_ _3685_ _3692_ _3691_ _3686_ VGND VGND VPWR VPWR _3694_ sky130_fd_sc_hd__or4_4
XFILLER_114_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5332_ _0581_ _0835_ _0840_ _0847_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__o31a_1
XFILLER_114_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8051_ adder_inst.is_zero_r _3461_ VGND VGND VPWR VPWR _3631_ sky130_fd_sc_hd__nor2_1
X_5263_ _0778_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nor2_1
X_5194_ _0571_ _0822_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand3_1
X_7002_ _2616_ _2630_ _2631_ VGND VGND VPWR VPWR _2632_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_110_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8753__C net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8953_ net529 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_39_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7904_ net194 adder_inst.sum_raw_r\[4\] _3383_ adder_inst.sum_raw_r\[3\] VGND VGND
+ VPWR VPWR _3507_ sky130_fd_sc_hd__o22a_1
X_8884_ net510 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout359_A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout261_A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7835_ adder_inst.exp_larger_r\[6\] net185 VGND VGND VPWR VPWR _3441_ sky130_fd_sc_hd__nor2_1
XANTENNA__8021__A1 net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6032__B1 net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9505_ clknet_leaf_17_clk net817 _0415_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
X_7766_ net854 _3372_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__nor2_1
X_4978_ net360 net274 VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__and2_1
XFILLER_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7697_ net613 _3322_ VGND VGND VPWR VPWR _3323_ sky130_fd_sc_hd__nand2_1
Xclkload4 clknet_leaf_1_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_8
XFILLER_50_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6717_ _2346_ _2341_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__nand2b_1
X_9436_ clknet_leaf_15_clk multiplier_inst.exp_final\[1\] _0346_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_6648_ _2271_ _2276_ _2277_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__nand3_1
XFILLER_106_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9367_ clknet_leaf_25_clk _0040_ _0277_ VGND VGND VPWR VPWR add_res\[13\] sky130_fd_sc_hd__dfrtp_1
X_8318_ net162 _3888_ _3890_ VGND VGND VPWR VPWR _3891_ sky130_fd_sc_hd__o21ai_2
X_6579_ _2202_ _2207_ _2208_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__nand3_1
XFILLER_117_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9298_ clknet_leaf_3_clk net716 _0208_ VGND VGND VPWR VPWR adder_inst.man_a_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6099__B1 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8249_ net322 net154 VGND VGND VPWR VPWR _3822_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_72_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout230 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
Xfanout252 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__buf_4
Xfanout263 net264 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__buf_4
Xfanout274 net275 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout285 net286 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__buf_4
Xfanout296 net297 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_87_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7295__B net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6574__A1 net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6574__B2 net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6911__C net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7582__Y _3212_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5301__A2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6655__A net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5950_ _1577_ _1578_ _1576_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__a21bo_1
XFILLER_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8003__B2 net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4901_ _0527_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__nand2b_1
XFILLER_80_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7620_ _3247_ _3248_ net111 VGND VGND VPWR VPWR _3250_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6014__B1 net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5881_ _1509_ _1508_ net632 net633 VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__a211oi_4
X_4832_ net353 adder_inst.man_b_r\[7\] net301 net348 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a22oi_1
X_4763_ _4487_ _4504_ _4533_ VGND VGND VPWR VPWR _4534_ sky130_fd_sc_hd__a21oi_2
X_7551_ net618 _3180_ VGND VGND VPWR VPWR _3181_ sky130_fd_sc_hd__nor2_1
XFILLER_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4694_ _4463_ _4464_ VGND VGND VPWR VPWR _4465_ sky130_fd_sc_hd__nor2_1
X_7482_ _3105_ _3111_ VGND VGND VPWR VPWR _3112_ sky130_fd_sc_hd__nand2_1
X_6502_ net430 net436 net311 net318 VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__and4_1
X_9221_ clknet_leaf_13_clk net16 _0131_ VGND VGND VPWR VPWR adder_inst.exp_a\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6868__A2 net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6433_ _1983_ _1984_ _1989_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__a21o_1
XANTENNA__8748__C net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9152_ net546 VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_112_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout107_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5540__A2 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6364_ _1905_ _1992_ _1991_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__a21o_1
XFILLER_130_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9083_ net520 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__inv_2
X_8103_ _3675_ _3676_ VGND VGND VPWR VPWR _3677_ sky130_fd_sc_hd__nand2_2
XFILLER_114_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5453__B _1082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5315_ _0940_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__xnor2_1
X_6295_ _1842_ _1923_ _1922_ _1908_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__o211ai_4
XFILLER_130_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8034_ net116 _3618_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and2_1
XFILLER_102_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5246_ _0807_ _0808_ _0809_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a21oi_1
XANTENNA__7293__A2 net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5177_ _0794_ _0795_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand3_2
XFILLER_68_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8936_ net516 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout264_X net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8867_ net780 mul_res\[19\] net506 VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__mux2_1
XANTENNA__5359__A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7818_ adder_inst.sum_raw_r\[10\] adder_inst.sum_raw_r\[13\] adder_inst.sum_raw_r\[12\]
+ adder_inst.sum_raw_r\[15\] VGND VGND VPWR VPWR _3424_ sky130_fd_sc_hd__or4_1
XANTENNA_fanout431_X net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8798_ _2047_ _4304_ VGND VGND VPWR VPWR _4305_ sky130_fd_sc_hd__xnor2_1
XFILLER_40_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7749_ adder_inst.i_a\[16\] adder_inst.i_a\[19\] adder_inst.i_a\[20\] _3366_ VGND
+ VGND VPWR VPWR _3367_ sky130_fd_sc_hd__or4_1
XFILLER_101_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9419_ clknet_leaf_27_clk multiplier_inst.man_final\[7\] _0329_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_4_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8955__A net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input37_A i_b[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7036__A2 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9294__Q adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5770__A2 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5273__B net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5100_ net369 net256 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nand2_1
X_6080_ _1708_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__and2_1
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5031_ _0536_ net593 _0659_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_127_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_127_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8721_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] net160 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[0\] sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_109_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6982_ _2600_ _2611_ VGND VGND VPWR VPWR _2612_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5933_ _1555_ _1556_ _1561_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__a21o_1
XANTENNA__5729__A net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8652_ _3964_ _4209_ net106 VGND VGND VPWR VPWR _4210_ sky130_fd_sc_hd__o21ai_2
XFILLER_22_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5864_ _1493_ _1492_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__and2b_1
X_4815_ _0438_ _0443_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__xnor2_1
X_8583_ _4149_ VGND VGND VPWR VPWR _4150_ sky130_fd_sc_hd__inv_2
X_7603_ _1082_ _1153_ _3222_ VGND VGND VPWR VPWR _3233_ sky130_fd_sc_hd__and3_1
XANTENNA__5167__C net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7534_ _2122_ _2257_ _2571_ _2252_ VGND VGND VPWR VPWR _3164_ sky130_fd_sc_hd__o31a_1
XFILLER_21_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5795_ net377 net308 VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_138_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4746_ net357 net232 _4374_ VGND VGND VPWR VPWR _4517_ sky130_fd_sc_hd__and3_1
XFILLER_135_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4677_ _4446_ _4447_ VGND VGND VPWR VPWR _4448_ sky130_fd_sc_hd__and2b_1
X_7465_ _3059_ _3093_ _3094_ VGND VGND VPWR VPWR _3095_ sky130_fd_sc_hd__a21oi_1
X_9204_ clknet_leaf_31_clk net29 _0114_ VGND VGND VPWR VPWR adder_inst.i_a\[6\] sky130_fd_sc_hd__dfrtp_1
X_7396_ _3014_ _3018_ _3013_ VGND VGND VPWR VPWR _3026_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_56_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6416_ _1969_ _2044_ _2043_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__a21o_1
X_9135_ net526 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__inv_2
X_6347_ net406 net412 net332 net337 VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__and4_1
XFILLER_115_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8775__A _2568_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9066_ net545 VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__inv_2
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6278_ _1825_ _1906_ _1907_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__nand3_4
XFILLER_130_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout381_X net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8017_ net486 net493 net172 net497 _3603_ VGND VGND VPWR VPWR _3604_ sky130_fd_sc_hd__a221o_1
XFILLER_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5229_ _0856_ _0857_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout479_X net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7974__B1 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8919_ net507 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
XFILLER_24_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6461__C net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8151__A0 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7292__C net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_95_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8454__B2 net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5821__B net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkload2_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7049__A_N _2678_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_122_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5549__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7764__A _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8390__A0 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4600_ _4361_ _4369_ VGND VGND VPWR VPWR _4371_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5580_ _1202_ _1204_ _1203_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__o21ba_1
XFILLER_30_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8142__A0 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold305 multiplier_inst.is_nan_r VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__7496__A2 _1158_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7250_ _2872_ _2873_ _2879_ VGND VGND VPWR VPWR _2880_ sky130_fd_sc_hd__nor3_2
XFILLER_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6201_ net296 net424 net303 net431 VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__and4_1
XFILLER_131_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7181_ _2687_ _2689_ _2688_ VGND VGND VPWR VPWR _2811_ sky130_fd_sc_hd__o21bai_1
XFILLER_112_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6132_ net253 net461 _1681_ _1682_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_85_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6063_ _1691_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__nand2_1
X_5014_ _0642_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__nor2_1
XFILLER_54_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout174_A net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6965_ net359 net312 net318 net353 VGND VGND VPWR VPWR _2595_ sky130_fd_sc_hd__a22oi_1
X_8704_ net188 _4253_ _4255_ VGND VGND VPWR VPWR _4256_ sky130_fd_sc_hd__o21ai_2
XANTENNA_fanout341_A net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5916_ _1543_ _1544_ _1432_ _1445_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__a211o_1
X_8635_ _3974_ _4103_ net106 VGND VGND VPWR VPWR _4195_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout439_A net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6896_ _2519_ _2520_ _2524_ VGND VGND VPWR VPWR _2526_ sky130_fd_sc_hd__nor3_1
XFILLER_22_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5847_ net238 net451 VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nand2_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5609__D net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8566_ _3831_ _3855_ _4123_ _4097_ VGND VGND VPWR VPWR _4135_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout227_X net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5778_ _1405_ _1406_ _1184_ _1191_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__a211o_1
X_8497_ net218 _4068_ net165 VGND VGND VPWR VPWR _4070_ sky130_fd_sc_hd__mux2_1
X_4729_ _4498_ _4499_ VGND VGND VPWR VPWR _4500_ sky130_fd_sc_hd__nor2_1
X_7517_ _3146_ VGND VGND VPWR VPWR _3147_ sky130_fd_sc_hd__inv_2
XFILLER_108_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7448_ _3062_ _3077_ VGND VGND VPWR VPWR _3078_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5625__C net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7379_ _3007_ _3008_ VGND VGND VPWR VPWR _3009_ sky130_fd_sc_hd__or2_1
X_9118_ net524 VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__inv_2
XFILLER_130_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9049_ net531 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__inv_2
XFILLER_76_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5641__B net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6456__C net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7411__A2 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6191__C net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4933__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6438__B1 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6989__B2 net641 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6989__A1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_124_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6750_ _2377_ _2378_ _2376_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__o21bai_1
XFILLER_50_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5701_ net384 net315 net321 net377 VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__a22oi_1
X_6681_ _2258_ _2310_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_21_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4911__A net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8420_ net275 net163 _3992_ VGND VGND VPWR VPWR _3993_ sky130_fd_sc_hd__o21ai_1
X_5632_ net241 net248 net461 net467 VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__and4_1
XFILLER_136_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8351_ _3920_ _3923_ VGND VGND VPWR VPWR _3924_ sky130_fd_sc_hd__nand2_1
XANTENNA__4630__B net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5563_ _1168_ _1174_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_135_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7302_ _2847_ _2864_ VGND VGND VPWR VPWR _2932_ sky130_fd_sc_hd__xnor2_1
XFILLER_132_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5494_ _0712_ _0714_ _0711_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__o21ba_1
X_8282_ _3849_ _3851_ VGND VGND VPWR VPWR _3855_ sky130_fd_sc_hd__xor2_2
Xhold168 adder_inst.i_a\[16\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold157 adder_inst.i_b\[4\] VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 adder_inst.i_a\[2\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
X_7233_ _2855_ _2861_ VGND VGND VPWR VPWR _2863_ sky130_fd_sc_hd__nor2_1
Xhold179 adder_inst.i_a\[9\] VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlygate4sd3_1
X_7164_ _2786_ _2789_ _2792_ VGND VGND VPWR VPWR _2794_ sky130_fd_sc_hd__nand3_1
XFILLER_113_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6115_ _1645_ _1742_ _1743_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__or3_1
X_7095_ _2723_ _2724_ VGND VGND VPWR VPWR _2725_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_13_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout291_A net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout389_A net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6046_ _1352_ _1353_ _1354_ _1209_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__a22o_4
XFILLER_37_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6573__A net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7997_ net116 _3586_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__and2_1
XFILLER_81_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5189__A net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout344_X net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6948_ _1597_ _1599_ _1596_ VGND VGND VPWR VPWR _2578_ sky130_fd_sc_hd__o21ba_1
XFILLER_42_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6879_ _2478_ _2485_ _2487_ _2508_ VGND VGND VPWR VPWR _2509_ sky130_fd_sc_hd__and4_1
XFILLER_139_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8618_ _4008_ _4175_ _3355_ _4003_ VGND VGND VPWR VPWR _4180_ sky130_fd_sc_hd__o211a_1
XFILLER_50_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8549_ _4025_ _4091_ _4116_ VGND VGND VPWR VPWR _4120_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_79_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8409__A1 net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_31_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_45_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6944__B1_N _2256_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4685__A2 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5712__D net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7920_ net194 adder_inst.sum_raw_r\[7\] adder_inst.sum_raw_r\[6\] _3383_ VGND VGND
+ VPWR VPWR _3520_ sky130_fd_sc_hd__o22a_1
X_7851_ _3452_ _3456_ net488 VGND VGND VPWR VPWR _3457_ sky130_fd_sc_hd__a21oi_1
XFILLER_48_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4625__B net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6802_ _2429_ _2430_ _2424_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__a21bo_1
X_7782_ net197 adder_inst.exp_larger_r\[1\] VGND VGND VPWR VPWR _3388_ sky130_fd_sc_hd__and2_1
X_4994_ _0621_ _0622_ _0606_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a21o_1
XFILLER_90_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5205__A1_N net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6733_ _2302_ _2319_ _2352_ _2360_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__o211ai_1
X_9452_ clknet_leaf_28_clk _0101_ _0362_ VGND VGND VPWR VPWR mul_res\[7\] sky130_fd_sc_hd__dfrtp_1
X_6664_ _2280_ _2291_ _2292_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__nand3_1
XFILLER_32_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8403_ _3971_ _3973_ VGND VGND VPWR VPWR _3976_ sky130_fd_sc_hd__nor2_1
X_5615_ _1243_ _1244_ net219 net480 VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__and4bb_1
X_9383_ clknet_leaf_16_clk _0057_ _0293_ VGND VGND VPWR VPWR add_res\[29\] sky130_fd_sc_hd__dfrtp_1
X_6595_ _2136_ _2211_ _2210_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__a21o_1
XFILLER_117_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8334_ adder_inst.man_a_r\[7\] _3342_ net649 VGND VGND VPWR VPWR _3907_ sky130_fd_sc_hd__and3_1
XANTENNA__8767__B _3167_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5546_ net285 net420 net426 net278 VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a22oi_1
X_5477_ net602 _1104_ _1105_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nand3_1
X_8265_ net141 _3773_ _3837_ net143 VGND VGND VPWR VPWR _3838_ sky130_fd_sc_hd__o211a_1
XFILLER_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7216_ _0935_ _2837_ _2844_ VGND VGND VPWR VPWR _2846_ sky130_fd_sc_hd__a21oi_1
X_8196_ _3768_ _3769_ net135 VGND VGND VPWR VPWR _3770_ sky130_fd_sc_hd__mux2_1
Xfanout423 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_74_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4676__A2 net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout412 net413 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__clkbuf_4
Xfanout401 net402 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__buf_2
Xfanout434 net435 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_2
X_7147_ _2641_ _2676_ _2675_ VGND VGND VPWR VPWR _2777_ sky130_fd_sc_hd__a21bo_1
Xfanout456 net457 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_4
Xfanout445 net446 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout294_X net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout489 adder_inst.sum_raw_r\[22\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__buf_2
XFILLER_101_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout467 net468 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__clkbuf_4
Xfanout478 net479 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_2
X_7078_ _2706_ _2707_ VGND VGND VPWR VPWR _2708_ sky130_fd_sc_hd__and2b_1
XFILLER_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6029_ _1196_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout461_X net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8575__B1 net683 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8722__S net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input67_A rst VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8015__C1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8030__A2 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5557__A net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_119_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload22 clknet_leaf_16_clk VGND VGND VPWR VPWR clkload22/X sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_132_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload11 clknet_leaf_10_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinv_8
X_5400_ _1020_ _1021_ _1024_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_11_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6380_ _2008_ _1921_ _2007_ _1993_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__o211a_1
XFILLER_127_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5331_ _0920_ _0954_ _0919_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a21bo_1
X_8050_ _3628_ _3630_ net198 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__o21a_1
XFILLER_126_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5292__A net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5262_ net347 net307 net313 net341 VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__a22oi_1
X_7001_ _2623_ _2624_ _2629_ VGND VGND VPWR VPWR _2631_ sky130_fd_sc_hd__a21o_1
X_5193_ _0568_ _0570_ _0569_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__o21ai_1
XFILLER_96_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8952_ net530 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__inv_2
XFILLER_55_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8883_ net521 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__inv_2
X_7903_ adder_inst.sum_raw_r\[0\] net492 _3413_ _3505_ VGND VGND VPWR VPWR _3506_
+ sky130_fd_sc_hd__a31o_1
XFILLER_52_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7834_ adder_inst.exp_larger_r\[6\] _3422_ VGND VGND VPWR VPWR _3440_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout254_A net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_19_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7765_ adder_inst.is_zero_b_r net840 VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__or2_1
XANTENNA__6032__A1 net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6032__B2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9504_ clknet_leaf_17_clk net797 _0414_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_4977_ _0472_ _0474_ _0473_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__o21bai_1
X_6716_ _2343_ _2344_ _2342_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__o21ba_1
XANTENNA__6583__A2 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7696_ _3290_ _3312_ _3321_ VGND VGND VPWR VPWR _3322_ sky130_fd_sc_hd__and3_1
Xclkload5 clknet_leaf_3_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__bufinv_16
XANTENNA_fanout421_A net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9435_ clknet_leaf_12_clk multiplier_inst.exp_final\[0\] _0345_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6647_ _2199_ _2265_ _2270_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__a21o_1
X_9366_ clknet_leaf_25_clk _0039_ _0276_ VGND VGND VPWR VPWR add_res\[12\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout307_X net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6578_ _2126_ _2201_ _2200_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__a21o_1
XFILLER_106_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8317_ net457 net162 VGND VGND VPWR VPWR _3890_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5529_ net555 net395 net315 net322 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__and4_1
XFILLER_133_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9297_ clknet_leaf_3_clk net728 _0207_ VGND VGND VPWR VPWR adder_inst.man_a_r\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_59_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6099__A1 net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8248_ _3678_ _3811_ _3816_ net120 VGND VGND VPWR VPWR _3821_ sky130_fd_sc_hd__o31ai_1
XANTENNA__5846__A1 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8179_ net168 _3680_ net150 _3699_ _3752_ VGND VGND VPWR VPWR _3753_ sky130_fd_sc_hd__a41o_1
Xfanout220 net224 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_2
Xfanout231 net236 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout264 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_4
Xfanout242 net243 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_4
Xfanout253 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__buf_2
XFILLER_115_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout275 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__buf_4
XFILLER_87_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout286 net288 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_6
Xfanout297 net298 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__buf_6
XFILLER_75_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7857__A net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6574__A2 net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6655__B net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4900_ _0527_ _0528_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__or3_1
XFILLER_45_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5880_ _1411_ _1414_ _1508_ _1509_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__o211a_4
XFILLER_33_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4831_ net359 net292 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6014__A1 net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6014__B2 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4762_ _4531_ _4532_ VGND VGND VPWR VPWR _4533_ sky130_fd_sc_hd__or2_1
X_7550_ _3015_ _3179_ VGND VGND VPWR VPWR _3180_ sky130_fd_sc_hd__xor2_2
X_4693_ net213 net378 net384 net206 VGND VGND VPWR VPWR _4464_ sky130_fd_sc_hd__a22oi_1
X_7481_ _3103_ _3104_ VGND VGND VPWR VPWR _3111_ sky130_fd_sc_hd__nand2_1
X_6501_ net306 net442 VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__nand2_1
X_9220_ clknet_leaf_4_clk net15 _0130_ VGND VGND VPWR VPWR adder_inst.i_a\[22\] sky130_fd_sc_hd__dfrtp_1
X_6432_ _2055_ _2060_ _2054_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__a21bo_1
XFILLER_134_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9151_ net546 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__inv_2
X_8102_ _3673_ _3674_ _3273_ VGND VGND VPWR VPWR _3676_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_58_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6363_ _1905_ _1991_ _1992_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__nand3_4
X_9082_ net520 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_112_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5314_ _0941_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__nor2_1
X_6294_ _1908_ _1922_ _1923_ _1842_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__a211o_4
XFILLER_130_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8033_ net486 net489 net172 net490 _3617_ VGND VGND VPWR VPWR _3618_ sky130_fd_sc_hd__a221o_1
XFILLER_114_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5245_ _0851_ _0852_ _0853_ _0812_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__o22a_1
XFILLER_130_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5176_ _0802_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nand2_1
XFILLER_69_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout469_A adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout371_A net583 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8935_ net516 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__inv_2
XFILLER_45_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8866_ net814 mul_res\[18\] net506 VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__mux2_1
XFILLER_52_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7817_ adder_inst.exp_larger_r\[6\] _3422_ VGND VGND VPWR VPWR _3423_ sky130_fd_sc_hd__or2_1
X_8797_ _2121_ _4279_ _2120_ VGND VGND VPWR VPWR _4304_ sky130_fd_sc_hd__a21bo_1
XFILLER_12_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7748_ adder_inst.i_a\[9\] adder_inst.i_a\[10\] adder_inst.i_a\[12\] adder_inst.i_a\[15\]
+ VGND VGND VPWR VPWR _3366_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_82_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout424_X net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7679_ _3303_ _3304_ VGND VGND VPWR VPWR _3305_ sky130_fd_sc_hd__nor2_1
XFILLER_138_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5484__X _1114_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9418_ clknet_leaf_30_clk multiplier_inst.man_final\[6\] _0328_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_9349_ clknet_leaf_13_clk adder_inst.is_nan_a _0259_ VGND VGND VPWR VPWR adder_inst.is_nan_a_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_4_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5660__A net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8971__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7992__A1 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7992__B2 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5030_ _0656_ _0658_ _0623_ _0626_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_127_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6981_ _2601_ _2610_ VGND VGND VPWR VPWR _2611_ sky130_fd_sc_hd__xor2_1
X_8720_ net204 net188 _4084_ _4264_ _4087_ VGND VGND VPWR VPWR adder_inst.sum_raw\[24\]
+ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_109_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5932_ _1555_ _1556_ _1561_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__nand3_2
XFILLER_19_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8651_ _4201_ _3965_ VGND VGND VPWR VPWR _4209_ sky130_fd_sc_hd__and2b_1
XFILLER_22_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5729__B net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5863_ _1238_ _1240_ _1239_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__o21ba_1
XFILLER_34_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4814_ _0443_ _0438_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__and2b_1
X_8582_ _3878_ _3894_ _3897_ _4135_ _3879_ VGND VGND VPWR VPWR _4149_ sky130_fd_sc_hd__a221oi_4
X_7602_ net592 _3227_ _3228_ _3231_ VGND VGND VPWR VPWR _3232_ sky130_fd_sc_hd__o31a_1
XFILLER_61_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5794_ _1421_ _1422_ _1416_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__a21o_1
X_4745_ _4484_ _4515_ VGND VGND VPWR VPWR _4516_ sky130_fd_sc_hd__xnor2_1
X_7533_ _3160_ _3162_ net110 VGND VGND VPWR VPWR _3163_ sky130_fd_sc_hd__mux2_1
XFILLER_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5167__D net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout217_A net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4676_ net348 net245 net251 net344 VGND VGND VPWR VPWR _4447_ sky130_fd_sc_hd__a22o_1
X_7464_ _3086_ _3091_ _3089_ VGND VGND VPWR VPWR _3094_ sky130_fd_sc_hd__a21o_1
X_7395_ _2887_ _2951_ _3024_ _2886_ VGND VGND VPWR VPWR _3025_ sky130_fd_sc_hd__a211oi_2
X_9203_ clknet_leaf_31_clk net28 _0113_ VGND VGND VPWR VPWR adder_inst.i_a\[5\] sky130_fd_sc_hd__dfrtp_1
X_6415_ _1969_ _2043_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__and3_1
X_9134_ net525 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__inv_2
X_6346_ _1974_ _1975_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__nand2_2
XANTENNA__6381__A1_N net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9065_ net547 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__inv_2
XFILLER_103_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8775__B _2570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8016_ adder_inst.sum_raw_r\[16\] _3504_ _3601_ _3602_ VGND VGND VPWR VPWR _3603_
+ sky130_fd_sc_hd__o211a_1
XFILLER_102_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6277_ _1819_ _1818_ _1824_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__a21o_1
X_5228_ _0814_ _0851_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__o21ba_1
XANTENNA_fanout374_X net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5159_ net341 net307 _0787_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nand4_2
XFILLER_56_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7974__B2 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8918_ net507 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__inv_2
X_8849_ net835 mul_res\[1\] net503 VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__mux2_1
XFILLER_13_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6461__D net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5418__A2_N net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5655__A net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8151__A1 net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7292__D net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8177__S net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7965__A1 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8206__A net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_27_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_62_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5549__B net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_699 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8678__C1 net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8142__A1 net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold306 multiplier_inst.man_final_r\[18\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_68_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6153__B1 net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7180_ _2702_ _2704_ VGND VGND VPWR VPWR _2810_ sky130_fd_sc_hd__nand2_1
X_6200_ _1732_ _1827_ _1826_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__a21o_1
X_6131_ _1663_ _1754_ _1759_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__a21o_1
XFILLER_112_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6062_ _1684_ _1686_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__xnor2_1
X_5013_ net234 net398 net403 net228 VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a22oi_1
XFILLER_112_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_77_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7956__A1 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_18_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA__4644__A net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5967__B1 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6964_ net353 net359 net311 net318 VGND VGND VPWR VPWR _2594_ sky130_fd_sc_hd__and4_1
X_8703_ net188 _4254_ VGND VGND VPWR VPWR _4255_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_66_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6895_ _2520_ _2524_ _2519_ VGND VGND VPWR VPWR _2525_ sky130_fd_sc_hd__o21a_1
X_5915_ _1432_ _1445_ _1543_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__o211ai_2
X_8634_ _3974_ _4186_ _3976_ VGND VGND VPWR VPWR _4194_ sky130_fd_sc_hd__a21oi_1
X_5846_ net254 net440 _1400_ _1399_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__a31o_1
XFILLER_21_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout334_A net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8565_ _4126_ _4127_ _3831_ VGND VGND VPWR VPWR _4134_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_86_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5777_ _1184_ _1191_ _1405_ _1406_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__o211ai_4
X_8496_ net358 _4068_ net159 VGND VGND VPWR VPWR _4069_ sky130_fd_sc_hd__mux2_1
X_4728_ net212 net372 net378 net205 VGND VGND VPWR VPWR _4499_ sky130_fd_sc_hd__a22oi_1
X_7516_ _3144_ _3145_ VGND VGND VPWR VPWR _3146_ sky130_fd_sc_hd__and2_1
XFILLER_107_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4659_ net222 net386 VGND VGND VPWR VPWR _4430_ sky130_fd_sc_hd__nand2_1
X_7447_ _3049_ _3050_ _3057_ VGND VGND VPWR VPWR _3077_ sky130_fd_sc_hd__o21a_1
XANTENNA__5625__D net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6695__A1 net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6695__B2 net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7378_ _2988_ _2995_ VGND VGND VPWR VPWR _3008_ sky130_fd_sc_hd__xnor2_2
XANTENNA_fanout491_X net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9117_ net527 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__inv_2
X_6329_ _1957_ _1958_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__or2_1
X_9048_ net527 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__inv_2
XANTENNA__8725__S net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_95_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6456__D net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7849__B net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_717 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6191__D net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4933__A1 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4933__B2 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6438__A1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6438__B2 net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6989__A2 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5700_ net378 net383 net315 net321 VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__and4_1
XFILLER_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6680_ _2247_ _2259_ _2309_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_21_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4911__B net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5631_ _1219_ _1258_ _1259_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__or3_1
X_8350_ net154 _3919_ _3922_ VGND VGND VPWR VPWR _3923_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_61_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5562_ _1185_ _1190_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_135_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8281_ _3849_ _3851_ VGND VGND VPWR VPWR _3854_ sky130_fd_sc_hd__and2_1
X_7301_ _2826_ _2902_ _2903_ _2906_ VGND VGND VPWR VPWR _2931_ sky130_fd_sc_hd__a31o_1
X_5493_ _1121_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__and2_1
X_7232_ _2855_ _2861_ VGND VGND VPWR VPWR _2862_ sky130_fd_sc_hd__and2_1
XFILLER_132_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_117_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold158 adder_inst.i_b\[22\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 adder_inst.i_b\[12\] VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
Xhold169 adder_inst.i_a\[4\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
X_7163_ _2789_ _2792_ _2786_ VGND VGND VPWR VPWR _2793_ sky130_fd_sc_hd__a21oi_1
XFILLER_113_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7094_ net265 net400 net406 net261 VGND VGND VPWR VPWR _2724_ sky130_fd_sc_hd__a22o_1
XANTENNA__7015__A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6114_ _1645_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__nor2_1
XFILLER_100_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6045_ _1657_ _1656_ _1673_ _1674_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and4bb_1
XFILLER_100_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout284_A net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6573__B net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout451_A net598 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout549_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7996_ net483 net501 adder_inst.sum_raw_r\[16\] net171 _3585_ VGND VGND VPWR VPWR
+ _3586_ sky130_fd_sc_hd__a221o_1
XANTENNA__5189__B net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6947_ _1594_ _1601_ _2575_ VGND VGND VPWR VPWR _2577_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout337_X net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6878_ _2490_ _2507_ VGND VGND VPWR VPWR _2508_ sky130_fd_sc_hd__nor2_1
XFILLER_139_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8617_ _4007_ _4179_ VGND VGND VPWR VPWR adder_inst.sum_raw\[10\] sky130_fd_sc_hd__xnor2_1
X_5829_ net254 net434 VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__nand2_1
X_8548_ _4092_ _4119_ VGND VGND VPWR VPWR adder_inst.sum_raw\[1\] sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_79_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8479_ net246 net159 _3776_ _3981_ VGND VGND VPWR VPWR _4052_ sky130_fd_sc_hd__a22o_1
XFILLER_118_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7865__B1 net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_92_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8042__B1 adder_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input12_A i_a[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclone92 net554 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__clkbuf_1
Xclone81 net391 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__clkbuf_1
XFILLER_126_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7608__A0 _3217_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5095__B1 net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7850_ net490 net493 _3450_ _3451_ _3455_ VGND VGND VPWR VPWR _3456_ sky130_fd_sc_hd__o41a_1
XFILLER_82_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6801_ _2424_ _2429_ _2430_ VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__nand3_1
X_7781_ _4346_ _3386_ VGND VGND VPWR VPWR _3387_ sky130_fd_sc_hd__nor2_1
X_4993_ _0606_ _0621_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_63_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6732_ _2361_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__inv_2
X_9451_ clknet_leaf_28_clk _0100_ _0361_ VGND VGND VPWR VPWR mul_res\[6\] sky130_fd_sc_hd__dfrtp_1
X_6663_ _2280_ _2291_ _2292_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_34_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8402_ _3974_ VGND VGND VPWR VPWR _3975_ sky130_fd_sc_hd__inv_2
XANTENNA__6898__A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5614_ net231 net467 net474 net225 VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__a22oi_1
X_9382_ clknet_leaf_17_clk _0056_ _0292_ VGND VGND VPWR VPWR add_res\[28\] sky130_fd_sc_hd__dfrtp_1
X_6594_ _2217_ _2222_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__xnor2_1
XFILLER_129_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8333_ net561 _3905_ net164 VGND VGND VPWR VPWR _3906_ sky130_fd_sc_hd__mux2_2
X_5545_ net278 net285 net420 net426 VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__and4_1
X_5476_ _1097_ _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__and3_4
XFILLER_117_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8264_ net655 _3737_ _3735_ net140 VGND VGND VPWR VPWR _3837_ sky130_fd_sc_hd__o211ai_1
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8195_ net235 net376 net158 VGND VGND VPWR VPWR _3769_ sky130_fd_sc_hd__mux2_1
X_7215_ _0935_ _2837_ _2844_ VGND VGND VPWR VPWR _2845_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_74_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout413 net417 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__buf_4
XFILLER_59_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7146_ _2666_ _2668_ _2665_ VGND VGND VPWR VPWR _2776_ sky130_fd_sc_hd__o21ba_1
Xfanout402 net405 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input4_A i_a[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout435 adder_inst.man_a_r\[8\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout457 adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_4
Xfanout446 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__buf_4
Xfanout424 net425 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__buf_4
XANTENNA_fanout287_X net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout479 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__clkbuf_4
X_7077_ _2704_ _2705_ _2700_ VGND VGND VPWR VPWR _2707_ sky130_fd_sc_hd__a21o_1
Xfanout468 net469 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6028_ net271 net439 _1194_ _1195_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__o2bb2a_1
XANTENNA__8024__B1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout454_X net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7979_ adder_inst.sum_raw_r\[11\] _3570_ net191 VGND VGND VPWR VPWR _3571_ sky130_fd_sc_hd__mux2_1
XFILLER_81_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5928__A net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7565__D _3187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6494__A net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6941__B _2568_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8318__A1 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5557__B net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_119_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5001__B1 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkload23 clknet_leaf_17_clk VGND VGND VPWR VPWR clkload23/Y sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_132_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload12 clknet_leaf_21_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__inv_16
XTAP_TAPCELL_ROW_11_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5330_ _0917_ _0959_ net147 _0875_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__a211oi_2
XFILLER_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5573__A net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5261_ _0883_ _0884_ _0889_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__a21o_1
XANTENNA__5292__B net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7000_ _2623_ _2624_ _2629_ VGND VGND VPWR VPWR _2630_ sky130_fd_sc_hd__nand3_2
XFILLER_87_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5192_ net258 net405 _0820_ _0818_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a31o_1
XFILLER_110_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8951_ net530 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__inv_2
XFILLER_68_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6804__A1 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7902_ adder_inst.sum_raw_r\[2\] net487 _3462_ adder_inst.sum_raw_r\[1\] _3394_ VGND
+ VGND VPWR VPWR _3505_ sky130_fd_sc_hd__a221o_1
XFILLER_83_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8882_ net546 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__inv_2
XFILLER_64_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7833_ net185 _3438_ _3437_ _3435_ VGND VGND VPWR VPWR _3439_ sky130_fd_sc_hd__a211o_1
XFILLER_63_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7764_ _3371_ _3375_ _3376_ VGND VGND VPWR VPWR adder_inst.is_inf_a sky130_fd_sc_hd__and3_1
XANTENNA__4652__A net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6032__A2 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9503_ clknet_leaf_16_clk net785 _0413_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_4976_ _0601_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__and2_1
XFILLER_11_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout247_A net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6715_ _2342_ _2344_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__nor2_1
X_7695_ _3315_ _3320_ VGND VGND VPWR VPWR _3321_ sky130_fd_sc_hd__nor2_1
X_9434_ clknet_leaf_27_clk multiplier_inst.man_final\[22\] _0344_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[22\] sky130_fd_sc_hd__dfrtp_1
Xclkload6 clknet_leaf_31_clk VGND VGND VPWR VPWR clkload6/X sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout414_A net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6646_ _2274_ _2275_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__xnor2_1
XFILLER_137_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9365_ clknet_leaf_26_clk _0038_ _0275_ VGND VGND VPWR VPWR add_res\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_76_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6577_ _2205_ _2206_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__xnor2_1
XFILLER_133_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout202_X net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8316_ net156 _3888_ _3881_ VGND VGND VPWR VPWR _3889_ sky130_fd_sc_hd__o21ai_2
X_5528_ _1136_ _1157_ _1155_ _1154_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__o211a_1
XFILLER_105_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9296_ clknet_2_0__leaf_clk adder_inst.i_a\[8\] _0206_ VGND VGND VPWR VPWR adder_inst.man_a_r\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__6099__A2 net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5459_ _1059_ _0737_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and3_1
X_8247_ net665 _3805_ net124 VGND VGND VPWR VPWR _3820_ sky130_fd_sc_hd__a21oi_1
XFILLER_133_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8178_ _3751_ VGND VGND VPWR VPWR _3752_ sky130_fd_sc_hd__inv_2
XFILLER_87_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout221 net224 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_2
Xfanout232 net236 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_2
Xfanout210 net211 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_2
Xfanout243 net565 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_6
X_7129_ _2756_ _2757_ VGND VGND VPWR VPWR _2759_ sky130_fd_sc_hd__xnor2_1
Xfanout265 net270 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__clkbuf_4
Xfanout254 net255 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_2
XFILLER_115_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout287 net288 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout298 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_8
Xfanout276 net282 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8969__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8720__A1 net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7113__A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6655__C net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4830_ net347 net353 net298 net301 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__and4_1
XFILLER_45_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4761_ _4516_ _4530_ VGND VGND VPWR VPWR _4532_ sky130_fd_sc_hd__and2_1
X_4692_ net206 net213 net378 net384 VGND VGND VPWR VPWR _4463_ sky130_fd_sc_hd__and4_1
X_7480_ _3081_ _3108_ VGND VGND VPWR VPWR _3110_ sky130_fd_sc_hd__xnor2_1
X_6500_ _2051_ _2128_ _2127_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__a21o_1
XFILLER_119_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6431_ _2054_ _2055_ _2060_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__nand3_1
XFILLER_115_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9150_ net542 VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__inv_2
X_6362_ _1898_ net591 _1904_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__a21o_1
XFILLER_127_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8101_ _3273_ _3673_ _3674_ VGND VGND VPWR VPWR _3675_ sky130_fd_sc_hd__nand3b_2
X_5313_ _0941_ _0942_ net220 net437 VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_58_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9081_ net520 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__inv_2
X_6293_ _1828_ _1830_ _1841_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__a21oi_2
XFILLER_114_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8032_ net494 net190 net185 _3616_ VGND VGND VPWR VPWR _3617_ sky130_fd_sc_hd__o211a_1
X_5244_ _0855_ _0863_ _0862_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_71_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5175_ _0802_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand3_1
XFILLER_84_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8934_ net513 VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__inv_2
X_8865_ net761 mul_res\[17\] net506 VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__mux2_1
X_7816_ _3419_ _3421_ adder_inst.exp_larger_r\[5\] VGND VGND VPWR VPWR _3422_ sky130_fd_sc_hd__a21o_1
XFILLER_52_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5213__B1 net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8796_ _1974_ _4277_ _4278_ _4280_ _4302_ VGND VGND VPWR VPWR _4303_ sky130_fd_sc_hd__o2111ai_1
XFILLER_24_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4959_ _0587_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_82_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7747_ adder_inst.i_a\[1\] adder_inst.i_a\[0\] adder_inst.i_a\[3\] adder_inst.i_a\[2\]
+ VGND VGND VPWR VPWR _3365_ sky130_fd_sc_hd__or4_2
XANTENNA_fanout417_X net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7678_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] VGND VGND VPWR VPWR _3304_
+ sky130_fd_sc_hd__and2b_1
X_9417_ clknet_leaf_30_clk multiplier_inst.man_final\[5\] _0327_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_6629_ _2195_ _2243_ _2246_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__or3_1
XFILLER_125_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9348_ clknet_leaf_13_clk net689 _0258_ VGND VGND VPWR VPWR adder_inst.i_vld_r2 sky130_fd_sc_hd__dfrtp_1
XFILLER_118_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9279_ clknet_leaf_22_clk adder_inst.sum_raw\[16\] _0189_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[16\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5660__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_106_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_747 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_115_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6385__C net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_127_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6980_ _2608_ _2609_ VGND VGND VPWR VPWR _2610_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_109_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5931_ _1557_ _1560_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_124_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8650_ _3964_ _4104_ _3965_ VGND VGND VPWR VPWR _4208_ sky130_fd_sc_hd__o21a_1
X_5862_ _1488_ _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__xnor2_1
X_4813_ _4435_ _4440_ _4434_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a21oi_1
X_8581_ _4146_ _4147_ VGND VGND VPWR VPWR _4148_ sky130_fd_sc_hd__nand2_1
X_7601_ _4370_ net131 _3151_ _3230_ VGND VGND VPWR VPWR _3231_ sky130_fd_sc_hd__a31o_1
XFILLER_33_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5793_ _1416_ _1421_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__nand3_1
X_4744_ net345 adder_inst.man_b_r\[17\] _4401_ VGND VGND VPWR VPWR _4515_ sky130_fd_sc_hd__and3_1
X_7532_ _2795_ _3161_ VGND VGND VPWR VPWR _3162_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4675_ net348 net344 net245 net251 VGND VGND VPWR VPWR _4446_ sky130_fd_sc_hd__and4_1
X_9202_ clknet_leaf_31_clk net27 _0112_ VGND VGND VPWR VPWR adder_inst.i_a\[4\] sky130_fd_sc_hd__dfrtp_1
X_7463_ _3092_ VGND VGND VPWR VPWR _3093_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_133_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout112_A net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7394_ _2888_ _2952_ _3023_ VGND VGND VPWR VPWR _3024_ sky130_fd_sc_hd__and3_1
X_6414_ _1885_ _1968_ _1967_ _1964_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9133_ net526 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__inv_2
X_6345_ _1969_ _1971_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__xnor2_2
X_9064_ net545 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__inv_2
XFILLER_115_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5761__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6276_ _1899_ _1904_ _1898_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__a21bo_1
X_8015_ net499 net189 _3463_ net502 net186 VGND VGND VPWR VPWR _3602_ sky130_fd_sc_hd__o221a_1
X_5227_ _0584_ _0589_ _0583_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__o21a_1
XANTENNA__6576__B net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout481_A net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5158_ _0780_ _0781_ _0786_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21o_1
XFILLER_69_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5089_ _0688_ _0717_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__and3_4
XANTENNA__7423__A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7423__B2 net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7974__A2 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout367_X net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8917_ net507 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__inv_2
XFILLER_56_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout534_X net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8848_ net755 mul_res\[0\] net503 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__mux2_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8779_ _2553_ _2558_ VGND VGND VPWR VPWR _4286_ sky130_fd_sc_hd__xor2_1
XFILLER_25_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5737__A1 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5737__B2 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer5_X net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5655__B net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input42_A i_b[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8982__A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7414__A1 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8206__B net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6153__B2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6153__A1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6130_ _1663_ _1754_ _1759_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__nand3_2
XANTENNA__5581__A net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6061_ net241 net247 net467 net474 _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__a41o_1
X_5012_ net228 net234 net398 net403 VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__and4_1
XFILLER_112_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7956__A2 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4644__B net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5967__B2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5967__A1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6963_ net367 net305 VGND VGND VPWR VPWR _2593_ sky130_fd_sc_hd__nand2_1
X_8702_ _4059_ _4060_ _4062_ _4250_ _4067_ VGND VGND VPWR VPWR _4254_ sky130_fd_sc_hd__a32o_2
XFILLER_81_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6894_ _2521_ _2523_ VGND VGND VPWR VPWR _2524_ sky130_fd_sc_hd__nor2_1
X_5914_ _1530_ _1531_ _1542_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a21o_1
X_8633_ _3977_ _4193_ VGND VGND VPWR VPWR adder_inst.sum_raw\[12\] sky130_fd_sc_hd__xnor2_1
X_5845_ _1226_ _1228_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__nand2_1
XFILLER_61_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8564_ _3824_ _3827_ VGND VGND VPWR VPWR _4133_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout327_A adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5776_ _1403_ _1404_ _1389_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__a21o_1
X_8495_ _3678_ net128 net121 _3871_ VGND VGND VPWR VPWR _4068_ sky130_fd_sc_hd__and4_1
X_4727_ net205 net212 net372 net378 VGND VGND VPWR VPWR _4498_ sky130_fd_sc_hd__and4_1
X_7515_ _3106_ _3109_ _3143_ VGND VGND VPWR VPWR _3145_ sky130_fd_sc_hd__or3_1
X_4658_ net229 net235 net374 net380 VGND VGND VPWR VPWR _4429_ sky130_fd_sc_hd__and4_1
X_7446_ _3074_ _3075_ VGND VGND VPWR VPWR _3076_ sky130_fd_sc_hd__nor2_1
XFILLER_101_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9116_ net527 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__inv_2
X_4589_ net204 net345 VGND VGND VPWR VPWR _4360_ sky130_fd_sc_hd__nand2_1
X_7377_ _2775_ _2782_ _2774_ VGND VGND VPWR VPWR _3007_ sky130_fd_sc_hd__a21boi_2
XFILLER_107_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6328_ _1937_ _1939_ _1956_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__and3_1
XFILLER_1_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout484_X net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9047_ net527 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__inv_2
X_6259_ _1806_ _1888_ _1887_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__a21oi_1
XFILLER_76_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4835__A net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4933__A2 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8188__S net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5630_ _1219_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_61_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5561_ _1185_ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_135_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5492_ _0719_ _0721_ _1120_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__or3b_1
X_8280_ _3849_ _3851_ VGND VGND VPWR VPWR _3853_ sky130_fd_sc_hd__nor2_1
X_7300_ _2914_ _2929_ VGND VGND VPWR VPWR _2930_ sky130_fd_sc_hd__or2_1
X_7231_ _2859_ _2860_ VGND VGND VPWR VPWR _2861_ sky130_fd_sc_hd__nor2_1
XFILLER_7_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold159 adder_inst.i_b\[20\] VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_117_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold148 adder_inst.i_a\[12\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__4688__A1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7162_ _2791_ _2790_ VGND VGND VPWR VPWR _2792_ sky130_fd_sc_hd__nand2b_1
X_7093_ net261 net265 net400 net406 VGND VGND VPWR VPWR _2723_ sky130_fd_sc_hd__and4_1
XANTENNA__7015__B net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6113_ net290 net426 _1643_ _1644_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_113_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6044_ _1671_ _1672_ _1665_ _1669_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__a211o_1
XANTENNA__4655__A net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout277_A net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6573__C net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7995_ adder_inst.sum_raw_r\[13\] _3504_ _3583_ _3584_ VGND VGND VPWR VPWR _3585_
+ sky130_fd_sc_hd__o211a_1
XFILLER_94_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6946_ _1594_ _1601_ VGND VGND VPWR VPWR _2576_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout444_A adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6870__A net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6877_ _2500_ _2505_ _2504_ VGND VGND VPWR VPWR _2507_ sky130_fd_sc_hd__a21oi_1
X_8616_ _4175_ _4178_ net173 VGND VGND VPWR VPWR _4179_ sky130_fd_sc_hd__mux2_4
XANTENNA_fanout232_X net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7562__A0 _3176_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5828_ _1454_ _1455_ _1456_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__a21o_1
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8547_ _4118_ net187 _4117_ VGND VGND VPWR VPWR _4119_ sky130_fd_sc_hd__o21ai_4
X_5759_ _1339_ _1347_ _1346_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_79_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8478_ _4050_ VGND VGND VPWR VPWR _4051_ sky130_fd_sc_hd__inv_2
XFILLER_118_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7429_ _4481_ _3058_ VGND VGND VPWR VPWR _3059_ sky130_fd_sc_hd__and2_2
XFILLER_2_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7595__B _1035_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone60 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__clkbuf_1
XFILLER_5_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6132__A2_N net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_130_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8646__S net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7608__A1 _3237_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5095__B2 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5095__A1 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8033__A1 net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6800_ _2379_ _2418_ _2423_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__a21o_1
X_7780_ adder_inst.exp_larger_r\[1\] net196 VGND VGND VPWR VPWR _3386_ sky130_fd_sc_hd__nand2_1
X_4992_ _0614_ _0615_ _0620_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__a21o_1
XFILLER_90_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6731_ _2352_ _2360_ _2302_ _2319_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__a211o_1
X_9450_ clknet_leaf_27_clk _0099_ _0360_ VGND VGND VPWR VPWR mul_res\[5\] sky130_fd_sc_hd__dfrtp_1
X_6662_ _2209_ _2264_ _2279_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__a21o_1
X_9381_ clknet_leaf_17_clk _0055_ _0291_ VGND VGND VPWR VPWR add_res\[27\] sky130_fd_sc_hd__dfrtp_1
X_8401_ _3971_ _3973_ VGND VGND VPWR VPWR _3974_ sky130_fd_sc_hd__nand2_1
X_5613_ net225 net231 net467 net474 VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__and4_1
XFILLER_117_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8332_ net121 _3904_ _3902_ _3903_ VGND VGND VPWR VPWR _3905_ sky130_fd_sc_hd__a2bb2o_1
X_6593_ _2222_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__inv_2
XFILLER_129_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5544_ _1172_ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__nand2b_1
X_5475_ _1065_ _1087_ _1096_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__o21ai_1
XFILLER_105_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8263_ net125 _3833_ _3834_ _3835_ net122 VGND VGND VPWR VPWR _3836_ sky130_fd_sc_hd__o221ai_1
X_8194_ net229 net370 net158 VGND VGND VPWR VPWR _3768_ sky130_fd_sc_hd__mux2_1
X_7214_ _2841_ _2842_ _2840_ VGND VGND VPWR VPWR _2844_ sky130_fd_sc_hd__a21bo_1
Xfanout403 net404 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_74_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7145_ _2683_ _2773_ VGND VGND VPWR VPWR _2775_ sky130_fd_sc_hd__xnor2_2
Xfanout414 net415 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__buf_2
XFILLER_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout425 net429 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_4
Xfanout436 net438 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_4
Xfanout447 net448 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout469 adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__buf_4
X_7076_ _2700_ _2704_ _2705_ VGND VGND VPWR VPWR _2706_ sky130_fd_sc_hd__and3_1
Xfanout458 net459 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__buf_2
XFILLER_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6027_ _1655_ _1319_ _1654_ _1641_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a211oi_2
XFILLER_70_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7978_ adder_inst.sum_raw_r\[10\] net495 _3568_ _3569_ VGND VGND VPWR VPWR _3570_
+ sky130_fd_sc_hd__a22o_1
XFILLER_15_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout447_X net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5928__B net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6929_ _2553_ _2558_ VGND VGND VPWR VPWR _2559_ sky130_fd_sc_hd__or2_1
XFILLER_80_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5309__A2_N net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5849__B1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6494__B net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5557__C net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_119_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5001__B2 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5001__A1 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_132_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload24 clknet_leaf_18_clk VGND VGND VPWR VPWR clkload24/Y sky130_fd_sc_hd__inv_8
Xclkload13 clknet_leaf_24_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_11_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5573__B net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5260_ _0883_ _0884_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nand3_1
XANTENNA__5292__C net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_114_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_721 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5191_ _0818_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and2b_1
XFILLER_96_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8950_ net530 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__inv_2
XFILLER_68_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8006__B2 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7901_ net492 _3413_ VGND VGND VPWR VPWR _3504_ sky130_fd_sc_hd__nand2_2
XFILLER_37_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8881_ _3628_ _4331_ net199 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__o21a_1
XFILLER_36_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7832_ adder_inst.exp_larger_r\[7\] _3423_ VGND VGND VPWR VPWR _3438_ sky130_fd_sc_hd__xor2_1
XFILLER_70_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6568__A1 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6568__B2 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7763_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] adder_inst.exp_a\[2\]
+ VGND VGND VPWR VPWR _3376_ sky130_fd_sc_hd__and4_1
X_4975_ _0603_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nor2_1
XANTENNA__4652__B net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9502_ clknet_leaf_17_clk net806 _0412_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_6714_ net299 net464 net470 net293 VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__a22oi_1
X_7694_ net572 _3286_ _3314_ VGND VGND VPWR VPWR _3320_ sky130_fd_sc_hd__a21oi_1
X_9433_ clknet_leaf_27_clk multiplier_inst.man_final\[21\] _0343_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[21\] sky130_fd_sc_hd__dfrtp_1
Xclkload7 clknet_leaf_5_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinvlp_4
XANTENNA__8190__A0 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6645_ net305 net452 VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__nand2_1
XFILLER_118_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9364_ clknet_leaf_25_clk _0037_ _0274_ VGND VGND VPWR VPWR add_res\[10\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout407_A net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6576_ net306 net447 VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__nand2_1
X_8315_ net121 _3883_ _3885_ _3887_ VGND VGND VPWR VPWR _3888_ sky130_fd_sc_hd__a31oi_2
X_5527_ _0977_ _1152_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_76_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9295_ clknet_leaf_31_clk net711 _0205_ VGND VGND VPWR VPWR adder_inst.man_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_117_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8246_ _3677_ _3817_ _3818_ net119 VGND VGND VPWR VPWR _3819_ sky130_fd_sc_hd__a31o_1
X_5458_ _1046_ _1047_ _1058_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__o21ai_1
XFILLER_132_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout222 net224 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_4
Xfanout211 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__clkbuf_4
X_5389_ _4544_ _0439_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__xor2_1
X_8177_ net288 net428 net155 VGND VGND VPWR VPWR _3751_ sky130_fd_sc_hd__mux2_1
Xfanout200 net202 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout397_X net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__buf_4
XFILLER_87_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4827__B _0456_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout233 net236 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_2
Xfanout255 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_4
X_7128_ _2757_ _2756_ VGND VGND VPWR VPWR _2758_ sky130_fd_sc_hd__and2b_1
Xfanout288 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_6
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout277 net282 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__buf_2
X_7059_ net353 net312 net318 net347 VGND VGND VPWR VPWR _2689_ sky130_fd_sc_hd__a22oi_2
XFILLER_47_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout299 net300 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_2
Xfanout266 net267 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__buf_2
XFILLER_75_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4843__A net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8985__A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7113__B net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6655__D net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_607 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4760_ _4516_ _4530_ VGND VGND VPWR VPWR _4531_ sky130_fd_sc_hd__nor2_1
XFILLER_61_698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4981__B1 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8172__A0 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4691_ _4460_ _4461_ VGND VGND VPWR VPWR _4462_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5525__A2 _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6430_ _2056_ _2059_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__xnor2_1
X_6361_ _1984_ _1989_ _1983_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__a21bo_1
XANTENNA__8895__A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8100_ _3342_ net645 _3672_ VGND VGND VPWR VPWR _3674_ sky130_fd_sc_hd__a21o_1
X_5312_ net233 net428 net432 net227 VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_58_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9080_ net535 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__inv_2
XFILLER_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6292_ _1908_ _1909_ net614 VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__nand3_4
X_8031_ _3463_ _3614_ _3615_ net497 VGND VGND VPWR VPWR _3616_ sky130_fd_sc_hd__a22o_1
XFILLER_102_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5243_ _0869_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__or2_1
XFILLER_114_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8227__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5174_ _0562_ _0564_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_71_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6238__B1 net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8933_ net513 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8864_ net787 mul_res\[16\] net506 VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__mux2_1
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7815_ net190 _3396_ _3406_ VGND VGND VPWR VPWR _3421_ sky130_fd_sc_hd__or3_1
XANTENNA_fanout357_A net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5213__B2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5213__A1 net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8795_ _4300_ _4301_ VGND VGND VPWR VPWR _4302_ sky130_fd_sc_hd__nor2_1
XFILLER_40_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4958_ net200 net437 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout524_A net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7746_ adder_inst.i_a\[5\] adder_inst.i_a\[4\] adder_inst.i_a\[7\] adder_inst.i_a\[6\]
+ VGND VGND VPWR VPWR _3364_ sky130_fd_sc_hd__or4_2
XFILLER_138_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7677_ adder_inst.exp_a_r\[4\] adder_inst.exp_b_r\[4\] VGND VGND VPWR VPWR _3303_
+ sky130_fd_sc_hd__and2b_1
X_4889_ net240 net398 _0516_ _0517_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a22o_1
XFILLER_137_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9416_ clknet_leaf_29_clk multiplier_inst.man_final\[4\] _0326_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_6628_ _2193_ _2247_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__xor2_1
X_9347_ clknet_leaf_13_clk net692 _0257_ VGND VGND VPWR VPWR adder_inst.i_vld_r sky130_fd_sc_hd__dfrtp_1
XFILLER_137_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6559_ _2184_ _2187_ _2114_ _2188_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__a211o_1
XFILLER_3_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9278_ clknet_leaf_22_clk adder_inst.sum_raw\[15\] _0188_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[15\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8229_ net168 _3680_ net150 _3699_ _3755_ VGND VGND VPWR VPWR _3802_ sky130_fd_sc_hd__a41oi_2
XFILLER_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8045__A adder_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4573__A adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6385__D net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_127_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6963__A net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_109_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5930_ _1558_ _1559_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__and2b_1
XFILLER_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7600_ _3036_ _3229_ VGND VGND VPWR VPWR _3230_ sky130_fd_sc_hd__or2_1
XFILLER_22_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5861_ _1489_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__nor2_1
X_4812_ _0440_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__or2_1
X_8580_ _4140_ _4139_ _3880_ VGND VGND VPWR VPWR _4147_ sky130_fd_sc_hd__a21o_1
XFILLER_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5792_ _1419_ _1420_ _1417_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__o21ai_1
XANTENNA__8145__A0 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4743_ _4512_ _4513_ VGND VGND VPWR VPWR _4514_ sky130_fd_sc_hd__xnor2_1
X_7531_ _2574_ _2799_ _2797_ VGND VGND VPWR VPWR _3161_ sky130_fd_sc_hd__a21o_1
X_7462_ _3086_ _3091_ VGND VGND VPWR VPWR _3092_ sky130_fd_sc_hd__xnor2_1
XFILLER_119_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4674_ net354 net240 VGND VGND VPWR VPWR _4445_ sky130_fd_sc_hd__nand2_1
X_9201_ clknet_leaf_0_clk net26 _0111_ VGND VGND VPWR VPWR adder_inst.i_a\[3\] sky130_fd_sc_hd__dfrtp_1
X_6413_ _2038_ _2041_ _1966_ _2042_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__a211oi_4
XFILLER_135_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7393_ _2982_ _3002_ _2981_ VGND VGND VPWR VPWR _3023_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout105_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9132_ net525 VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__inv_2
X_6344_ _1889_ _1891_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__nor2_4
XFILLER_1_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9063_ net544 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__inv_2
XFILLER_130_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4658__A net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5761__B net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6459__B1 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6275_ _1898_ _1899_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__nand3_1
X_8014_ adder_inst.sum_raw_r\[12\] _3432_ _3523_ adder_inst.sum_raw_r\[13\] _3600_
+ VGND VGND VPWR VPWR _3601_ sky130_fd_sc_hd__a221o_1
X_5226_ _0816_ _0850_ _0814_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21o_1
XFILLER_102_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5157_ _0780_ _0781_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__nand3_1
XFILLER_69_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout474_A net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5088_ _0700_ _0702_ _0716_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__o21ai_1
XANTENNA__7423__A2 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout262_X net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8916_ net508 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__inv_2
XFILLER_56_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8847_ net776 mul_ovf net505 VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__mux2_1
XFILLER_52_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8778_ _2556_ _2560_ _2562_ _2563_ VGND VGND VPWR VPWR _4285_ sky130_fd_sc_hd__o22a_1
XFILLER_12_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7729_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _3351_ sky130_fd_sc_hd__or4_1
XFILLER_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7229__A2_N net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input35_A i_b[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7414__A2 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_122_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7886__C1 _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6153__A2 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5581__B net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6060_ net237 net480 _1688_ _1689_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__and4_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5011_ _0636_ _0637_ _0638_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21oi_1
XFILLER_87_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6693__A net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4644__C net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5967__A2 net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6962_ _2586_ _2589_ VGND VGND VPWR VPWR _2592_ sky130_fd_sc_hd__xnor2_1
X_8701_ _4065_ net661 _4064_ _4245_ _4252_ VGND VGND VPWR VPWR _4253_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_66_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6893_ _2520_ _2522_ VGND VGND VPWR VPWR _2523_ sky130_fd_sc_hd__or2_1
X_5913_ _1530_ _1531_ _1542_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__nand3_1
X_8632_ net174 _4190_ _4192_ _4191_ VGND VGND VPWR VPWR _4193_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_62_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5844_ _1223_ _1231_ _1230_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__a21bo_1
X_8563_ _3831_ _4132_ VGND VGND VPWR VPWR adder_inst.sum_raw\[3\] sky130_fd_sc_hd__xor2_1
X_7514_ _3106_ _3109_ _3143_ VGND VGND VPWR VPWR _3144_ sky130_fd_sc_hd__o21ai_1
X_5775_ _1389_ _1403_ _1404_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__nand3_4
XANTENNA_fanout222_A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8494_ _4064_ _4066_ VGND VGND VPWR VPWR _4067_ sky130_fd_sc_hd__nand2_1
X_4726_ _4495_ _4496_ VGND VGND VPWR VPWR _4497_ sky130_fd_sc_hd__nor2_1
XFILLER_135_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4657_ _4426_ _4427_ VGND VGND VPWR VPWR _4428_ sky130_fd_sc_hd__nor2_1
X_7445_ _4538_ _4540_ _3072_ VGND VGND VPWR VPWR _3075_ sky130_fd_sc_hd__and3_1
XFILLER_116_740 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7376_ _2999_ _3000_ VGND VGND VPWR VPWR _3006_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout108_X net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9115_ net529 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__inv_2
X_4588_ net352 net209 VGND VGND VPWR VPWR _4359_ sky130_fd_sc_hd__nand2_1
X_6327_ _1937_ _1939_ _1956_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__a21oi_2
XFILLER_115_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9046_ net525 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__inv_2
X_6258_ _1711_ _1805_ _1803_ _1800_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__a211o_1
XFILLER_131_787 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5209_ _0837_ _0838_ net220 net432 VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__and4bb_1
XANTENNA_fanout477_X net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6189_ _1817_ _1722_ _1816_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_4_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4835__B net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6108__A net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5947__A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7580__A1 _3209_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8596__B1 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_106_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkload0_A clknet_2_0__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4909__B1 net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5560_ _1186_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__xnor2_1
X_5491_ _0719_ _0721_ _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__o21bai_2
XFILLER_117_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7230_ _2856_ _2857_ net200 net454 VGND VGND VPWR VPWR _2860_ sky130_fd_sc_hd__and4b_1
XFILLER_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_117_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold149 adder_inst.i_b\[14\] VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_98_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7161_ _2787_ _2788_ VGND VGND VPWR VPWR _2791_ sky130_fd_sc_hd__xnor2_1
X_7092_ net255 net412 VGND VGND VPWR VPWR _2722_ sky130_fd_sc_hd__nand2_1
X_6112_ _1727_ _1729_ _1728_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__o21ba_1
XFILLER_58_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6043_ _1665_ _1669_ _1671_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__o211ai_4
XFILLER_39_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4655__B net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6573__D net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7994_ adder_inst.sum_raw_r\[15\] net190 net169 adder_inst.sum_raw_r\[14\] net184
+ VGND VGND VPWR VPWR _3584_ sky130_fd_sc_hd__o221a_1
XFILLER_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6945_ _1573_ _1606_ _1605_ VGND VGND VPWR VPWR _2575_ sky130_fd_sc_hd__o21bai_1
XANTENNA__6870__B net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout437_A net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6876_ _2504_ _2505_ VGND VGND VPWR VPWR _2506_ sky130_fd_sc_hd__nand2b_1
X_8615_ _4102_ _4177_ net106 VGND VGND VPWR VPWR _4178_ sky130_fd_sc_hd__mux2_4
XANTENNA__7562__A1 _3189_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5827_ _1454_ _1455_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__nand3_1
X_8546_ _3782_ _3783_ net105 VGND VGND VPWR VPWR _4118_ sky130_fd_sc_hd__mux2_4
XANTENNA_fanout225_X net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5758_ _1386_ _1385_ _1337_ _1350_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__a211oi_2
XFILLER_136_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8477_ _4046_ _4047_ VGND VGND VPWR VPWR _4050_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_79_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4709_ net354 net240 _4447_ _4446_ VGND VGND VPWR VPWR _4480_ sky130_fd_sc_hd__a31o_1
X_7428_ _3051_ _3056_ VGND VGND VPWR VPWR _3058_ sky130_fd_sc_hd__xnor2_1
X_5689_ _1316_ _1317_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_9_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7359_ _2761_ _2763_ _2760_ VGND VGND VPWR VPWR _2989_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_9_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9029_ net514 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__inv_2
XFILLER_104_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8988__A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_101_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5095__A2 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8033__A2 net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4991_ _0614_ _0615_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nand3_1
XFILLER_63_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6730_ _2352_ _2358_ _2359_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__nand3_2
XANTENNA__5587__A net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8898__A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6661_ _2284_ _2289_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9380_ clknet_leaf_15_clk _0054_ _0290_ VGND VGND VPWR VPWR add_res\[26\] sky130_fd_sc_hd__dfrtp_1
X_8400_ net411 _3969_ net157 VGND VGND VPWR VPWR _3973_ sky130_fd_sc_hd__mux2_1
X_6592_ _2219_ _2220_ _2218_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__o21ba_1
X_5612_ _1238_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__xnor2_1
XFILLER_136_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8331_ net144 net138 _3784_ VGND VGND VPWR VPWR _3904_ sky130_fd_sc_hd__or3b_1
X_5543_ _1162_ _1167_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__xnor2_1
X_5474_ _1102_ _1101_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__xnor2_2
X_8262_ net139 _3717_ net125 VGND VGND VPWR VPWR _3835_ sky130_fd_sc_hd__o21ai_1
X_8193_ _3763_ _3766_ net141 VGND VGND VPWR VPWR _3767_ sky130_fd_sc_hd__mux2_1
XFILLER_105_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7213_ _2840_ _2841_ _2842_ VGND VGND VPWR VPWR _2843_ sky130_fd_sc_hd__nand3_1
Xfanout404 net405 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7144_ _2683_ _2773_ VGND VGND VPWR VPWR _2774_ sky130_fd_sc_hd__nand2b_1
XFILLER_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout437 net438 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__buf_2
Xfanout415 net417 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__clkbuf_2
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__clkbuf_4
Xfanout426 net429 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__buf_2
XANTENNA_fanout387_A net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout459 net460 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__buf_2
X_7075_ _2702_ _2703_ _2701_ VGND VGND VPWR VPWR _2705_ sky130_fd_sc_hd__a21bo_1
X_6026_ _1641_ _1654_ _1655_ _1319_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__o211a_4
XANTENNA_fanout175_X net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7977_ adder_inst.sum_raw_r\[9\] _4341_ net182 adder_inst.sum_raw_r\[7\] net193 VGND
+ VGND VPWR VPWR _3569_ sky130_fd_sc_hd__o221a_1
XFILLER_82_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout342_X net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5928__C net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6928_ _2555_ _2557_ VGND VGND VPWR VPWR _2558_ sky130_fd_sc_hd__xor2_2
XFILLER_23_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6859_ _2467_ _2471_ _2470_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_33_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5546__B1 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8529_ _4100_ _3948_ _4101_ VGND VGND VPWR VPWR _4102_ sky130_fd_sc_hd__o21ai_4
XFILLER_13_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5849__A1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5849__B2 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_103_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5557__D net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5001__A2 net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_132_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload25 clknet_leaf_19_clk VGND VGND VPWR VPWR clkload25/Y sky130_fd_sc_hd__inv_12
Xclkload14 clknet_leaf_25_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_11_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6031__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5573__C net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5292__D net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5190_ net391 net269 net397 net263 VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__a22o_1
XFILLER_110_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7900_ net114 _3502_ _3503_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and3_1
XFILLER_49_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8880_ adder_inst.is_zero_r _3497_ VGND VGND VPWR VPWR _4331_ sky130_fd_sc_hd__nor2_1
X_7831_ _3436_ adder_inst.exp_larger_r\[7\] _3392_ VGND VGND VPWR VPWR _3437_ sky130_fd_sc_hd__mux2_1
XFILLER_64_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7762_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _3375_ sky130_fd_sc_hd__and4_1
X_4974_ net349 net292 net609 net342 VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a22oi_1
XANTENNA__4652__C net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9501_ clknet_leaf_16_clk net823 _0411_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
X_7693_ net613 _3290_ _3314_ VGND VGND VPWR VPWR _3319_ sky130_fd_sc_hd__and3_1
X_6713_ net289 net477 VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__nand2_1
X_9432_ clknet_leaf_30_clk multiplier_inst.man_final\[20\] _0342_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[20\] sky130_fd_sc_hd__dfrtp_1
X_6644_ _2272_ _2273_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__nor2_1
XFILLER_32_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload8 clknet_leaf_6_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinv_8
XANTENNA__8190__A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9363_ clknet_leaf_26_clk _0067_ _0273_ VGND VGND VPWR VPWR add_res\[9\] sky130_fd_sc_hd__dfrtp_1
X_6575_ _2203_ _2204_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__and2b_1
X_8314_ net126 net119 _3767_ VGND VGND VPWR VPWR _3887_ sky130_fd_sc_hd__and3_1
X_5526_ _1145_ _1149_ _1144_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_76_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9294_ clknet_leaf_31_clk net738 _0204_ VGND VGND VPWR VPWR adder_inst.man_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA_fanout302_A net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5457_ _1061_ _1062_ _1064_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a21oi_1
X_8245_ _3809_ _3810_ net127 VGND VGND VPWR VPWR _3818_ sky130_fd_sc_hd__a21o_1
XFILLER_105_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout223 net224 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_2
X_5388_ _4399_ _1014_ _1017_ _1015_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__nor4_4
X_8176_ _3749_ VGND VGND VPWR VPWR _3750_ sky130_fd_sc_hd__inv_2
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_2
Xfanout201 net202 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_2
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_2
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_6
XFILLER_113_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout256 net258 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout292_X net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7127_ _2657_ _2659_ _2658_ VGND VGND VPWR VPWR _2757_ sky130_fd_sc_hd__o21ba_1
XFILLER_101_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7453__B1 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout267 net270 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
X_7058_ net347 net353 net312 net318 VGND VGND VPWR VPWR _2688_ sky130_fd_sc_hd__and4_1
Xfanout278 net279 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__buf_2
Xfanout289 net292 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__clkbuf_4
XFILLER_28_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6009_ _1295_ _1296_ _1298_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__a21o_1
XANTENNA__7893__A_N adder_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4843__B net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5020__A net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8181__A1 net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6192__B1 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4742__A1 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input65_A i_vld VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__9162__A net539 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6495__A1 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6495__B2 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_129_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7995__A1 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4981__B2 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4981__A1 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8172__A1 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4690_ _4423_ _4426_ VGND VGND VPWR VPWR _4461_ sky130_fd_sc_hd__nor2_1
X_6360_ _1983_ _1984_ _1989_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__nand3_1
XFILLER_127_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5311_ net227 net233 net428 net432 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_58_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8030_ net501 net191 net490 VGND VGND VPWR VPWR _3615_ sky130_fd_sc_hd__a21o_1
XFILLER_103_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6291_ _1920_ _1909_ _1908_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__and3_1
XFILLER_88_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5242_ _0858_ _0861_ _0868_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nor3_1
X_5173_ _0498_ _0796_ _0801_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_71_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6238__B2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6238__A1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7986__A1 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput1 i_a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_68_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8932_ net515 VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__inv_2
X_8863_ net798 mul_res\[15\] net506 VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__mux2_1
XFILLER_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7814_ _3395_ _3406_ VGND VGND VPWR VPWR _3420_ sky130_fd_sc_hd__or2_1
XFILLER_101_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8850__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5213__A2 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8794_ _2257_ _4281_ VGND VGND VPWR VPWR _4301_ sky130_fd_sc_hd__xnor2_1
X_7745_ adder_inst.man_b\[23\] _3363_ VGND VGND VPWR VPWR adder_inst.is_zero_b sky130_fd_sc_hd__and2b_1
X_4957_ _0585_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_82_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout517_A net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7676_ _3300_ _3301_ VGND VGND VPWR VPWR _3302_ sky130_fd_sc_hd__nor2_1
X_4888_ net239 net398 _0516_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_82_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9415_ clknet_leaf_30_clk multiplier_inst.man_final\[3\] _0325_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
X_6627_ _2191_ _2192_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__or2_4
X_9346_ clknet_leaf_13_clk net825 _0256_ VGND VGND VPWR VPWR adder_inst.is_nan_r sky130_fd_sc_hd__dfrtp_2
XFILLER_118_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5921__B1 net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout305_X net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6558_ _2113_ net611 _2107_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__a21oi_2
XFILLER_105_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9277_ clknet_leaf_22_clk adder_inst.sum_raw\[14\] _0187_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[14\]
+ sky130_fd_sc_hd__dfrtp_4
X_5509_ _0750_ _0752_ _1128_ _1138_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__o211ai_2
X_6489_ _2118_ _2043_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__nor2_4
X_8228_ net134 _3751_ _3800_ VGND VGND VPWR VPWR _3801_ sky130_fd_sc_hd__a21o_1
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8159_ net252 net394 net158 VGND VGND VPWR VPWR _3733_ sky130_fd_sc_hd__mux2_1
XFILLER_86_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7977__B2 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7977__A1 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4854__A net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4660__B1 net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8061__A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6963__B net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5860_ net231 net455 net461 net225 VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__a22oi_1
X_4811_ _4443_ _4471_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__xor2_1
XFILLER_61_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5595__A net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_38_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5791_ _1417_ _1419_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__or3_1
XANTENNA__8145__A1 net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4742_ net201 net384 _4500_ _4498_ VGND VGND VPWR VPWR _4513_ sky130_fd_sc_hd__a31o_1
X_7530_ _2574_ _2799_ VGND VGND VPWR VPWR _3160_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4673_ _4400_ _4403_ _4402_ VGND VGND VPWR VPWR _4444_ sky130_fd_sc_hd__o21ba_1
X_7461_ _3089_ _3090_ VGND VGND VPWR VPWR _3091_ sky130_fd_sc_hd__nor2_1
X_9200_ clknet_leaf_0_clk net23 _0110_ VGND VGND VPWR VPWR adder_inst.i_a\[2\] sky130_fd_sc_hd__dfrtp_1
X_6412_ _1965_ _1964_ _1957_ _1960_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__a211oi_4
X_7392_ _2794_ _2797_ _2793_ VGND VGND VPWR VPWR _3022_ sky130_fd_sc_hd__a21o_1
XANTENNA__4939__A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9131_ net526 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__inv_2
X_6343_ _1890_ _1972_ _1891_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__a21oi_1
X_9062_ net544 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__inv_2
XFILLER_103_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6459__A1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6459__B2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6274_ _1900_ _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__xnor2_1
XFILLER_130_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8013_ adder_inst.sum_raw_r\[15\] net496 _3404_ adder_inst.sum_raw_r\[14\] _3473_
+ VGND VGND VPWR VPWR _3600_ sky130_fd_sc_hd__a221o_1
XFILLER_102_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4658__B net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5225_ _0812_ net147 _0764_ _0776_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o211a_4
XPHY_EDGE_ROW_47_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7959__A1 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5156_ _0782_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nand2b_1
XFILLER_29_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5087_ _0700_ _0702_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__or3_4
XFILLER_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4674__A net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout467_A net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8915_ net535 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
XFILLER_112_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8846_ _3159_ _3268_ VGND VGND VPWR VPWR multiplier_inst.man_final\[22\] sky130_fd_sc_hd__or2_1
XANTENNA_fanout255_X net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_56_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8777_ _2556_ _2560_ _2562_ _2563_ VGND VGND VPWR VPWR _4284_ sky130_fd_sc_hd__nor4_1
X_5989_ _1611_ _1612_ _1617_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__o21ai_1
X_7728_ _3348_ _3350_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[7\] sky130_fd_sc_hd__or2_1
XANTENNA_fanout422_X net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7659_ _4357_ net572 _3285_ _3284_ VGND VGND VPWR VPWR _3287_ sky130_fd_sc_hd__a31o_1
XFILLER_4_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9329_ clknet_leaf_0_clk net704 _0239_ VGND VGND VPWR VPWR adder_inst.man_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_134_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8056__A net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input28_A i_a[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5010_ _0636_ _0637_ _0638_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand3_1
XFILLER_100_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6974__A net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6693__B net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8700_ _4064_ _4109_ net107 _4065_ VGND VGND VPWR VPWR _4252_ sky130_fd_sc_hd__a211oi_1
XANTENNA__4644__D net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4624__B1 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6961_ _2586_ _2589_ VGND VGND VPWR VPWR _2591_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_66_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6892_ net335 net466 net473 net328 VGND VGND VPWR VPWR _2522_ sky130_fd_sc_hd__a22oi_1
X_5912_ _1532_ _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__xor2_1
X_8631_ _4103_ net106 net174 VGND VGND VPWR VPWR _4192_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_66_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5843_ _1470_ _1471_ _1387_ net571 VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__a211oi_4
X_8562_ net187 _4126_ _4127_ _4131_ VGND VGND VPWR VPWR _4132_ sky130_fd_sc_hd__a31o_1
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7513_ _3136_ _3138_ VGND VGND VPWR VPWR _3143_ sky130_fd_sc_hd__xnor2_1
X_5774_ _1396_ _1397_ _1402_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__a21o_1
X_8493_ _4065_ VGND VGND VPWR VPWR _4066_ sky130_fd_sc_hd__inv_2
X_4725_ _4455_ _4458_ _4494_ VGND VGND VPWR VPWR _4496_ sky130_fd_sc_hd__o21a_1
XFILLER_107_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4656_ net222 net382 _4425_ VGND VGND VPWR VPWR _4427_ sky130_fd_sc_hd__a21oi_1
X_7444_ _3073_ VGND VGND VPWR VPWR _3074_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout215_A net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4587_ _4355_ _4356_ VGND VGND VPWR VPWR _4358_ sky130_fd_sc_hd__nand2_4
X_7375_ _2888_ _2952_ _2983_ _3004_ VGND VGND VPWR VPWR _3005_ sky130_fd_sc_hd__nand4_4
XFILLER_116_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9114_ net532 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__inv_2
X_6326_ _1791_ _1955_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__xor2_1
XFILLER_107_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9045_ net524 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__inv_2
X_6257_ _1883_ _1885_ _1886_ _1804_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__o211a_1
XFILLER_131_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5208_ net233 net422 net428 net227 VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a22oi_1
XFILLER_57_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6188_ _1722_ _1816_ _1817_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__nand3_1
X_5139_ _0765_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_4_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6108__B net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8829_ _3242_ net102 _4322_ _3241_ net104 VGND VGND VPWR VPWR multiplier_inst.man_final\[13\]
+ sky130_fd_sc_hd__a221oi_1
XFILLER_53_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5947__B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5040__B1 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6055__A1_N net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_19_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7399__A2 _2256_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4606__B1 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_106_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_91_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5490_ _0710_ _0715_ _0709_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a21oi_1
XFILLER_129_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold139 add_vld VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
X_7160_ _1497_ _1616_ _1614_ VGND VGND VPWR VPWR _2790_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6111_ _1737_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__and2b_1
XFILLER_113_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7091_ _2717_ _2718_ _2719_ VGND VGND VPWR VPWR _2721_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6042_ _1650_ _1652_ _1670_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__nand3_2
XFILLER_39_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7993_ adder_inst.sum_raw_r\[12\] net495 _3581_ _3582_ _3473_ VGND VGND VPWR VPWR
+ _3583_ sky130_fd_sc_hd__a221o_1
XFILLER_81_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout165_A _3665_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6944_ _2568_ _2573_ _2256_ VGND VGND VPWR VPWR _2574_ sky130_fd_sc_hd__a21bo_2
XFILLER_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8614_ _3948_ _4163_ _4176_ VGND VGND VPWR VPWR _4177_ sky130_fd_sc_hd__o21ai_1
X_6875_ _2491_ _2497_ _2503_ VGND VGND VPWR VPWR _2505_ sky130_fd_sc_hd__nand3_1
X_5826_ _1391_ _1393_ _1392_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__a21bo_1
XFILLER_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout332_A net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8545_ net173 _4116_ VGND VGND VPWR VPWR _4117_ sky130_fd_sc_hd__or2_1
X_5757_ _1337_ _1350_ _1385_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__o211a_4
XFILLER_136_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8476_ _4047_ _4046_ VGND VGND VPWR VPWR _4049_ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout218_X net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4708_ _4454_ _4470_ _4453_ VGND VGND VPWR VPWR _4479_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_79_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7427_ _3051_ _3056_ VGND VGND VPWR VPWR _3057_ sky130_fd_sc_hd__nand2b_1
X_5688_ _1172_ _1173_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__xnor2_1
X_4639_ net350 net263 net268 net342 VGND VGND VPWR VPWR _4410_ sky130_fd_sc_hd__a22o_1
XFILLER_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7358_ _2985_ _2986_ VGND VGND VPWR VPWR _2988_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_9_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7289_ _2917_ _2918_ VGND VGND VPWR VPWR _2919_ sky130_fd_sc_hd__and2_1
X_6309_ _1931_ _1934_ _1937_ _1938_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__o211ai_4
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9028_ net516 VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__inv_2
XFILLER_77_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8027__A0 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5023__A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8334__A adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5958__A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5013__B1 net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6789__A net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5693__A net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8569__A1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4990_ _0616_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__xnor2_1
XFILLER_17_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5587__B net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7544__A2 _3170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6660_ _2289_ _2284_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__nand2b_1
X_6591_ _2218_ _2220_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__nor2_1
XANTENNA__6699__A net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5611_ _1239_ _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__nor2_1
XFILLER_129_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8330_ _3898_ _3899_ net120 VGND VGND VPWR VPWR _3903_ sky130_fd_sc_hd__o21a_1
X_5542_ _1169_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__nor2_1
XFILLER_117_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5473_ _1102_ _1101_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__and2b_1
X_8261_ net137 _3721_ VGND VGND VPWR VPWR _3834_ sky130_fd_sc_hd__nor2_1
X_8192_ _3764_ _3765_ net136 VGND VGND VPWR VPWR _3766_ sky130_fd_sc_hd__mux2_1
X_7212_ _0932_ _2839_ _2838_ VGND VGND VPWR VPWR _2842_ sky130_fd_sc_hd__a21o_1
Xfanout405 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkbuf_4
XANTENNA__8419__A net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7143_ _2737_ _2772_ VGND VGND VPWR VPWR _2773_ sky130_fd_sc_hd__xor2_2
Xfanout416 net417 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_4
Xfanout438 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__buf_4
Xfanout427 net429 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__clkbuf_2
XANTENNA__6865__C net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7074_ _2701_ _2702_ _2703_ VGND VGND VPWR VPWR _2704_ sky130_fd_sc_hd__nand3b_1
Xfanout449 adder_inst.man_a_r\[5\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_4
XANTENNA__8853__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6025_ _1317_ _1316_ _1318_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__a21o_1
XFILLER_15_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout547_A net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout168_X net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7976_ adder_inst.sum_raw_r\[8\] net170 VGND VGND VPWR VPWR _3568_ sky130_fd_sc_hd__or2_1
XFILLER_82_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5928__D net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6927_ _2411_ _2550_ VGND VGND VPWR VPWR _2557_ sky130_fd_sc_hd__nand2_1
XFILLER_23_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6858_ _2487_ VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__inv_2
XFILLER_50_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5809_ _1436_ _1437_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__nand3b_1
XFILLER_23_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5546__B2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5546__A1 net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8528_ _3933_ _3946_ _3945_ VGND VGND VPWR VPWR _4101_ sky130_fd_sc_hd__a21oi_1
X_6789_ net448 net328 net453 net334 VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__and4_1
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8496__A0 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8459_ _4027_ _4029_ VGND VGND VPWR VPWR _4032_ sky130_fd_sc_hd__nand2_2
XFILLER_136_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input10_A i_a[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4592__A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6015__C net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload26 clknet_leaf_20_clk VGND VGND VPWR VPWR clkload26/Y sky130_fd_sc_hd__inv_6
Xclkload15 clknet_leaf_26_clk VGND VGND VPWR VPWR clkload15/Y sky130_fd_sc_hd__clkinv_8
XFILLER_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6031__B net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5573__D net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7830_ adder_inst.exp_larger_r\[7\] net185 VGND VGND VPWR VPWR _3436_ sky130_fd_sc_hd__nor2_1
XFILLER_64_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7761_ _3363_ _3373_ _3374_ VGND VGND VPWR VPWR adder_inst.is_inf_b sky130_fd_sc_hd__and3_1
X_4973_ net342 net292 _0459_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__and3_1
XFILLER_64_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9500_ clknet_leaf_16_clk net808 _0410_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
X_7692_ net572 _3317_ _3316_ VGND VGND VPWR VPWR _3318_ sky130_fd_sc_hd__a21oi_1
XANTENNA__4652__D net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6712_ net293 net299 net464 net470 VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__and4_1
X_9431_ clknet_leaf_27_clk multiplier_inst.man_final\[19\] _0341_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6643_ net442 net319 net447 net311 VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__a22oi_1
XFILLER_32_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload9 clknet_leaf_7_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_30_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9362_ clknet_leaf_28_clk _0066_ _0272_ VGND VGND VPWR VPWR add_res\[8\] sky130_fd_sc_hd__dfrtp_1
X_6574_ net311 net442 net318 net436 VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__a22o_1
XFILLER_106_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8313_ net127 _3767_ VGND VGND VPWR VPWR _3886_ sky130_fd_sc_hd__and2_1
X_5525_ _1034_ _1081_ _1033_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_76_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9293_ clknet_leaf_31_clk net713 _0203_ VGND VGND VPWR VPWR adder_inst.man_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__8848__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5456_ _1075_ _1067_ _1074_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__o21a_1
X_8244_ _3814_ _3815_ net143 VGND VGND VPWR VPWR _3817_ sky130_fd_sc_hd__a21o_1
XFILLER_132_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout202 net204 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__buf_4
X_5387_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__inv_2
XFILLER_99_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8175_ net281 net423 net155 VGND VGND VPWR VPWR _3749_ sky130_fd_sc_hd__mux2_1
XFILLER_87_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout213 net218 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_2
Xfanout224 adder_inst.man_b_r\[20\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_4
Xfanout235 net236 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_4
Xfanout246 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_4
XFILLER_113_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7126_ _2752_ _2755_ VGND VGND VPWR VPWR _2756_ sky130_fd_sc_hd__xnor2_1
Xfanout268 net269 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
Xfanout257 net258 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_2
XANTENNA_input2_A i_a[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7453__B2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7453__A1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7057_ net359 net305 VGND VGND VPWR VPWR _2687_ sky130_fd_sc_hd__nand2_1
Xfanout279 net282 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout285_X net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6008_ _1631_ _1636_ _1630_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a21bo_1
XFILLER_131_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4843__C net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7959_ adder_inst.sum_raw_r\[11\] net171 net184 _3552_ _3553_ VGND VGND VPWR VPWR
+ _3554_ sky130_fd_sc_hd__a221o_1
XFILLER_82_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5020__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8181__A2 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6192__B2 net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6192__A1 net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4742__A2 net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input58_A i_b[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer90_X net639 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4981__A2 net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5310_ _0839_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_58_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6290_ _1914_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__xor2_2
XFILLER_6_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5241_ _0866_ _0869_ _0774_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__o21ai_1
XFILLER_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5172_ _0498_ _0796_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_71_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6238__A2 net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8931_ net513 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__inv_2
Xinput2 i_a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8862_ net772 mul_res\[14\] net504 VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__mux2_1
XANTENNA__6217__A net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7813_ net488 _3412_ _3418_ VGND VGND VPWR VPWR _3419_ sky130_fd_sc_hd__or3_1
XFILLER_92_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8793_ _2566_ _4299_ _4298_ _4283_ _4282_ VGND VGND VPWR VPWR _4300_ sky130_fd_sc_hd__a2111o_1
XFILLER_24_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7744_ _3359_ _3362_ VGND VGND VPWR VPWR _3363_ sky130_fd_sc_hd__nor2_1
XFILLER_101_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout245_A net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4956_ net216 net428 net432 net205 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_82_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7675_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] _3299_ VGND VGND VPWR VPWR
+ _3301_ sky130_fd_sc_hd__a21oi_1
X_4887_ net250 net386 net392 net244 VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_82_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9414_ clknet_leaf_28_clk multiplier_inst.man_final\[2\] _0324_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout412_A net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6626_ _2253_ _1811_ _2255_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__o21a_4
X_9345_ clknet_leaf_7_clk adder_inst.man_b\[23\] _0255_ VGND VGND VPWR VPWR adder_inst.man_b_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__5921__A1 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6557_ _2180_ _2184_ _2185_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__nand3_1
XFILLER_20_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5508_ _1119_ _1127_ _1126_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout200_X net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5921__B2 net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9276_ clknet_leaf_22_clk adder_inst.sum_raw\[13\] _0186_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[13\]
+ sky130_fd_sc_hd__dfrtp_4
X_6488_ _2042_ _1966_ _2041_ _2038_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__o211a_1
X_5439_ _0426_ _0998_ _1003_ _1010_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__o31a_1
XFILLER_126_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8227_ _4358_ net151 net656 net148 _3749_ VGND VGND VPWR VPWR _3800_ sky130_fd_sc_hd__o41a_1
XFILLER_114_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8158_ _3671_ _3700_ VGND VGND VPWR VPWR _3732_ sky130_fd_sc_hd__or2_2
XFILLER_87_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5015__B net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_704 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7109_ _2646_ _2648_ VGND VGND VPWR VPWR _2739_ sky130_fd_sc_hd__nand2_1
X_8089_ net664 _3327_ _3662_ _3343_ _3326_ VGND VGND VPWR VPWR _3663_ sky130_fd_sc_hd__a311oi_4
XANTENNA__8607__A net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4854__B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4660__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4660__B2 net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5966__A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_rebuffer50_A net598 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4810_ _4544_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or2_1
XFILLER_92_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8252__A net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5790_ net354 net332 net338 net348 VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__a22oi_2
X_4741_ _4507_ _4510_ VGND VGND VPWR VPWR _4512_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5595__B net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4672_ _4441_ _4442_ _4422_ VGND VGND VPWR VPWR _4443_ sky130_fd_sc_hd__o21ai_2
X_7460_ _3045_ _3048_ _3088_ VGND VGND VPWR VPWR _3090_ sky130_fd_sc_hd__nor3_1
XANTENNA__6156__A1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6411_ _2032_ _2038_ _2039_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__nand3_1
X_9130_ net546 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__inv_2
X_7391_ _3020_ VGND VGND VPWR VPWR _3021_ sky130_fd_sc_hd__inv_2
XANTENNA__4939__B net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6342_ _1969_ _1971_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__and2b_1
X_9061_ net546 VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__inv_2
XANTENNA__6459__A2 net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6273_ _1901_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__nor2_1
X_8012_ net116 _3599_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and2_1
XFILLER_102_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4658__C net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5224_ _0812_ _0853_ _0852_ _0851_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__nor4_4
XPHY_EDGE_ROW_102_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7959__A2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4955__A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5155_ _0782_ _0783_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__or3_1
XFILLER_57_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5086_ _0710_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__xnor2_1
XFILLER_110_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4674__B net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8914_ net519 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__inv_2
XFILLER_112_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout362_A net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7050__B _2678_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4642__A1 net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8845_ _3268_ _4330_ VGND VGND VPWR VPWR multiplier_inst.man_final\[21\] sky130_fd_sc_hd__nor2_1
XFILLER_65_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_111_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout248_X net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8776_ _2313_ _2567_ VGND VGND VPWR VPWR _4283_ sky130_fd_sc_hd__xor2_1
XFILLER_12_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5988_ _1611_ _1612_ _1617_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__or3_1
X_7727_ net103 _3339_ _3349_ VGND VGND VPWR VPWR _3350_ sky130_fd_sc_hd__a21oi_1
X_4939_ net238 net413 VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand2_1
X_7658_ net168 _3284_ _3285_ VGND VGND VPWR VPWR _3286_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout415_X net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6609_ _2152_ _2228_ _2227_ _2212_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__o211ai_1
XFILLER_119_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7589_ _4370_ net131 net562 _3206_ VGND VGND VPWR VPWR _3219_ sky130_fd_sc_hd__a31o_1
XFILLER_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_720 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9328_ clknet_leaf_0_clk net702 _0238_ VGND VGND VPWR VPWR adder_inst.man_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_9259_ clknet_leaf_8_clk net54 _0169_ VGND VGND VPWR VPWR adder_inst.exp_b\[6\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_120_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4865__A net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7583__A0 _3209_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4599__X _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone112_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_704 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6960_ _2586_ _2589_ VGND VGND VPWR VPWR _2590_ sky130_fd_sc_hd__and2_1
XANTENNA__4624__B2 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4624__A1 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5911_ _1539_ _1540_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_66_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6891_ net324 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR _2521_ sky130_fd_sc_hd__nand2_1
X_8630_ net106 _4186_ VGND VGND VPWR VPWR _4191_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_66_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5842_ _1387_ _1409_ _1470_ _1471_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__o211a_4
X_8561_ net671 _4128_ _3853_ _4130_ net173 VGND VGND VPWR VPWR _4131_ sky130_fd_sc_hd__o221a_1
XFILLER_61_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5773_ _1396_ _1397_ _1402_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__nand3_2
X_4724_ _4455_ _4458_ _4494_ VGND VGND VPWR VPWR _4495_ sky130_fd_sc_hd__nor3_1
X_7512_ _3132_ _3135_ _3139_ VGND VGND VPWR VPWR _3142_ sky130_fd_sc_hd__nor3_1
XFILLER_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8492_ _4061_ _4063_ VGND VGND VPWR VPWR _4065_ sky130_fd_sc_hd__and2_1
XFILLER_107_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4655_ net222 net382 _4425_ VGND VGND VPWR VPWR _4426_ sky130_fd_sc_hd__and3_1
X_7443_ _4538_ _4540_ _3072_ VGND VGND VPWR VPWR _3073_ sky130_fd_sc_hd__a21o_1
X_4586_ _4355_ _4356_ VGND VGND VPWR VPWR _4357_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout208_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput60 i_b[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
X_7374_ _3003_ VGND VGND VPWR VPWR _3004_ sky130_fd_sc_hd__inv_2
XFILLER_107_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9113_ net529 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__inv_2
XANTENNA__8856__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6325_ _1789_ _1872_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__nor2_1
XFILLER_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9044_ net526 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__inv_2
XFILLER_107_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6256_ _1800_ _1802_ _1801_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__o21ai_1
XFILLER_130_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5207_ net227 net233 net422 net428 VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__and4_1
XFILLER_69_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6187_ net622 _1721_ _1720_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__o21ai_1
X_5138_ _0749_ _0754_ _0761_ net569 VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_4_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5069_ _0627_ _0635_ _0634_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__a21bo_1
XFILLER_84_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout365_X net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5012__C net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8828_ _3270_ _4321_ _4322_ VGND VGND VPWR VPWR multiplier_inst.man_final\[12\] sky130_fd_sc_hd__and3_1
XFILLER_52_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5947__C net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_43_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8759_ net766 _4272_ _0104_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_23_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5040__B2 net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5040__A1 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6037__A2_N net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input40_A i_b[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4606__B2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4606__A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_139_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4909__A2 net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6110_ _1737_ _1738_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__or3_1
XFILLER_98_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7090_ _2717_ _2718_ _2719_ VGND VGND VPWR VPWR _2720_ sky130_fd_sc_hd__nand3_1
XFILLER_112_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6041_ _1650_ _1652_ _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__a21o_2
XANTENNA__8036__A1 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7992_ adder_inst.sum_raw_r\[9\] net182 net170 adder_inst.sum_raw_r\[10\] VGND VGND
+ VPWR VPWR _3582_ sky130_fd_sc_hd__o22a_1
XFILLER_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6943_ _2572_ _1811_ VGND VGND VPWR VPWR _2573_ sky130_fd_sc_hd__nor2_8
XFILLER_62_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6874_ _2497_ _2503_ _2491_ VGND VGND VPWR VPWR _2504_ sky130_fd_sc_hd__a21oi_1
XANTENNA__6870__D net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout158_A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8613_ _3935_ _3946_ _3945_ VGND VGND VPWR VPWR _4176_ sky130_fd_sc_hd__a21o_1
X_5825_ _1452_ _1453_ _1451_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8544_ _3777_ _3778_ _3780_ VGND VGND VPWR VPWR _4116_ sky130_fd_sc_hd__or3_4
XANTENNA_fanout325_A adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5756_ _1372_ _1373_ _1384_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__a21o_1
X_8475_ _4046_ _4047_ VGND VGND VPWR VPWR _4048_ sky130_fd_sc_hd__nand2b_1
X_4707_ _4475_ _4476_ VGND VGND VPWR VPWR _4478_ sky130_fd_sc_hd__xor2_1
X_5687_ _1314_ _1315_ _1300_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__a21o_1
X_4638_ net356 net257 VGND VGND VPWR VPWR _4409_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_79_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout113_X net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7426_ _3054_ _3055_ VGND VGND VPWR VPWR _3056_ sky130_fd_sc_hd__xnor2_1
XANTENNA__7056__A net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4569_ net499 VGND VGND VPWR VPWR _4341_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7357_ _2985_ _2986_ VGND VGND VPWR VPWR _2987_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_9_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7288_ net220 net449 _2754_ _2753_ VGND VGND VPWR VPWR _2918_ sky130_fd_sc_hd__a31o_1
X_6308_ _1855_ _1936_ _1935_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__a21o_1
X_9027_ net516 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout482_X net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6239_ _1866_ _1868_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__and2b_1
XFILLER_76_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7222__C net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5023__B net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8334__B _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5958__B net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6761__A1 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5693__B net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_rebuffer16_X net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6513__B2 net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6513__A1 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9181__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5587__C net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6590_ net301 net452 net458 net293 VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__a22oi_1
XANTENNA__6699__B net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5610_ net231 net462 net468 net225 VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5541_ _1169_ _1170_ net420 net290 VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__and4bb_1
XFILLER_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8260_ net137 _3714_ _3832_ VGND VGND VPWR VPWR _3833_ sky130_fd_sc_hd__o21bai_1
XFILLER_8_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5472_ _1053_ _1055_ _1052_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__o21ba_1
X_7211_ _2741_ _2743_ VGND VGND VPWR VPWR _2841_ sky130_fd_sc_hd__nand2_1
X_8191_ net222 net361 net158 VGND VGND VPWR VPWR _3765_ sky130_fd_sc_hd__mux2_1
XFILLER_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7142_ _2738_ _2771_ VGND VGND VPWR VPWR _2772_ sky130_fd_sc_hd__xor2_2
Xfanout417 adder_inst.man_a_r\[11\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__buf_6
XFILLER_99_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout428 net429 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_4
XFILLER_98_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout406 net409 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__buf_4
Xfanout439 net441 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__buf_4
X_7073_ net373 net295 net299 net367 VGND VGND VPWR VPWR _2703_ sky130_fd_sc_hd__a22o_1
XFILLER_100_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6024_ _1640_ _1642_ _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__and3_4
XANTENNA__8009__B2 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7975_ net115 _3567_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__and2_1
XFILLER_82_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6926_ _2550_ _2555_ VGND VGND VPWR VPWR _2556_ sky130_fd_sc_hd__nor2_1
XFILLER_14_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout442_A net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_18_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6857_ _2477_ _2486_ VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__nor2_2
XANTENNA_fanout230_X net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5546__A2 net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6788_ _2376_ _2378_ _2377_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__o21ai_1
X_5808_ net630 net297 net303 net383 VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__a22o_1
XFILLER_109_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8527_ _3910_ _3924_ _3927_ _4099_ _3909_ VGND VGND VPWR VPWR _4100_ sky130_fd_sc_hd__o221a_4
X_5739_ _1365_ _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__xnor2_1
XFILLER_135_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8458_ _4030_ VGND VGND VPWR VPWR _4031_ sky130_fd_sc_hd__inv_2
X_8389_ net159 _3960_ _3961_ VGND VGND VPWR VPWR _3962_ sky130_fd_sc_hd__o21ai_1
X_7409_ _3038_ _4534_ VGND VGND VPWR VPWR _3039_ sky130_fd_sc_hd__and2b_1
XFILLER_89_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4873__A net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5969__A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8420__A1 net275 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4592__B net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8064__B _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6015__D net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload16 clknet_leaf_27_clk VGND VGND VPWR VPWR clkload16/Y sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_11_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload27 clknet_leaf_22_clk VGND VGND VPWR VPWR clkload27/Y sky130_fd_sc_hd__clkinv_4
XFILLER_62_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8239__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4783__A net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7760_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _3374_ sky130_fd_sc_hd__and4_1
X_4972_ net342 net292 VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
XFILLER_63_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7691_ _3286_ _3312_ _3314_ VGND VGND VPWR VPWR _3317_ sky130_fd_sc_hd__and3_1
XANTENNA__8175__A0 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6711_ _2338_ _2339_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__xnor2_1
XFILLER_32_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9430_ clknet_leaf_27_clk multiplier_inst.man_final\[18\] _0340_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6642_ net311 net442 net319 net447 VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__and4_1
X_9361_ clknet_leaf_28_clk _0065_ _0271_ VGND VGND VPWR VPWR add_res\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8312_ net145 _3774_ _3884_ net123 VGND VGND VPWR VPWR _3885_ sky130_fd_sc_hd__a211o_1
X_6573_ net436 net311 net442 net318 VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_30_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5524_ _1083_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_76_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9292_ clknet_leaf_31_clk net718 _0202_ VGND VGND VPWR VPWR adder_inst.man_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_133_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5455_ _1079_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__and2_1
X_8243_ net127 _3814_ _3815_ VGND VGND VPWR VPWR _3816_ sky130_fd_sc_hd__and3_1
XANTENNA__4958__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8174_ net168 _3680_ net150 _3699_ _3747_ VGND VGND VPWR VPWR _3748_ sky130_fd_sc_hd__a41o_1
X_5386_ net350 net257 net264 net343 VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a22o_1
XFILLER_99_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout203 net204 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7125_ _2753_ _2754_ VGND VGND VPWR VPWR _2755_ sky130_fd_sc_hd__and2b_1
Xfanout214 net215 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__buf_2
Xfanout236 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_4
XANTENNA__8864__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7989__B1 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout392_A net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout225 net230 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
XANTENNA__9322__Q adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout247 net248 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_4
Xfanout269 net270 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_6
Xfanout258 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_2
XANTENNA__7453__A2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7056_ net341 net324 _1418_ VGND VGND VPWR VPWR _2686_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout180_X net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6007_ _1630_ _1631_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__nand3_1
XFILLER_28_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5789__A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout278_X net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4843__D net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7958_ net194 _4339_ VGND VGND VPWR VPWR _3553_ sky130_fd_sc_hd__nor2_1
XFILLER_70_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout445_X net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7889_ _3439_ _3443_ _3461_ _3494_ VGND VGND VPWR VPWR _3495_ sky130_fd_sc_hd__or4_1
XANTENNA__5020__C net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6909_ _2521_ _2523_ VGND VGND VPWR VPWR _2539_ sky130_fd_sc_hd__and2_1
XFILLER_23_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold290 multiplier_inst.man_final_r\[14\] VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_129_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5699__A net555 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__9407__Q adder_inst.is_zero_b_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6529__A1_N net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5240_ _0774_ _0866_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_58_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5694__A1 net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5171_ _0798_ _0799_ _0797_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5694__B2 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8930_ net511 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
XANTENNA__6643__B1 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput3 i_a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_83_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8861_ net768 mul_res\[13\] net504 VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__mux2_1
XFILLER_83_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6217__B net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7812_ net195 _3416_ net490 VGND VGND VPWR VPWR _3418_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_69_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8792_ _2369_ _2565_ VGND VGND VPWR VPWR _4299_ sky130_fd_sc_hd__or2_1
XFILLER_24_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7743_ _3356_ _3357_ _3360_ _3361_ VGND VGND VPWR VPWR _3362_ sky130_fd_sc_hd__or4_2
X_4955_ net205 net216 net428 net432 VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7674_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] _3299_ VGND VGND VPWR VPWR
+ _3300_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout140_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4886_ net244 net250 net386 net392 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_82_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout238_A adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9413_ clknet_leaf_30_clk multiplier_inst.man_final\[1\] _0323_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_6625_ _1716_ _2254_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__nor2_1
X_9344_ clknet_leaf_4_clk net707 _0254_ VGND VGND VPWR VPWR adder_inst.man_b_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__5921__A2 net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6556_ _2184_ _2185_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__and2_4
XFILLER_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5507_ _1129_ _1130_ _1121_ _1125_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__o211a_1
X_9275_ clknet_leaf_22_clk adder_inst.sum_raw\[12\] _0185_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[12\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_106_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8226_ net137 _3798_ net145 _3795_ VGND VGND VPWR VPWR _3799_ sky130_fd_sc_hd__a211o_1
X_6487_ _2115_ _2112_ _2116_ _2040_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__a211oi_4
XFILLER_126_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5438_ _1043_ _1060_ _1042_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5369_ _0426_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nor2_1
XFILLER_114_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8157_ _3671_ _3700_ VGND VGND VPWR VPWR _3731_ sky130_fd_sc_hd__nor2_1
XFILLER_102_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout395_X net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8088_ _3296_ _3303_ _3297_ VGND VGND VPWR VPWR _3662_ sky130_fd_sc_hd__a21oi_2
XFILLER_114_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7108_ _2655_ _2672_ VGND VGND VPWR VPWR _2738_ sky130_fd_sc_hd__nor2_2
XFILLER_101_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7039_ _2667_ _2668_ VGND VGND VPWR VPWR _2669_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_749 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7230__C net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4660__A2 net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8139__A0 net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5966__B net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7114__A1 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_111_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_109_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4740_ _4479_ _4506_ _4510_ VGND VGND VPWR VPWR _4511_ sky130_fd_sc_hd__or3_1
XFILLER_119_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4671_ _4408_ _4421_ VGND VGND VPWR VPWR _4442_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6988__A net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6156__A2 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7390_ _3013_ _3019_ _3014_ VGND VGND VPWR VPWR _3020_ sky130_fd_sc_hd__nor3b_1
X_6410_ _2032_ _2038_ _2039_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_40_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6341_ _1887_ _1970_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__nor2_2
X_9060_ net546 VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__inv_2
XFILLER_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6272_ net418 net314 net320 net413 VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__a22oi_1
XFILLER_115_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8011_ net185 _3596_ _3597_ _3598_ VGND VGND VPWR VPWR _3599_ sky130_fd_sc_hd__a31o_1
XANTENNA__4658__D net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5223_ _0759_ _0777_ _0791_ _0811_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__o211a_1
XANTENNA__6864__B1 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5154_ net359 net609 net301 net353 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a22oi_1
XFILLER_111_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4955__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5085_ _0713_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout188_A _3355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8913_ net521 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__inv_2
XFILLER_84_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4642__A2 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_84_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8844_ _3262_ _3266_ _3265_ VGND VGND VPWR VPWR _4330_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout355_A net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5987_ _1497_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__xnor2_1
X_8775_ _2568_ _2570_ VGND VGND VPWR VPWR _4282_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout522_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7726_ _3337_ _3347_ VGND VGND VPWR VPWR _3349_ sky130_fd_sc_hd__xnor2_1
X_4938_ net245 net251 net400 net409 VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__and4_1
XFILLER_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7657_ _4354_ _3282_ VGND VGND VPWR VPWR _3285_ sky130_fd_sc_hd__nor2_1
X_4869_ _0496_ _0497_ _0495_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__o21bai_1
XFILLER_20_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout310_X net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6608_ _2233_ _2237_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__xor2_1
XFILLER_20_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7588_ _3212_ _3217_ net112 VGND VGND VPWR VPWR _3218_ sky130_fd_sc_hd__mux2_2
XANTENNA_fanout408_X net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9327_ clknet_leaf_0_clk net735 _0237_ VGND VGND VPWR VPWR adder_inst.man_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_6539_ _2148_ _2150_ _2168_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__a21oi_1
XFILLER_4_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9258_ clknet_leaf_9_clk net53 _0168_ VGND VGND VPWR VPWR adder_inst.exp_b\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9189_ net543 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__inv_2
XFILLER_106_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8209_ _3779_ _3781_ VGND VGND VPWR VPWR _3783_ sky130_fd_sc_hd__or2_1
XFILLER_0_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7522__A _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4865__B net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4881__A net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7583__A1 _3212_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6974__C net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4624__A2 net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5910_ _1537_ _1538_ _1533_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__a21o_1
XANTENNA__5887__A net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6890_ net328 net335 net466 net473 VGND VGND VPWR VPWR _2520_ sky130_fd_sc_hd__and4_1
XFILLER_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5841_ _1447_ _1448_ _1468_ _1469_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__a22o_1
XFILLER_22_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8560_ net105 _4129_ VGND VGND VPWR VPWR _4130_ sky130_fd_sc_hd__nand2_4
X_5772_ _1398_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__xnor2_1
X_8491_ _4061_ _4063_ VGND VGND VPWR VPWR _4064_ sky130_fd_sc_hd__or2_2
X_4723_ _4492_ _4493_ VGND VGND VPWR VPWR _4494_ sky130_fd_sc_hd__xnor2_1
X_7511_ _3140_ VGND VGND VPWR VPWR _3141_ sky130_fd_sc_hd__inv_2
X_7442_ _3037_ _3070_ VGND VGND VPWR VPWR _3072_ sky130_fd_sc_hd__xor2_1
X_4654_ _4423_ _4424_ VGND VGND VPWR VPWR _4425_ sky130_fd_sc_hd__nor2_1
XANTENNA__6511__A net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5888__A1 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput50 i_b[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
X_4585_ adder_inst.exp_a_r\[0\] _4332_ VGND VGND VPWR VPWR _4356_ sky130_fd_sc_hd__nand2_1
Xinput61 i_b[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_7373_ _2984_ _3001_ VGND VGND VPWR VPWR _3003_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5888__B2 net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout103_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9112_ net529 VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__inv_2
X_6324_ _1951_ _1953_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__nand2_1
XFILLER_107_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9043_ net524 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__inv_2
X_6255_ _1876_ _1878_ _1883_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__a211oi_4
XFILLER_103_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5206_ _0581_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nor2_1
X_6186_ _1813_ _1814_ net638 VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__o21bai_1
XANTENNA__8872__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8725__X adder_inst.exp_larger\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5137_ _0597_ _0598_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__xor2_1
XANTENNA__9330__Q adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5068_ _0695_ _0696_ _0689_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21o_1
XFILLER_57_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5012__D net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout358_X net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout260_X net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8827_ _3213_ _3218_ _3238_ _4317_ VGND VGND VPWR VPWR _4322_ sky130_fd_sc_hd__or4_1
XFILLER_53_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8758_ net763 _4272_ _0104_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a21o_1
XANTENNA__8762__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7709_ _3331_ _3332_ VGND VGND VPWR VPWR _3333_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5040__A2 net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8689_ _4242_ _4033_ VGND VGND VPWR VPWR adder_inst.sum_raw\[19\] sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_97_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input33_A i_b[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4606__A2 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6040_ _1201_ _1206_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__xnor2_1
XFILLER_112_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7991_ _4338_ net500 net495 VGND VGND VPWR VPWR _3581_ sky130_fd_sc_hd__a21oi_1
XFILLER_66_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6942_ _2122_ _1976_ _2257_ _2570_ VGND VGND VPWR VPWR _2572_ sky130_fd_sc_hd__or4_4
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6873_ _2501_ _2502_ VGND VGND VPWR VPWR _2503_ sky130_fd_sc_hd__nand2b_1
X_8612_ _3947_ _4169_ _4174_ VGND VGND VPWR VPWR _4175_ sky130_fd_sc_hd__a21boi_1
X_5824_ _1451_ _1452_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__or3_1
XANTENNA__5558__B1 net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8543_ adder_inst.sign_b_r adder_inst.sign_a_r net108 VGND VGND VPWR VPWR adder_inst.sign_sum
+ sky130_fd_sc_hd__mux2_4
X_5755_ _1372_ _1373_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__nand3_2
XANTENNA__4781__A1 net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8474_ adder_inst.man_b_r\[17\] net160 _3981_ _4019_ VGND VGND VPWR VPWR _4047_ sky130_fd_sc_hd__a22o_1
X_4706_ _4476_ _4475_ VGND VGND VPWR VPWR _4477_ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout220_A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout318_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5686_ _1300_ _1314_ _1315_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__nand3_4
XANTENNA__8867__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4637_ _4397_ _4406_ VGND VGND VPWR VPWR _4408_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_79_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7425_ net203 net371 VGND VGND VPWR VPWR _3055_ sky130_fd_sc_hd__nand2_1
XANTENNA__7056__B net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4568_ net497 VGND VGND VPWR VPWR _4340_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7356_ _2957_ _2963_ VGND VGND VPWR VPWR _2986_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_9_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7287_ _2852_ _2916_ VGND VGND VPWR VPWR _2917_ sky130_fd_sc_hd__nor2_1
XANTENNA__7072__A net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6307_ _1855_ _1935_ _1936_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__nand3_2
XFILLER_131_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9026_ net514 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__inv_2
XFILLER_103_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6238_ net266 net462 net468 net259 VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__a22o_1
X_6169_ _1677_ _1679_ _1701_ _1702_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__o22a_1
XFILLER_85_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7222__D net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout475_X net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5013__A2 net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6789__C net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6761__A2 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_20_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA__6151__A net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone64 net104 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__clkbuf_1
XFILLER_126_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7710__A1 _3152_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6513__A2 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5587__D net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5960__B1 net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5540_ net414 net297 net302 net407 VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a22oi_1
XANTENNA__6699__C net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5471_ _1098_ _1099_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__xnor2_2
XFILLER_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7210_ _0932_ _2838_ _2839_ VGND VGND VPWR VPWR _2840_ sky130_fd_sc_hd__nand3_1
XANTENNA__6996__A net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8190_ net217 net356 net158 VGND VGND VPWR VPWR _3764_ sky130_fd_sc_hd__mux2_1
XFILLER_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7141_ _2769_ _2770_ VGND VGND VPWR VPWR _2771_ sky130_fd_sc_hd__nand2_1
XFILLER_99_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout429 adder_inst.man_a_r\[9\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_6
XFILLER_98_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout407 net409 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_2
X_7072_ net367 net373 net295 net300 VGND VGND VPWR VPWR _2702_ sky130_fd_sc_hd__nand4_1
Xfanout418 net423 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__buf_2
X_6023_ _1646_ _1651_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__xnor2_1
XFILLER_86_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7974_ net483 adder_inst.sum_raw_r\[14\] net171 adder_inst.sum_raw_r\[13\] _3566_
+ VGND VGND VPWR VPWR _3567_ sky130_fd_sc_hd__a221o_1
XFILLER_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6236__A net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout268_A net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6925_ _2366_ _2554_ VGND VGND VPWR VPWR _2555_ sky130_fd_sc_hd__nand2_2
XANTENNA__6440__A1 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6856_ _2475_ _2476_ _2468_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__a21oi_1
XFILLER_23_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6787_ _2381_ _2387_ _2386_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__a21o_1
X_5807_ net383 net630 net609 net303 VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand4_1
X_8526_ _3879_ _3892_ _4098_ _3896_ _3878_ VGND VGND VPWR VPWR _4099_ sky130_fd_sc_hd__o221a_4
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5738_ _1366_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__nor2_1
XFILLER_124_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8457_ _4027_ _4029_ VGND VGND VPWR VPWR _4030_ sky130_fd_sc_hd__or2_1
X_5669_ _1295_ _1296_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__nand3_1
X_8388_ adder_inst.man_b_r\[14\] net165 VGND VGND VPWR VPWR _3961_ sky130_fd_sc_hd__or2_1
X_7408_ _4524_ _4529_ _4523_ VGND VGND VPWR VPWR _3038_ sky130_fd_sc_hd__a21oi_1
XFILLER_116_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7339_ _2958_ _2962_ _2960_ VGND VGND VPWR VPWR _2969_ sky130_fd_sc_hd__o21ai_1
XANTENNA__6604__A2_N adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9009_ net507 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__inv_2
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4873__B net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5969__B net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload17 clknet_leaf_29_clk VGND VGND VPWR VPWR clkload17/Y sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_11_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload28 clknet_leaf_23_clk VGND VGND VPWR VPWR clkload28/Y sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_11_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4783__B net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_48_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8542__Y _4115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4971_ net355 net292 _0468_ _0467_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_19_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7690_ _3312_ _3315_ VGND VGND VPWR VPWR _3316_ sky130_fd_sc_hd__nor2_1
XANTENNA__8175__A1 net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6710_ _2338_ _2339_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__nand2b_1
XFILLER_20_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6641_ _2199_ _2265_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__nand3_1
XFILLER_32_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9360_ clknet_leaf_28_clk _0064_ _0270_ VGND VGND VPWR VPWR add_res\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_30_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8311_ net145 _3743_ _3744_ VGND VGND VPWR VPWR _3884_ sky130_fd_sc_hd__nor3_1
XFILLER_20_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6572_ _2126_ _2200_ _2201_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_30_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5523_ _1114_ _1133_ _1113_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_76_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9291_ clknet_leaf_31_clk net694 _0201_ VGND VGND VPWR VPWR adder_inst.man_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
X_5454_ _1070_ _1073_ _1078_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__nand3_1
XFILLER_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8242_ net135 _3738_ _3812_ net140 VGND VGND VPWR VPWR _3815_ sky130_fd_sc_hd__a211o_1
XANTENNA__4958__B net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5385_ _0986_ _0987_ _1013_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8173_ _3746_ VGND VGND VPWR VPWR _3747_ sky130_fd_sc_hd__inv_2
Xfanout204 adder_inst.man_b_r\[23\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_4
XFILLER_99_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7124_ net233 net437 net444 net227 VGND VGND VPWR VPWR _2754_ sky130_fd_sc_hd__a22o_1
XFILLER_87_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout226 net230 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_2
Xfanout215 net218 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_2
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_2
XANTENNA_fanout385_A adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout248 net249 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_4
X_7055_ _2600_ _2611_ _2599_ VGND VGND VPWR VPWR _2685_ sky130_fd_sc_hd__a21oi_1
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_2
XFILLER_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6006_ _1632_ _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__xnor2_1
XFILLER_28_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5789__B net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout173_X net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_87_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7957_ adder_inst.sum_raw_r\[10\] net489 _3462_ adder_inst.sum_raw_r\[9\] _3551_
+ VGND VGND VPWR VPWR _3552_ sky130_fd_sc_hd__a221o_1
XFILLER_70_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7888_ _3469_ _3481_ _3482_ _3493_ VGND VGND VPWR VPWR _3494_ sky130_fd_sc_hd__or4_1
XANTENNA__5020__D net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8166__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout438_X net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout340_X net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6908_ _2499_ _2527_ VGND VGND VPWR VPWR _2538_ sky130_fd_sc_hd__xnor2_1
X_6839_ net299 net478 _2458_ _2462_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_118_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8509_ _4079_ _4081_ VGND VGND VPWR VPWR _4082_ sky130_fd_sc_hd__nand2_1
XFILLER_108_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9489_ clknet_leaf_25_clk net765 _0399_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
XFILLER_136_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold280 _0002_ VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold291 adder_inst.is_zero_a_r VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5699__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5694__A2 net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_17_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5170_ _0797_ _0798_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__or3_1
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6643__A1 net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6643__B2 net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput4 i_a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_83_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8860_ net764 mul_res\[12\] net504 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__mux2_1
XFILLER_64_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6217__C net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_7811_ net490 _3416_ VGND VGND VPWR VPWR _3417_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8791_ _4284_ _4285_ _4297_ VGND VGND VPWR VPWR _4298_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_35_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7742_ adder_inst.i_b\[17\] adder_inst.i_b\[18\] adder_inst.i_b\[21\] adder_inst.i_b\[22\]
+ VGND VGND VPWR VPWR _3361_ sky130_fd_sc_hd__or4_1
X_4954_ _0578_ _0582_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__xnor2_1
XFILLER_52_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6514__A net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7673_ _3295_ _3297_ VGND VGND VPWR VPWR _3299_ sky130_fd_sc_hd__or2_1
X_4885_ net386 net256 _0486_ _0485_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_82_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4709__A1 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9412_ clknet_leaf_29_clk multiplier_inst.man_final\[0\] _0322_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
X_6624_ _1717_ _1808_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__nor2_1
XANTENNA__5906__B1 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9343_ clknet_leaf_4_clk net724 _0253_ VGND VGND VPWR VPWR adder_inst.man_b_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_6555_ _2110_ _2183_ _2182_ _2176_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__o211ai_1
X_9274_ clknet_leaf_22_clk adder_inst.sum_raw\[11\] _0184_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[11\]
+ sky130_fd_sc_hd__dfrtp_4
X_5506_ _1083_ _1115_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__or3_4
XANTENNA_fanout300_A net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8225_ net134 _3715_ net132 VGND VGND VPWR VPWR _3798_ sky130_fd_sc_hd__a21bo_1
X_6486_ _2038_ _2039_ _2032_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__a21oi_2
XFILLER_133_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8875__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5437_ _1066_ net577 _1065_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__nor3b_4
X_5368_ net223 net393 _0424_ _0425_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_126_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8156_ net145 _3718_ _3727_ net124 VGND VGND VPWR VPWR _3730_ sky130_fd_sc_hd__a211oi_1
XFILLER_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8087_ _3659_ _3656_ _3299_ _3306_ VGND VGND VPWR VPWR _3661_ sky130_fd_sc_hd__a211o_4
XFILLER_113_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5299_ net243 net249 net413 net419 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__and4_1
X_7107_ _2684_ _2735_ VGND VGND VPWR VPWR _2737_ sky130_fd_sc_hd__xor2_2
XANTENNA_fanout290_X net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout388_X net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7038_ net201 net476 VGND VGND VPWR VPWR _2668_ sky130_fd_sc_hd__nand2_1
XANTENNA__4645__B1 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7230__D net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8989_ net514 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__inv_2
XFILLER_83_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5966__C net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8139__A1 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_input63_A i_b[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7114__A2 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8092__Y _3666_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4670_ _4435_ _4440_ VGND VGND VPWR VPWR _4441_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6988__B net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6340_ _1804_ _1886_ _1885_ net589 VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__a211oi_2
XFILLER_127_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6271_ net412 net418 net314 net320 VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__and4_1
X_8010_ net485 net497 net499 net172 VGND VGND VPWR VPWR _3598_ sky130_fd_sc_hd__a22o_1
X_5222_ _0815_ _0816_ _0850_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a21oi_1
XANTENNA__6864__B2 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5153_ net367 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand2_1
XANTENNA__4955__C net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5084_ net202 net422 VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand2_1
XFILLER_56_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8912_ net522 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__inv_2
XFILLER_65_761 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5644__A2_N net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8843_ _3262_ _3266_ VGND VGND VPWR VPWR multiplier_inst.man_final\[20\] sky130_fd_sc_hd__xor2_1
XFILLER_25_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout250_A net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout348_A adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8774_ _2249_ _2571_ VGND VGND VPWR VPWR _4281_ sky130_fd_sc_hd__nand2_1
XFILLER_13_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5986_ _1614_ _1615_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__and2_1
X_7725_ net103 _3339_ _3347_ VGND VGND VPWR VPWR _3348_ sky130_fd_sc_hd__and3_1
X_4937_ _0530_ _0565_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nand3_1
X_7656_ _3276_ _3283_ VGND VGND VPWR VPWR _3284_ sky130_fd_sc_hd__xnor2_1
X_4868_ _0495_ _0496_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__or3_1
X_6607_ _2235_ _2236_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__and2_1
XFILLER_20_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4799_ _0423_ _0427_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__xnor2_2
X_7587_ _3215_ _3216_ VGND VGND VPWR VPWR _3217_ sky130_fd_sc_hd__or2_1
X_9326_ clknet_leaf_0_clk net706 _0236_ VGND VGND VPWR VPWR adder_inst.man_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_20_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8829__C1 net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6538_ _2088_ _2093_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__xor2_1
XANTENNA_fanout303_X net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9257_ clknet_leaf_9_clk net52 _0167_ VGND VGND VPWR VPWR adder_inst.exp_b\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_137_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6469_ _2095_ _2097_ _2098_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__nand3_1
X_9188_ net547 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__inv_2
XFILLER_134_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8208_ _3779_ _3781_ VGND VGND VPWR VPWR _3782_ sky130_fd_sc_hd__nand2_1
XFILLER_0_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8139_ net304 net446 net155 VGND VGND VPWR VPWR _3713_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4865__C net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6419__A net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_34_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4881__B net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_43_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7713__A _3152_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_52_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6974__D net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone122 net108 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__buf_8
XFILLER_93_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5887__B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5840_ _1447_ _1448_ _1468_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__nand4_2
XFILLER_22_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5771_ _1399_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__and2b_1
XFILLER_34_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8490_ net165 _4059_ _4062_ VGND VGND VPWR VPWR _4063_ sky130_fd_sc_hd__o21a_1
X_4722_ net219 net365 VGND VGND VPWR VPWR _4493_ sky130_fd_sc_hd__nand2_1
X_7510_ _3135_ _3139_ _3132_ VGND VGND VPWR VPWR _3140_ sky130_fd_sc_hd__o21a_1
X_7441_ _3070_ _3037_ VGND VGND VPWR VPWR _3071_ sky130_fd_sc_hd__and2b_1
Xinput40 i_b[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
X_4653_ net235 net370 net376 net229 VGND VGND VPWR VPWR _4424_ sky130_fd_sc_hd__a22oi_1
XANTENNA__6511__B net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput51 i_b[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_4584_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _4355_
+ sky130_fd_sc_hd__nand2b_4
Xinput62 i_b[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
X_7372_ _2984_ _3001_ VGND VGND VPWR VPWR _3002_ sky130_fd_sc_hd__nor2_1
X_9111_ net529 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__inv_2
X_6323_ _1872_ _1952_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__nor2_1
XFILLER_116_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9042_ net525 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__inv_2
X_6254_ _1798_ _1882_ _1880_ net581 VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__a211oi_4
XFILLER_88_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5205_ net222 net429 _0579_ _0580_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__o2bb2a_1
XANTENNA__7910__X _0062_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6185_ _1812_ _1813_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__or3_4
XFILLER_123_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5136_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__inv_2
XFILLER_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5067_ _0689_ _0695_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nand3_1
XFILLER_84_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout465_A net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7014__A1 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_121_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8826_ net102 _3238_ VGND VGND VPWR VPWR _4321_ sky130_fd_sc_hd__nand2b_1
XFILLER_53_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout253_X net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8757_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r _4273_ net199 VGND VGND
+ VPWR VPWR _0104_ sky130_fd_sc_hd__o31a_4
XFILLER_53_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5969_ net203 net482 VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__nand2_1
XFILLER_12_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7708_ _3301_ _3311_ _3300_ VGND VGND VPWR VPWR _3332_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_23_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6702__A net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout420_X net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout518_X net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8688_ _4239_ net175 _4241_ VGND VGND VPWR VPWR _4242_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_97_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7639_ _3244_ _3159_ _3261_ _3267_ VGND VGND VPWR VPWR _3269_ sky130_fd_sc_hd__and4_1
XFILLER_20_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9309_ clknet_leaf_4_clk net712 _0219_ VGND VGND VPWR VPWR adder_inst.man_a_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_122_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6452__A1_N net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input26_A i_a[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_139_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8505__A1 net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_61_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7990_ net115 _3580_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_1_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6941_ _2570_ _2568_ VGND VGND VPWR VPWR _2571_ sky130_fd_sc_hd__nand2b_1
XFILLER_50_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6872_ _2492_ _2496_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__xnor2_1
XFILLER_35_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8611_ _3947_ _4170_ _4173_ VGND VGND VPWR VPWR _4174_ sky130_fd_sc_hd__a21oi_1
X_5823_ net279 net408 net286 net402 VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a22oi_2
XFILLER_22_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5558__B2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5558__A1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8542_ net105 VGND VGND VPWR VPWR _4115_ sky130_fd_sc_hd__inv_16
XFILLER_10_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5754_ _1374_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__xor2_1
XANTENNA__4781__A2 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8473_ net382 net165 _3979_ _4019_ VGND VGND VPWR VPWR _4046_ sky130_fd_sc_hd__a22o_1
X_4705_ _4464_ _4466_ _4463_ VGND VGND VPWR VPWR _4476_ sky130_fd_sc_hd__o21ba_1
X_5685_ _1307_ _1308_ _1313_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__a21o_1
X_4636_ _4406_ _4397_ VGND VGND VPWR VPWR _4407_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_79_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout213_A net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7424_ _3052_ _3053_ VGND VGND VPWR VPWR _3054_ sky130_fd_sc_hd__nor2_1
XANTENNA__5629__A1_N net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7355_ _2737_ _2772_ _2736_ VGND VGND VPWR VPWR _2985_ sky130_fd_sc_hd__a21oi_2
XANTENNA__5730__A1 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4567_ adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR _4339_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6306_ _1852_ _1853_ _1854_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__a21o_1
XANTENNA__5730__B2 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7286_ net220 net444 _2850_ _2851_ VGND VGND VPWR VPWR _2916_ sky130_fd_sc_hd__o2bb2a_1
X_9025_ net514 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__inv_2
XFILLER_103_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6237_ net253 net475 VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__nand2_1
XANTENNA__7072__B net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6168_ _1774_ _1797_ _1796_ _1776_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__or4_4
XANTENNA_fanout370_X net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5119_ _0661_ _0746_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nor3_2
XFILLER_97_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout468_X net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6099_ net407 net316 net321 net401 VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_28_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5797__B2 net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5797__A1 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8809_ _3185_ _3192_ VGND VGND VPWR VPWR _4312_ sky130_fd_sc_hd__and2b_1
XFILLER_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone43 net113 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__clkbuf_1
XANTENNA__6151__B net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8078__B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8822__A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5960__A1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5960__B2 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5470_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__inv_2
XANTENNA__6996__B net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7140_ _2767_ _2768_ _2633_ _2635_ VGND VGND VPWR VPWR _2770_ sky130_fd_sc_hd__o211ai_1
XFILLER_125_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout419 net423 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__clkbuf_2
Xfanout408 net409 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_2
X_7071_ net573 net292 VGND VGND VPWR VPWR _2701_ sky130_fd_sc_hd__nand2_1
XFILLER_101_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6022_ _1646_ _1651_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__nand2b_1
XFILLER_94_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7973_ _3414_ _3564_ _3565_ VGND VGND VPWR VPWR _3566_ sky130_fd_sc_hd__o21a_1
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6236__B net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout163_A net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6924_ _2318_ _2362_ _2365_ VGND VGND VPWR VPWR _2554_ sky130_fd_sc_hd__or3_1
XANTENNA__6440__A2 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6855_ _2444_ _2448_ _2474_ _2477_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__a211o_1
XANTENNA_fanout428_A net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout330_A adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6786_ _2390_ _2398_ _2397_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_33_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5806_ net395 net291 VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__nand2_1
XANTENNA__8878__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9336__Q adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8525_ _3830_ _3854_ _4095_ _4096_ VGND VGND VPWR VPWR _4098_ sky130_fd_sc_hd__o31ai_4
X_5737_ net377 net314 net320 net371 VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__a22oi_1
XANTENNA__5568__A1_N net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_33_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8456_ net160 _4026_ _4028_ VGND VGND VPWR VPWR _4029_ sky130_fd_sc_hd__o21ai_1
XFILLER_136_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout216_X net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7407_ _4512_ _4513_ _4511_ VGND VGND VPWR VPWR _3037_ sky130_fd_sc_hd__a21bo_1
X_5668_ _1161_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__nor2_2
X_8387_ net121 _3958_ _3959_ VGND VGND VPWR VPWR _3960_ sky130_fd_sc_hd__and3_1
X_4619_ _4373_ _4383_ VGND VGND VPWR VPWR _4390_ sky130_fd_sc_hd__nor2_1
X_5599_ _1226_ _1227_ _1225_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a21bo_1
X_7338_ net201 net460 _2923_ _2922_ VGND VGND VPWR VPWR _2968_ sky130_fd_sc_hd__a31oi_1
XFILLER_104_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7269_ _2898_ _2897_ VGND VGND VPWR VPWR _2899_ sky130_fd_sc_hd__and2b_1
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9008_ net507 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__inv_2
XFILLER_49_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7208__A1 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4873__C net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6427__A net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5209__C net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload18 clknet_leaf_30_clk VGND VGND VPWR VPWR clkload18/Y sky130_fd_sc_hd__clkinv_8
XFILLER_5_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4783__C net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6958__B1 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4970_ _0595_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__or2_1
XFILLER_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7168__A _1622_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6640_ _2267_ _2268_ _2266_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__o21bai_1
XFILLER_20_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6571_ _2123_ _2125_ _2124_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__o21ai_1
X_8310_ net125 _3718_ net124 _3882_ VGND VGND VPWR VPWR _3883_ sky130_fd_sc_hd__a211o_1
X_5522_ _1146_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_30_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9290_ clknet_leaf_0_clk net695 _0200_ VGND VGND VPWR VPWR adder_inst.man_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_133_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8241_ net135 _3746_ _3813_ net137 VGND VGND VPWR VPWR _3814_ sky130_fd_sc_hd__a211o_1
X_5453_ _1035_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__or2_1
X_5384_ _1013_ _0987_ _0986_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__and3_1
XFILLER_105_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8172_ net274 net416 net155 VGND VGND VPWR VPWR _3746_ sky130_fd_sc_hd__mux2_1
XFILLER_113_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout205 net211 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_2
X_7123_ net227 net233 net437 net444 VGND VGND VPWR VPWR _2753_ sky130_fd_sc_hd__and4_1
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout216 net218 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_2
XFILLER_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7989__A2 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout227 net230 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_2
Xfanout238 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout249 net563 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_6
X_7054_ _2614_ _2637_ _2613_ VGND VGND VPWR VPWR _2684_ sky130_fd_sc_hd__a21oi_2
XANTENNA_fanout280_A net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6005_ _1633_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__nor2_1
XFILLER_95_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout378_A net379 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7610__A1 net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout545_A net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout166_X net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8462__A net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7956_ adder_inst.sum_raw_r\[8\] net191 _3549_ _3550_ _3413_ VGND VGND VPWR VPWR
+ _3551_ sky130_fd_sc_hd__o221a_1
X_7887_ net186 _3490_ _3491_ _3492_ VGND VGND VPWR VPWR _3493_ sky130_fd_sc_hd__a31o_1
X_6907_ _2484_ _2536_ VGND VGND VPWR VPWR _2537_ sky130_fd_sc_hd__xnor2_1
X_6838_ _2458_ _2462_ net299 net478 VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__o211a_1
XANTENNA_fanout333_X net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_118_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8508_ _4080_ VGND VGND VPWR VPWR _4081_ sky130_fd_sc_hd__inv_2
XFILLER_10_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6769_ _2390_ _2397_ _2398_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__and3_1
XFILLER_136_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9488_ clknet_leaf_25_clk net829 _0398_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
XFILLER_136_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9443__D net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_131_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8439_ _4011_ VGND VGND VPWR VPWR _4012_ sky130_fd_sc_hd__inv_2
Xhold270 multiplier_inst.man_final_r\[0\] VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 _0071_ VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold281 add_res\[6\] VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5061__A net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5860__B1 net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7601__A1 _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput5 i_a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_7810_ adder_inst.exp_larger_r\[1\] _3395_ VGND VGND VPWR VPWR _3416_ sky130_fd_sc_hd__or2_1
XFILLER_76_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6217__D net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8790_ _2552_ _4287_ _4296_ _4286_ VGND VGND VPWR VPWR _4297_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_35_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7741_ adder_inst.i_b\[8\] adder_inst.i_b\[11\] adder_inst.i_b\[13\] adder_inst.i_b\[14\]
+ VGND VGND VPWR VPWR _3360_ sky130_fd_sc_hd__or4_1
X_4953_ _0578_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6514__B net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7672_ _3295_ _3297_ VGND VGND VPWR VPWR _3298_ sky130_fd_sc_hd__nor2_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9411_ clknet_leaf_14_clk multiplier_inst.overflow_calc _0321_ VGND VGND VPWR VPWR
+ multiplier_inst.overflow_calc_r sky130_fd_sc_hd__dfrtp_1
X_4884_ _0510_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_82_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6623_ _2252_ _1976_ _1973_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__o21a_1
XFILLER_20_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4709__A2 net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5906__B2 net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5906__A1 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9342_ clknet_leaf_5_clk net708 _0252_ VGND VGND VPWR VPWR adder_inst.man_b_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_118_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6554_ _2176_ _2182_ _2183_ net612 VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__a211o_4
X_9273_ clknet_leaf_24_clk adder_inst.sum_raw\[10\] _0183_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[10\]
+ sky130_fd_sc_hd__dfrtp_4
XPHY_EDGE_ROW_89_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5505_ _1133_ _1134_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__or2_1
X_6485_ _2107_ _2112_ net570 VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__nand3_4
XFILLER_118_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5436_ _1014_ _1015_ _1017_ _4399_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__o22a_1
X_8224_ net134 _3715_ net132 VGND VGND VPWR VPWR _3797_ sky130_fd_sc_hd__a21boi_1
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5367_ _0419_ _0988_ _0995_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__a21oi_1
X_8155_ _3678_ _3700_ VGND VGND VPWR VPWR _3729_ sky130_fd_sc_hd__or2_4
XFILLER_87_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8086_ _3656_ _3659_ VGND VGND VPWR VPWR _3660_ sky130_fd_sc_hd__and2_1
XFILLER_59_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5298_ _0828_ _0926_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nand3_1
X_7106_ _2684_ _2735_ VGND VGND VPWR VPWR _2736_ sky130_fd_sc_hd__nor2_1
XANTENNA__7831__A1 adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7037_ _2665_ _2666_ VGND VGND VPWR VPWR _2667_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout283_X net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4645__B2 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4645__A1 net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_98_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_751 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout548_X net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8988_ net517 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__inv_2
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout450_X net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_124_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7939_ adder_inst.sum_raw_r\[5\] net192 _3405_ adder_inst.sum_raw_r\[4\] net191 VGND
+ VGND VPWR VPWR _3536_ sky130_fd_sc_hd__o221a_1
XFILLER_82_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5966__D net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6113__A1_N net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input56_A i_b[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_111_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6086__B1 _1622_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6053__C net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6988__C net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9434__Q multiplier_inst.man_final_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6270_ net425 net308 VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__nand2_1
XFILLER_130_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8277__A net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5221_ _0815_ _0816_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__and3_1
XFILLER_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6864__A2 net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5152_ net353 net359 net298 net301 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__and4_1
XFILLER_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4955__D net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5083_ _0711_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nor2_1
XFILLER_111_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8911_ net521 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__inv_2
XFILLER_110_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8842_ _3250_ _4329_ _3262_ VGND VGND VPWR VPWR multiplier_inst.man_final\[19\] sky130_fd_sc_hd__a21oi_1
XFILLER_65_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8773_ _2121_ _4279_ VGND VGND VPWR VPWR _4280_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7724_ _3340_ _3346_ VGND VGND VPWR VPWR _3347_ sky130_fd_sc_hd__xnor2_2
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5985_ _1503_ _1505_ _1613_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__or3b_1
X_4936_ _0527_ _0529_ _0528_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout243_A net565 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7655_ _4352_ _3282_ _3281_ VGND VGND VPWR VPWR _3283_ sky130_fd_sc_hd__o21bai_1
X_4867_ net373 net281 net287 net367 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a22oi_2
XFILLER_32_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout410_A net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7586_ _1135_ _1156_ _3214_ VGND VGND VPWR VPWR _3216_ sky130_fd_sc_hd__and3_1
X_6606_ net276 net283 net470 net477 VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__and4_1
X_4798_ _0427_ _0423_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__and2b_1
X_9325_ clknet_leaf_31_clk net700 _0235_ VGND VGND VPWR VPWR adder_inst.man_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_6537_ _2090_ _2166_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__nand2b_1
XFILLER_134_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9256_ clknet_leaf_8_clk net51 _0166_ VGND VGND VPWR VPWR adder_inst.exp_b\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_137_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6468_ _2073_ _2075_ _2096_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__nand3_1
X_9187_ net543 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__inv_2
XFILLER_134_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5419_ _1002_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__nor2_1
XFILLER_121_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8207_ _3777_ net157 _3780_ VGND VGND VPWR VPWR _3781_ sky130_fd_sc_hd__a21oi_4
X_6399_ net567 _2026_ _2028_ _1941_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__o211ai_4
XANTENNA__8057__A1 net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8138_ net560 adder_inst.man_a_r\[7\] net155 VGND VGND VPWR VPWR _3712_ sky130_fd_sc_hd__mux2_1
XFILLER_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4865__D net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6419__B net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_126_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8069_ net186 _3422_ VGND VGND VPWR VPWR _3647_ sky130_fd_sc_hd__nand2_1
XFILLER_102_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_2_0__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6791__B2 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_26_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_leaf_16_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7537__Y _3167_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6059__B1 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone112 net108 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__buf_8
XANTENNA__8825__A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone134 net105 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__inv_8
XFILLER_93_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8036__S net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8220__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5770_ net267 net427 net433 net260 VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a22o_1
X_4721_ _4490_ _4491_ VGND VGND VPWR VPWR _4492_ sky130_fd_sc_hd__nor2_1
X_4652_ net229 net235 net370 net376 VGND VGND VPWR VPWR _4423_ sky130_fd_sc_hd__and4_1
X_7440_ _3068_ _3069_ VGND VGND VPWR VPWR _3070_ sky130_fd_sc_hd__or2_1
Xinput30 i_a[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XANTENNA__6511__C net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput52 i_b[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4583_ _4352_ _4353_ VGND VGND VPWR VPWR _4354_ sky130_fd_sc_hd__nand2_1
XFILLER_116_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput41 i_b[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput63 i_b[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
X_9110_ net529 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__inv_2
X_7371_ _2999_ _3000_ _2998_ VGND VGND VPWR VPWR _3001_ sky130_fd_sc_hd__a21boi_1
XANTENNA__8287__A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6322_ _1790_ _1871_ _1870_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__a21oi_1
XFILLER_89_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9041_ net525 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
X_6253_ net581 _1880_ _1882_ _1798_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__o211a_4
XANTENNA__6298__B1 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5204_ _0574_ _0817_ _0832_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a21oi_1
X_6184_ net402 net332 net338 net395 VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__a22oi_2
X_5135_ _0761_ net569 _0749_ _0754_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__a211oi_2
X_5066_ _0693_ _0694_ _0690_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout360_A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7014__A2 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout458_A net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_121_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__9339__Q adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8825_ net104 _4319_ _4320_ VGND VGND VPWR VPWR multiplier_inst.man_final\[11\] sky130_fd_sc_hd__nor3_1
XFILLER_53_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8756_ multiplier_inst.is_zero_r multiplier_inst.overflow_calc_r VGND VGND VPWR VPWR
+ _4273_ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout246_X net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5968_ _1596_ _1597_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__nor2_1
XANTENNA__6773__A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7707_ _3329_ _3330_ VGND VGND VPWR VPWR _3331_ sky130_fd_sc_hd__nor2_1
X_4919_ _0542_ _0547_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__xor2_1
XFILLER_52_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8687_ net188 _4038_ _4240_ VGND VGND VPWR VPWR _4241_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_97_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout413_X net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6702__B net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5899_ _1521_ _1522_ _1527_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__a21o_1
X_7638_ _3244_ _3261_ _3267_ VGND VGND VPWR VPWR _3268_ sky130_fd_sc_hd__and3_1
XFILLER_119_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7569_ _3173_ _3184_ _3198_ _3193_ VGND VGND VPWR VPWR _3199_ sky130_fd_sc_hd__nor4b_4
X_9308_ clknet_leaf_5_clk net703 _0218_ VGND VGND VPWR VPWR adder_inst.man_a_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA__8278__A1 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9239_ clknet_leaf_3_clk net64 _0149_ VGND VGND VPWR VPWR adder_inst.i_b\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_79_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4839__A1 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input19_A i_a[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_805 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7795__A3 adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6940_ net559 _2569_ VGND VGND VPWR VPWR _2570_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6871_ _2498_ _2500_ VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__or2_1
XFILLER_34_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8610_ _3942_ _3944_ VGND VGND VPWR VPWR _4173_ sky130_fd_sc_hd__and2b_1
XFILLER_50_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5822_ net402 net279 net408 net286 VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__and4_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5558__A2 net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8541_ _4012_ _4093_ _4113_ _4111_ VGND VGND VPWR VPWR _4114_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_50_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5753_ _1381_ _1382_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__and2b_1
X_4704_ _4472_ _4473_ VGND VGND VPWR VPWR _4475_ sky130_fd_sc_hd__xnor2_1
X_8472_ _4044_ VGND VGND VPWR VPWR _4045_ sky130_fd_sc_hd__inv_2
X_5684_ _1307_ _1308_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__nand3_1
X_4635_ _4399_ _4405_ VGND VGND VPWR VPWR _4406_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_79_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7423_ net215 net362 net366 net210 VGND VGND VPWR VPWR _3053_ sky130_fd_sc_hd__a22oi_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4566_ adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR _4338_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout206_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7354_ _2978_ _2979_ VGND VGND VPWR VPWR _2984_ sky130_fd_sc_hd__xor2_1
XFILLER_116_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6305_ _1914_ _1918_ _1917_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__a21o_1
XFILLER_131_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9024_ net516 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__inv_2
XFILLER_103_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7285_ _2843_ _2912_ _2913_ VGND VGND VPWR VPWR _2915_ sky130_fd_sc_hd__a21oi_1
XFILLER_134_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7072__C net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6236_ net259 net266 net462 net468 VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__and4_1
XFILLER_131_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7640__Y _3270_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6167_ _1778_ _1779_ _1793_ _1795_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__o211a_1
X_5118_ _0745_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__or2_1
XFILLER_69_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6098_ net401 net407 net315 net321 VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_28_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5049_ _0677_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__and2b_1
XFILLER_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout363_X net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8752__X _0085_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8808_ _3178_ _3181_ _4310_ _3185_ VGND VGND VPWR VPWR multiplier_inst.man_final\[3\]
+ sky130_fd_sc_hd__o31a_1
XFILLER_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6713__A net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8739_ net837 net179 net176 VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__and3_1
XFILLER_139_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6151__C net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_134_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8187__A0 net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5960__A2 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_14_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6996__C net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout409 net411 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__buf_4
X_7070_ _2593_ _2595_ _2594_ VGND VGND VPWR VPWR _2700_ sky130_fd_sc_hd__o21bai_1
XFILLER_113_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6021_ _1647_ _1649_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7972_ adder_inst.sum_raw_r\[12\] net189 net169 adder_inst.sum_raw_r\[11\] net184
+ VGND VGND VPWR VPWR _3565_ sky130_fd_sc_hd__o221a_1
XANTENNA__6236__C net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6923_ _2548_ _2551_ _2412_ _2481_ VGND VGND VPWR VPWR _2553_ sky130_fd_sc_hd__o2bb2a_2
XANTENNA__8717__A2 _4115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8732__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout156_A _3666_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6854_ _2447_ _2478_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__xnor2_2
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6785_ _2406_ _2414_ VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__nand2b_1
X_5805_ _1365_ _1367_ _1366_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__o21bai_1
XFILLER_129_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8524_ _4096_ VGND VGND VPWR VPWR _4097_ sky130_fd_sc_hd__inv_2
XFILLER_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5736_ net371 net377 net314 net320 VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__and4_1
X_8455_ net230 net166 VGND VGND VPWR VPWR _4028_ sky130_fd_sc_hd__or2_1
X_5667_ net401 net308 _1159_ _1160_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_135_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7406_ _1158_ _3035_ _0458_ VGND VGND VPWR VPWR _3036_ sky130_fd_sc_hd__a21oi_1
X_4618_ _4373_ _4387_ VGND VGND VPWR VPWR _4389_ sky130_fd_sc_hd__and2_1
X_8386_ net127 net141 _3763_ _3678_ VGND VGND VPWR VPWR _3959_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout209_X net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5598_ _1225_ _1226_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__nand3b_1
XFILLER_116_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8747__X _0079_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7337_ _2964_ _2965_ VGND VGND VPWR VPWR _2967_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7268_ _2697_ _2709_ _2696_ VGND VGND VPWR VPWR _2898_ sky130_fd_sc_hd__a21oi_2
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9007_ net543 VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout480_X net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6219_ net285 net445 net450 net278 VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__a22o_1
X_7199_ _0907_ _0908_ _0909_ VGND VGND VPWR VPWR _2829_ sky130_fd_sc_hd__a21o_1
XFILLER_58_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7208__A2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4873__D net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6427__B net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8708__A2 net683 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4898__A net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload19 clknet_leaf_12_clk VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__inv_12
XANTENNA__5209__D net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_rebuffer14_X net563 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9262__Q opcode_stage1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_114_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_118_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4783__D net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6958__A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6958__B2 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_127_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6570_ _2197_ _2198_ _2196_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__o21bai_1
XFILLER_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5521_ _1149_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_30_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8240_ _4358_ net151 net656 net148 _3741_ VGND VGND VPWR VPWR _3813_ sky130_fd_sc_hd__o41a_1
XTAP_TAPCELL_ROW_76_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5452_ _1036_ _1080_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__xnor2_4
XFILLER_132_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5383_ _0996_ _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nand2b_4
XFILLER_117_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8171_ net125 _3743_ _3744_ VGND VGND VPWR VPWR _3745_ sky130_fd_sc_hd__or3_4
XPHY_EDGE_ROW_136_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7122_ net220 net449 VGND VGND VPWR VPWR _2752_ sky130_fd_sc_hd__nand2_1
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_2
Xfanout228 net229 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_2
XFILLER_99_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout206 net211 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_2
X_7053_ _2640_ _2677_ _2639_ VGND VGND VPWR VPWR _2683_ sky130_fd_sc_hd__a21oi_2
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6004_ net401 net315 net322 net396 VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a22oi_1
XFILLER_28_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout273_A net275 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7610__A2 _3237_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8462__B net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7955_ adder_inst.sum_raw_r\[7\] net496 net492 VGND VGND VPWR VPWR _3550_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout538_A net539 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7886_ _4345_ net172 _3483_ net485 _3435_ VGND VGND VPWR VPWR _3492_ sky130_fd_sc_hd__a221o_1
XFILLER_70_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout440_A net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6263__A net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6906_ _2488_ _2515_ _2530_ _2534_ _2510_ VGND VGND VPWR VPWR _2536_ sky130_fd_sc_hd__o41a_1
X_6837_ _2431_ _2450_ _2466_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_118_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout326_X net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8507_ _4077_ _4078_ VGND VGND VPWR VPWR _4080_ sky130_fd_sc_hd__and2_1
XFILLER_7_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6768_ _2335_ _2374_ _2389_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__a21o_1
X_9487_ clknet_leaf_26_clk net775 _0397_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
X_6699_ net310 net317 net447 net452 VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__and4_1
XANTENNA__5607__A net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5719_ _1339_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_131_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8438_ _3948_ _3967_ _3989_ _4010_ VGND VGND VPWR VPWR _4011_ sky130_fd_sc_hd__and4b_1
XFILLER_136_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8369_ _4333_ _3941_ net162 VGND VGND VPWR VPWR _3942_ sky130_fd_sc_hd__mux2_1
XFILLER_2_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold260 multiplier_inst.man_final_r\[7\] VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dlygate4sd3_1
Xhold271 add_res\[5\] VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 multiplier_inst.sign_res_r VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 _0028_ VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__7541__B _3170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5061__B net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5860__A1 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5860__B2 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5376__B1 net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8828__A _3270_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5523__Y _1153_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4794__C net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6348__A net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput6 i_a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_110_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7740_ adder_inst.i_b\[16\] adder_inst.i_b\[19\] adder_inst.i_b\[20\] _3358_ VGND
+ VGND VPWR VPWR _3359_ sky130_fd_sc_hd__or4_1
X_4952_ _0579_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_69_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_690 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7671_ adder_inst.exp_a_r\[5\] adder_inst.exp_b_r\[5\] VGND VGND VPWR VPWR _3297_
+ sky130_fd_sc_hd__and2b_1
X_4883_ _0510_ _0511_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__or3_4
X_9410_ clknet_leaf_13_clk _0070_ _0320_ VGND VGND VPWR VPWR multiplier_inst.is_nan_r
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__8553__B1 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6622_ _2250_ _2121_ _2046_ _2251_ _2045_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__a311oi_2
XFILLER_137_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5906__A2 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9341_ clknet_leaf_5_clk net715 _0251_ VGND VGND VPWR VPWR adder_inst.man_b_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_6553_ _2103_ _2104_ _2109_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__o21ba_1
X_5504_ _1116_ _1132_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__and2_1
X_9272_ clknet_leaf_24_clk adder_inst.sum_raw\[9\] _0182_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[9\]
+ sky130_fd_sc_hd__dfrtp_4
X_6484_ _2113_ _2112_ _2107_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__and3_1
X_5435_ _1061_ _1062_ _1064_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__and3_1
X_8223_ _4358_ net151 net656 net148 _3713_ VGND VGND VPWR VPWR _3796_ sky130_fd_sc_hd__o41ai_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5366_ _0419_ _0988_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__and3_1
XFILLER_114_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8154_ _3678_ _3700_ VGND VGND VPWR VPWR _3728_ sky130_fd_sc_hd__nor2_1
XFILLER_59_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8085_ _3654_ _3657_ VGND VGND VPWR VPWR _3659_ sky130_fd_sc_hd__nand2b_4
XANTENNA_fanout488_A net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5297_ _0825_ _0827_ _0826_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__o21ai_1
X_7105_ _2712_ _2734_ VGND VGND VPWR VPWR _2735_ sky130_fd_sc_hd__xnor2_2
XFILLER_75_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7036_ net213 net463 net469 net206 VGND VGND VPWR VPWR _2666_ sky130_fd_sc_hd__a22oi_1
XANTENNA__4645__A2 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout276_X net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8987_ net517 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__inv_2
XFILLER_83_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7938_ net115 _3535_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__and2_1
XFILLER_82_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7869_ net493 _3432_ VGND VGND VPWR VPWR _3475_ sky130_fd_sc_hd__nor2_1
XFILLER_23_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7552__A _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_111_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5530__B1 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input49_A i_b[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5597__B1 net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7338__A1 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6053__D net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6988__D net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5247__A net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5220_ _0833_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__or2_1
XANTENNA__8277__B _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5151_ _0463_ _0779_ _0778_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__a21o_1
X_5082_ net217 net410 net417 net207 VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__a22oi_1
XFILLER_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8910_ net522 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
XFILLER_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8841_ _3270_ _4328_ _4329_ VGND VGND VPWR VPWR multiplier_inst.man_final\[18\] sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8772_ _2257_ _2571_ _2250_ VGND VGND VPWR VPWR _4279_ sky130_fd_sc_hd__o21bai_1
XANTENNA__5588__B1 net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7723_ _3344_ _3345_ VGND VGND VPWR VPWR _3346_ sky130_fd_sc_hd__xnor2_1
XFILLER_40_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5984_ _1503_ _1505_ _1613_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__o21bai_1
XFILLER_80_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4935_ net258 net397 _0563_ _0561_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a31o_1
XFILLER_52_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7654_ _3280_ _3281_ VGND VGND VPWR VPWR _3282_ sky130_fd_sc_hd__or2_1
X_4866_ net379 net274 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__nand2_1
X_4797_ _0424_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nor2_2
X_7585_ _1156_ _3214_ _1135_ VGND VGND VPWR VPWR _3215_ sky130_fd_sc_hd__a21oi_1
X_6605_ _2163_ _2234_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__nor2_1
XFILLER_20_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout403_A net404 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9324_ clknet_leaf_31_clk net723 _0234_ VGND VGND VPWR VPWR adder_inst.man_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_2
X_6536_ _2160_ _2164_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9255_ clknet_leaf_8_clk net50 _0165_ VGND VGND VPWR VPWR adder_inst.exp_b\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_95_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6467_ _2073_ _2075_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__a21o_1
X_9186_ net544 VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__inv_2
XFILLER_133_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5418_ net223 net399 _1000_ _1001_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_88_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8206_ net482 net156 VGND VGND VPWR VPWR _3780_ sky130_fd_sc_hd__nor2_1
X_6398_ _1924_ _1925_ _1939_ _1940_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__a22o_1
X_8137_ net149 net151 _4358_ net148 VGND VGND VPWR VPWR _3711_ sky130_fd_sc_hd__or4_4
X_5349_ _0449_ _0451_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__xor2_1
X_8068_ _3628_ _3646_ net198 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_126_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7019_ _2646_ _2647_ _2645_ VGND VGND VPWR VPWR _2649_ sky130_fd_sc_hd__a21bo_1
XANTENNA__7017__B1 net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8765__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6240__A1 net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7547__A _3176_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6791__A2 net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9270__Q adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6059__A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6059__B2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8841__A _3270_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4720_ net226 net363 net232 net357 VGND VGND VPWR VPWR _4491_ sky130_fd_sc_hd__a22oi_1
XFILLER_14_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4651_ _4408_ _4421_ VGND VGND VPWR VPWR _4422_ sky130_fd_sc_hd__or2_1
XFILLER_30_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput20 i_a[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 i_a[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
Xinput53 i_b[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4582_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] _4351_ VGND VGND VPWR VPWR
+ _4353_ sky130_fd_sc_hd__or3_1
Xinput42 i_b[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
Xinput64 i_b[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
X_7370_ _2996_ _2997_ VGND VGND VPWR VPWR _3000_ sky130_fd_sc_hd__xor2_1
XFILLER_116_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6321_ net249 net479 _1950_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__and3_1
X_9040_ net525 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__inv_2
X_6252_ _1774_ _1776_ _1796_ _1797_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__o22ai_1
XANTENNA__6298__B2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6298__A1 net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5203_ _0574_ _0817_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__and3_1
X_6183_ net407 net326 VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__nand2_1
X_5134_ _0593_ _0762_ _0760_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__or4_4
XANTENNA__8735__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5065_ _0690_ _0693_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand3_1
X_8824_ _3213_ _4317_ _3218_ VGND VGND VPWR VPWR _4320_ sky130_fd_sc_hd__nor3_4
XFILLER_65_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout353_A net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8755_ multiplier_inst.is_zero_r net199 VGND VGND VPWR VPWR _4272_ sky130_fd_sc_hd__and2b_2
XANTENNA__7970__A1 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5967_ net214 net467 net474 net209 VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__a22oi_1
XANTENNA__6773__A2 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout520_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7706_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] _3328_ VGND VGND VPWR VPWR
+ _3330_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout239_X net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8686_ _4234_ _4235_ _4043_ VGND VGND VPWR VPWR _4240_ sky130_fd_sc_hd__a21o_1
X_4918_ _0542_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__and2_1
XANTENNA__6271__A net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7637_ _3265_ _3266_ VGND VGND VPWR VPWR _3267_ sky130_fd_sc_hd__and2_1
X_5898_ _1521_ _1522_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_97_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4849_ net369 net280 net287 net360 VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a22oi_2
XFILLER_21_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7568_ net111 _3197_ _3195_ VGND VGND VPWR VPWR _3198_ sky130_fd_sc_hd__a21oi_1
XANTENNA_fanout406_X net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9307_ clknet_leaf_5_clk net710 _0217_ VGND VGND VPWR VPWR adder_inst.man_a_r\[19\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_107_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7499_ _3124_ _3127_ _3128_ VGND VGND VPWR VPWR _3129_ sky130_fd_sc_hd__a21oi_1
X_6519_ _2146_ _2147_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__xnor2_1
X_9238_ clknet_leaf_1_clk net63 _0148_ VGND VGND VPWR VPWR adder_inst.i_b\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7830__A adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9169_ net526 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__inv_2
XFILLER_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5350__A net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_139_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_23_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_12_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8836__A _3270_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6356__A net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_1_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6870_ net310 net317 net471 net477 VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__and4_1
XFILLER_50_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5821_ net272 net415 VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__nand2_1
XFILLER_22_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8540_ _4083_ _4084_ _4112_ VGND VGND VPWR VPWR _4113_ sky130_fd_sc_hd__o21a_1
X_5752_ _1379_ _1380_ _1375_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__a21o_1
XFILLER_34_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_14_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_4703_ _4473_ _4472_ VGND VGND VPWR VPWR _4474_ sky130_fd_sc_hd__and2b_1
XFILLER_50_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8471_ _4033_ _4042_ VGND VGND VPWR VPWR _4044_ sky130_fd_sc_hd__or2_1
X_5683_ _1309_ _1312_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__xnor2_1
X_4634_ _4400_ _4404_ VGND VGND VPWR VPWR _4405_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_79_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7422_ net210 net215 net362 net366 VGND VGND VPWR VPWR _3052_ sky130_fd_sc_hd__and4_1
XFILLER_30_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4565_ adder_inst.sum_raw_r\[3\] VGND VGND VPWR VPWR _4337_ sky130_fd_sc_hd__inv_2
X_7353_ _2981_ _2982_ VGND VGND VPWR VPWR _2983_ sky130_fd_sc_hd__and2b_1
XFILLER_116_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6304_ _1932_ _1933_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__and2_1
XFILLER_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9023_ net514 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__inv_2
XFILLER_103_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7284_ _2843_ _2912_ _2913_ VGND VGND VPWR VPWR _2914_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7072__D net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6235_ _1771_ _1863_ net152 _1844_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__a211oi_2
XFILLER_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_15_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6166_ _1793_ _1795_ _1778_ _1779_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__a211oi_1
XFILLER_112_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5117_ _0743_ _0744_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__and2_1
XFILLER_69_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout470_A net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6097_ net415 net309 VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__nand2_1
X_5048_ net368 net262 net268 net360 VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a22o_1
XFILLER_57_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout356_X net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8807_ _4310_ _4311_ VGND VGND VPWR VPWR multiplier_inst.man_final\[2\] sky130_fd_sc_hd__nor2_1
XFILLER_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6713__B net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout523_X net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8738_ net809 net180 net177 VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__and3_1
X_6999_ _2625_ _2628_ VGND VGND VPWR VPWR _2629_ sky130_fd_sc_hd__xnor2_1
XFILLER_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone23 _3152_ VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__clkbuf_1
X_8669_ _4052_ _4053_ VGND VGND VPWR VPWR _4225_ sky130_fd_sc_hd__and2_1
XANTENNA__6151__D net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__9462__D _0080_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input31_A i_a[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4693__B1 net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7286__A2_N net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8187__A1 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6996__D net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5255__A net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_74_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_3_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_67_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6020_ _1171_ _1647_ _1648_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__or3_1
XFILLER_39_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_2_2__f_clk_X clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7971_ adder_inst.sum_raw_r\[10\] _3563_ net191 VGND VGND VPWR VPWR _3564_ sky130_fd_sc_hd__mux2_1
XFILLER_82_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6236__D net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6922_ _2548_ _2551_ VGND VGND VPWR VPWR _2552_ sky130_fd_sc_hd__nand2_1
XFILLER_120_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6853_ _2409_ _2413_ _2446_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__a21o_1
XFILLER_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5804_ _1377_ _1379_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__nand2_1
XFILLER_35_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6784_ _2401_ _2405_ _2404_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__o21ai_1
X_8523_ _3830_ _3849_ _3851_ _3829_ VGND VGND VPWR VPWR _4096_ sky130_fd_sc_hd__o31a_1
XFILLER_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5735_ net383 net308 VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__nand2_1
XFILLER_129_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8454_ net123 _3790_ _3979_ net166 net370 VGND VGND VPWR VPWR _4027_ sky130_fd_sc_hd__a32o_1
XANTENNA_fanout316_A adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5666_ _1294_ _1293_ _1289_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__a21o_1
XFILLER_136_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7405_ _3030_ _3029_ _3034_ VGND VGND VPWR VPWR _3035_ sky130_fd_sc_hd__a21o_1
X_4617_ _4373_ _4387_ VGND VGND VPWR VPWR _4388_ sky130_fd_sc_hd__nor2_1
X_8385_ net143 _3844_ _3914_ _3728_ VGND VGND VPWR VPWR _3958_ sky130_fd_sc_hd__a211o_1
X_5597_ net249 net445 net450 net241 VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__a22o_1
XFILLER_116_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap150 _3693_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_2
XANTENNA_fanout104_X net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7336_ _2964_ _2965_ VGND VGND VPWR VPWR _2966_ sky130_fd_sc_hd__and2b_1
X_7267_ _2809_ _2817_ VGND VGND VPWR VPWR _2897_ sky130_fd_sc_hd__xor2_2
X_9006_ net520 VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__inv_2
XFILLER_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6218_ net271 net456 VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__nand2_1
XFILLER_58_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7198_ _2810_ _2814_ _2813_ VGND VGND VPWR VPWR _2828_ sky130_fd_sc_hd__a21bo_1
XFILLER_100_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6149_ _1697_ _1777_ _1769_ _1767_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__a211oi_2
XANTENNA__6427__C net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_577 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4898__B net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_11_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4666__B1 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7604__B1 _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_699 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5520_ _1147_ _1148_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_30_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5451_ _1036_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_76_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5382_ _0996_ _0997_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or3_4
XFILLER_114_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8170_ net133 _3737_ _3735_ net138 VGND VGND VPWR VPWR _3744_ sky130_fd_sc_hd__o211a_1
XFILLER_125_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7121_ _2747_ _2748_ _2749_ VGND VGND VPWR VPWR _2751_ sky130_fd_sc_hd__a21oi_1
Xfanout229 net230 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout218 adder_inst.man_b_r\[21\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_4
Xfanout207 net211 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_2
XFILLER_101_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7052_ _2680_ _2681_ _2679_ VGND VGND VPWR VPWR _2682_ sky130_fd_sc_hd__a21oi_1
XFILLER_101_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6003_ net395 net401 net316 net321 VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__and4_1
XFILLER_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7954_ adder_inst.sum_raw_r\[5\] net170 _3548_ VGND VGND VPWR VPWR _3549_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_87_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5082__B1 net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout266_A net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6905_ _2488_ _2516_ _2530_ _2534_ VGND VGND VPWR VPWR _2535_ sky130_fd_sc_hd__nor4_1
X_7885_ net488 _3485_ VGND VGND VPWR VPWR _3491_ sky130_fd_sc_hd__nand2_1
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6263__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8020__B1 net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout433_A net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6836_ _2463_ _2464_ _2457_ VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__a21o_1
XANTENNA__4999__A net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6767_ _2394_ _2395_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_118_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8506_ _4077_ _4078_ VGND VGND VPWR VPWR _4079_ sky130_fd_sc_hd__or2_1
XANTENNA_fanout221_X net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5718_ _1346_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__and2b_1
X_9486_ clknet_leaf_26_clk net801 _0396_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
X_6698_ _2269_ _2322_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__nand3_1
XFILLER_40_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8437_ _4009_ VGND VGND VPWR VPWR _4010_ sky130_fd_sc_hd__inv_2
X_5649_ _1269_ _1270_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__nor3_2
XANTENNA__5607__B net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8368_ net122 _3940_ _3938_ net119 VGND VGND VPWR VPWR _3941_ sky130_fd_sc_hd__a211o_1
Xhold261 add_res\[29\] VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold250 _0006_ VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd3_1
X_7319_ _2948_ _2947_ VGND VGND VPWR VPWR _2949_ sky130_fd_sc_hd__and2b_1
XFILLER_2_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8299_ net127 _3871_ VGND VGND VPWR VPWR _3872_ sky130_fd_sc_hd__nand2_1
Xhold283 multiplier_inst.man_final_r\[11\] VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold294 multiplier_inst.man_final_r\[10\] VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlygate4sd3_1
Xhold272 _0027_ VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_129_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5061__C net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5860__A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6454__A net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5376__A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5376__B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8562__A1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__9273__Q adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4887__B1 net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5533__A net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4794__D net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4639__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6348__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput7 i_a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_77_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8250__B1 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4951_ _0579_ _0580_ net222 net429 VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_35_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7670_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR _3296_
+ sky130_fd_sc_hd__nand2b_1
X_4882_ net251 net392 net398 net245 VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a22oi_1
XANTENNA__7747__X _3365_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6621_ _2046_ _2117_ _2119_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__and3_1
XFILLER_32_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9340_ clknet_leaf_4_clk net736 _0250_ VGND VGND VPWR VPWR adder_inst.man_b_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6552_ _2176_ _2177_ _2181_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__nand3_2
X_5503_ _1116_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nor2_2
X_9271_ clknet_leaf_24_clk adder_inst.sum_raw\[8\] _0181_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[8\]
+ sky130_fd_sc_hd__dfrtp_4
X_6483_ _2111_ _2036_ _2110_ net568 VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__a211o_1
XFILLER_133_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5434_ _0984_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__nor2_1
X_8222_ _3719_ net133 _3793_ net139 VGND VGND VPWR VPWR _3795_ sky130_fd_sc_hd__o211a_1
XFILLER_133_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8153_ net139 _3721_ _3724_ _3726_ net125 VGND VGND VPWR VPWR _3727_ sky130_fd_sc_hd__o221a_1
XANTENNA__8738__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5365_ _0992_ _0993_ _0991_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a21bo_1
XANTENNA__8608__A2 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7104_ _2732_ _2733_ VGND VGND VPWR VPWR _2734_ sky130_fd_sc_hd__and2_1
X_8084_ _3657_ VGND VGND VPWR VPWR _3658_ sky130_fd_sc_hd__inv_2
X_5296_ net255 net406 _0924_ _0922_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a31o_1
XFILLER_113_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7035_ net206 net213 net463 net469 VGND VGND VPWR VPWR _2665_ sky130_fd_sc_hd__and4_1
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout383_A net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout269_X net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8986_ net512 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout171_X net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7937_ net483 adder_inst.sum_raw_r\[9\] adder_inst.sum_raw_r\[8\] net171 _3534_ VGND
+ VGND VPWR VPWR _3535_ sky130_fd_sc_hd__a221o_1
XFILLER_83_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7868_ _3388_ _3406_ VGND VGND VPWR VPWR _3474_ sky130_fd_sc_hd__nand2b_1
XFILLER_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout436_X net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6819_ _2433_ _2439_ _2438_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__a21oi_1
X_7799_ net192 net499 VGND VGND VPWR VPWR _3405_ sky130_fd_sc_hd__nand2_1
XFILLER_51_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9469_ clknet_leaf_15_clk _0088_ _0379_ VGND VGND VPWR VPWR mul_res\[24\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__7392__X _3022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_111_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5530__B2 net555 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5530__A1 net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7979__S net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5294__B1 net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_109_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5597__A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5597__B2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7338__A2 net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5247__B net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5150_ _0463_ _0778_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nand3_1
XFILLER_69_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5081_ net207 net217 net410 net417 VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__and4_1
XFILLER_110_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8840_ _3244_ _3253_ _3257_ _3260_ VGND VGND VPWR VPWR _4329_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_84_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8771_ _1975_ _3164_ VGND VGND VPWR VPWR _4278_ sky130_fd_sc_hd__xor2_1
XANTENNA__5588__A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5588__B2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5983_ _1495_ _1499_ _1494_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__a21oi_1
X_7722_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR _3345_
+ sky130_fd_sc_hd__nand2_1
XFILLER_80_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4934_ _0561_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__and2b_1
XANTENNA__6822__A net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7716__A1_N net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7653_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] net663 VGND VGND VPWR VPWR
+ _3281_ sky130_fd_sc_hd__and3_1
X_4865_ net367 net373 net281 net287 VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__and4_1
XANTENNA_fanout229_A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4796_ _0424_ _0425_ net223 net392 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and4bb_1
X_7584_ _0977_ _3207_ _1152_ VGND VGND VPWR VPWR _3214_ sky130_fd_sc_hd__a21o_1
X_6604_ net273 adder_inst.man_a_r\[0\] _2161_ _2162_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_119_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9323_ clknet_leaf_31_clk net725 _0233_ VGND VGND VPWR VPWR adder_inst.man_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_2
XANTENNA__5760__A1 net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6535_ _2086_ _2159_ _2164_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__or3_1
XFILLER_20_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9254_ clknet_leaf_8_clk net49 _0164_ VGND VGND VPWR VPWR adder_inst.exp_b\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_137_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7653__A adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8205_ net163 _3777_ _3778_ VGND VGND VPWR VPWR _3779_ sky130_fd_sc_hd__a21o_1
X_6466_ _2018_ _2019_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__xnor2_1
X_9185_ net547 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__inv_2
X_5417_ _0994_ _1044_ _1045_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a21oi_1
X_6397_ _2010_ _2009_ _2024_ _2025_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__or4bb_4
XFILLER_114_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8136_ _3699_ _3680_ _3693_ net168 VGND VGND VPWR VPWR _3710_ sky130_fd_sc_hd__and4_1
X_5348_ _0453_ _0454_ _0444_ _0447_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__a211o_1
X_8067_ _3642_ _3645_ _3643_ _3644_ VGND VGND VPWR VPWR _3646_ sky130_fd_sc_hd__and4bb_1
XFILLER_101_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout386_X net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5279_ _0819_ _0821_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__xnor2_1
X_7018_ _2645_ _2646_ _2647_ VGND VGND VPWR VPWR _2648_ sky130_fd_sc_hd__nand3b_1
XFILLER_47_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7017__A1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7017__B2 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7568__A2 _3197_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8969_ net542 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__inv_2
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6240__A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9465__D _0084_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input61_A i_b[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6059__A2 net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8333__S net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_66_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6642__A net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4650_ _4414_ _4420_ VGND VGND VPWR VPWR _4421_ sky130_fd_sc_hd__and2_1
XFILLER_14_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput21 i_a[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
XANTENNA__7744__Y _3363_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput10 i_a[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_30_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput54 i_b[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
X_4581_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] _4351_ VGND VGND VPWR VPWR
+ _4352_ sky130_fd_sc_hd__o21ai_1
Xinput43 i_b[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput32 i_a[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
X_6320_ net255 net479 _1948_ _1946_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__a31o_1
Xinput65 i_vld VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6251_ _1864_ _1865_ _1879_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__or3_4
XANTENNA__6298__A2 net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6089__A net389 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5202_ _0829_ _0830_ _0824_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a21bo_1
X_6182_ net395 net402 net332 net336 VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__and4_1
XFILLER_130_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5133_ _0743_ _0755_ _0759_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a21oi_1
XFILLER_96_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5064_ net239 net387 _0691_ _0692_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a22o_1
XFILLER_38_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8823_ _3213_ _4317_ _3218_ VGND VGND VPWR VPWR _4319_ sky130_fd_sc_hd__o21a_1
XANTENNA_fanout179_A net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8751__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8754_ multiplier_inst.is_nan_r _4271_ net199 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_121_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5966_ net210 net214 net469 net475 VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__and4_1
X_7705_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] _3328_ VGND VGND VPWR VPWR
+ _3329_ sky130_fd_sc_hd__a21oi_1
X_8685_ _4238_ _4237_ net107 VGND VGND VPWR VPWR _4239_ sky130_fd_sc_hd__mux2_4
X_4917_ net222 net422 _0544_ _0543_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a31o_1
XANTENNA__6271__B net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_23_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5897_ _1523_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__xnor2_1
XFILLER_138_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout513_A net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4848_ net374 net274 VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nand2_1
X_7636_ _3249_ _3264_ net111 VGND VGND VPWR VPWR _3266_ sky130_fd_sc_hd__mux2_1
XANTENNA__5168__A net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9306_ clknet_leaf_4_clk net726 _0216_ VGND VGND VPWR VPWR adder_inst.man_a_r\[18\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_120_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4779_ _4547_ _4549_ VGND VGND VPWR VPWR _4550_ sky130_fd_sc_hd__and2b_1
X_7567_ _2888_ _3196_ VGND VGND VPWR VPWR _3197_ sky130_fd_sc_hd__xnor2_2
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4800__A net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout301_X net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7498_ _3118_ _3121_ _3117_ VGND VGND VPWR VPWR _3128_ sky130_fd_sc_hd__a21bo_1
X_6518_ _2146_ _2147_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__nand2b_1
XFILLER_107_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9237_ clknet_leaf_0_clk net62 _0147_ VGND VGND VPWR VPWR adder_inst.i_b\[7\] sky130_fd_sc_hd__dfrtp_1
X_6449_ _1993_ _1994_ _2005_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__a21oi_1
X_9168_ net528 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__inv_2
XANTENNA__7830__B net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8119_ _3685_ _3686_ _3691_ _3692_ VGND VGND VPWR VPWR _3693_ sky130_fd_sc_hd__nor4_2
XFILLER_102_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9099_ net524 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__inv_2
XANTENNA__5249__B1 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6997__B1 net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5350__B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7829__Y _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5806__A net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4710__A net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6637__A net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6356__B net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5820_ _1374_ _1382_ _1381_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__a21o_1
XFILLER_62_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4604__B net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5751_ _1375_ _1379_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__and3_1
XFILLER_22_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8470_ _4042_ VGND VGND VPWR VPWR _4043_ sky130_fd_sc_hd__inv_2
X_4702_ _4458_ _4459_ _4461_ _4468_ VGND VGND VPWR VPWR _4473_ sky130_fd_sc_hd__o31a_1
X_7421_ _3049_ _3050_ VGND VGND VPWR VPWR _3051_ sky130_fd_sc_hd__xnor2_1
X_5682_ _1310_ _1311_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__nor2_1
X_4633_ _4402_ _4403_ VGND VGND VPWR VPWR _4404_ sky130_fd_sc_hd__nor2_1
XFILLER_128_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4564_ net483 VGND VGND VPWR VPWR _4336_ sky130_fd_sc_hd__inv_2
X_7352_ _2953_ _2977_ _2980_ VGND VGND VPWR VPWR _2982_ sky130_fd_sc_hd__nand3_1
XFILLER_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7283_ _2739_ _2746_ _2745_ VGND VGND VPWR VPWR _2913_ sky130_fd_sc_hd__a21bo_1
X_6303_ _1867_ _1869_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__xnor2_1
XFILLER_131_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9022_ net511 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__inv_2
X_6234_ _1844_ net152 _1863_ _1771_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__o211a_4
XFILLER_85_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6165_ _1271_ _1794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__or2_1
XANTENNA_fanout296_A net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5116_ _0659_ _0660_ _0536_ net594 VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__o211a_1
X_6096_ _1627_ _1724_ _1723_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a21o_1
X_5047_ net360 net368 net262 net268 VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__and4_1
XFILLER_111_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout463_A adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout251_X net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout349_X net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8806_ _3173_ _3183_ VGND VGND VPWR VPWR _4311_ sky130_fd_sc_hd__and2_1
X_6998_ _2626_ _2627_ VGND VGND VPWR VPWR _2628_ sky130_fd_sc_hd__and2b_1
XFILLER_25_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8737_ net754 net180 net176 VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__and3_1
XFILLER_53_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5949_ _1576_ _1577_ _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__nand3b_1
XFILLER_25_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8668_ _4057_ _4221_ _4220_ VGND VGND VPWR VPWR _4224_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_101_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone13 _3149_ _3148_ _4393_ VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__a21o_1
X_8599_ _4100_ _4163_ net105 VGND VGND VPWR VPWR _4164_ sky130_fd_sc_hd__mux2_4
X_7619_ _3248_ VGND VGND VPWR VPWR _3249_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_134_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4693__A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4693__B2 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input24_A i_a[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7559__Y _3189_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9276__Q adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5945__A1 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5255__B net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7870__A1 net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7970_ adder_inst.sum_raw_r\[9\] net495 _3561_ _3562_ VGND VGND VPWR VPWR _3563_
+ sky130_fd_sc_hd__a22o_1
XFILLER_82_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5633__B1 net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6921_ _2412_ _2481_ _2549_ _2550_ VGND VGND VPWR VPWR _2551_ sky130_fd_sc_hd__o211a_1
X_6852_ _2409_ _2413_ _2446_ VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__nand3_2
XFILLER_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6533__C net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5803_ _1430_ _1431_ _1415_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__a21oi_1
X_8522_ _3779_ _4091_ _3781_ _4024_ VGND VGND VPWR VPWR _4095_ sky130_fd_sc_hd__a31oi_4
XFILLER_50_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6783_ _2407_ _2408_ _2402_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__a21o_1
XFILLER_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5734_ _1361_ _1362_ _1357_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__a21o_1
X_8453_ _3732_ _3791_ VGND VGND VPWR VPWR _4026_ sky130_fd_sc_hd__nor2_1
X_5665_ _1289_ _1293_ _1294_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__nand3_1
XFILLER_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8384_ _3956_ VGND VGND VPWR VPWR _3957_ sky130_fd_sc_hd__inv_2
X_7404_ _3033_ _1152_ _3031_ _1136_ VGND VGND VPWR VPWR _3034_ sky130_fd_sc_hd__or4_4
X_4616_ _4385_ _4386_ VGND VGND VPWR VPWR _4387_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7335_ _2911_ _2935_ VGND VGND VPWR VPWR _2965_ sky130_fd_sc_hd__xor2_1
X_5596_ net243 net248 net445 net450 VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__nand4_1
XFILLER_132_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7266_ _2834_ _2895_ VGND VGND VPWR VPWR _2896_ sky130_fd_sc_hd__nand2_1
X_9005_ net521 VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
XANTENNA__5452__Y _1082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7197_ _2823_ _2826_ VGND VGND VPWR VPWR _2827_ sky130_fd_sc_hd__nand2_1
X_6217_ net278 net285 net445 net450 VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__and4_1
XANTENNA_fanout299_X net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6148_ _1767_ _1769_ _1777_ _1697_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__o211a_1
XFILLER_58_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout466_X net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6079_ _1276_ _1699_ _1701_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__or3_1
XFILLER_73_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4666__A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4666__B2 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_14_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5450_ _1027_ _1037_ _1077_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__o31a_4
XFILLER_9_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7540__B1 _3022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5381_ _1004_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__xnor2_1
XANTENNA_clkbuf_leaf_29_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7120_ _2747_ _2748_ _2749_ VGND VGND VPWR VPWR _2750_ sky130_fd_sc_hd__and3_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout208 net211 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_99_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout219 net221 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_4
X_7051_ _2578_ _2579_ VGND VGND VPWR VPWR _2681_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6097__A net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6002_ net408 net308 VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__nand2_1
XFILLER_95_751 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7953_ adder_inst.sum_raw_r\[6\] _4341_ net182 adder_inst.sum_raw_r\[4\] net192 VGND
+ VGND VPWR VPWR _3548_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_38_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5082__B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5082__A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6904_ _2532_ _2533_ VGND VGND VPWR VPWR _2534_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_38_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7884_ adder_inst.sum_raw_r\[21\] _3386_ _3415_ _3489_ net489 VGND VGND VPWR VPWR
+ _3490_ sky130_fd_sc_hd__a311o_1
XANTENNA_fanout161_A _3666_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout259_A net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6018__A1_N net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6835_ _2457_ _2464_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__and2b_1
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout426_A net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6766_ _2394_ _2395_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_118_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8505_ net352 net165 _3917_ _3979_ VGND VGND VPWR VPWR _4078_ sky130_fd_sc_hd__a22o_1
XANTENNA__4593__B1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5717_ _1344_ _1345_ _1340_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__a21o_1
XFILLER_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9485_ clknet_leaf_28_clk net779 _0395_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
X_6697_ _2324_ _2325_ _2323_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__o21bai_1
XFILLER_40_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_131_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8436_ _3997_ _4007_ VGND VGND VPWR VPWR _4009_ sky130_fd_sc_hd__or2_1
XANTENNA_fanout214_X net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5648_ _1276_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__or2_1
XFILLER_40_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8487__A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8367_ net126 _3858_ _3939_ VGND VGND VPWR VPWR _3940_ sky130_fd_sc_hd__a21oi_1
X_5579_ _1200_ _1207_ _1208_ _1193_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__o211ai_4
Xhold262 _0021_ VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlygate4sd3_1
X_8298_ net141 _3784_ _3870_ VGND VGND VPWR VPWR _3871_ sky130_fd_sc_hd__o21a_1
Xhold251 add_res\[9\] VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlygate4sd3_1
X_7318_ _2892_ _2946_ VGND VGND VPWR VPWR _2948_ sky130_fd_sc_hd__xnor2_2
Xhold240 add_res\[2\] VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__5904__A net641 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold284 adder_inst.is_nan_b_r VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold295 multiplier_inst.exp_final_r\[5\] VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 add_res\[24\] VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7249_ _2876_ _2877_ VGND VGND VPWR VPWR _2879_ sky130_fd_sc_hd__xor2_1
XFILLER_104_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_129_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5061__D net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7598__B1 _1035_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6454__B net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8011__A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5376__A2 net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8397__A net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_58_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4887__A1 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4887__B2 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5533__B net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4639__B2 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 i_a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_92_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6645__A net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5064__A1 net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_35_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4950_ net235 net416 net422 net229 VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a22oi_1
XFILLER_64_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8002__A1 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4881_ net240 net403 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
XANTENNA__8553__A2 _4115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6620_ _2249_ net610 _2192_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__o21bai_4
X_6551_ _2091_ _2178_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__xnor2_1
X_5502_ _1129_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nor2_2
XFILLER_20_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9270_ clknet_leaf_24_clk adder_inst.sum_raw\[7\] _0180_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
X_6482_ _2110_ net568 _2111_ _2036_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__o211ai_4
X_5433_ _0724_ _0982_ _0983_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__nor3_1
XFILLER_106_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8221_ net655 _3719_ _3793_ VGND VGND VPWR VPWR _3794_ sky130_fd_sc_hd__o21a_1
X_5364_ _0991_ _0992_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nand3_1
X_8152_ net134 _3725_ net137 VGND VGND VPWR VPWR _3726_ sky130_fd_sc_hd__a21o_1
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7103_ _2729_ _2731_ _2623_ _2630_ VGND VGND VPWR VPWR _2733_ sky130_fd_sc_hd__o211ai_1
X_8083_ adder_inst.exp_a_r\[0\] _4332_ _4348_ _4349_ VGND VGND VPWR VPWR _3657_ sky130_fd_sc_hd__a31oi_2
XFILLER_113_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5295_ _0922_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__and2b_1
X_7034_ _2661_ _2662_ VGND VGND VPWR VPWR _2664_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8985_ net517 VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_124_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout164_X net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7936_ adder_inst.sum_raw_r\[5\] _3504_ _3532_ _3533_ VGND VGND VPWR VPWR _3534_
+ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_67_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7867_ net191 _3413_ VGND VGND VPWR VPWR _3473_ sky130_fd_sc_hd__nand2_2
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4803__A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6004__B1 net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6818_ _2442_ _2443_ _2437_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout429_X net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7798_ net498 _4341_ VGND VGND VPWR VPWR _3404_ sky130_fd_sc_hd__nor2_2
XFILLER_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6749_ _2376_ _2377_ _2378_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__or3_1
XFILLER_137_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9468_ clknet_leaf_16_clk _0087_ _0378_ VGND VGND VPWR VPWR mul_res\[23\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8419_ net156 _3991_ VGND VGND VPWR VPWR _3992_ sky130_fd_sc_hd__or2_1
XFILLER_136_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9399_ clknet_leaf_9_clk net748 _0309_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_124_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5530__A2 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8480__A1 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_53_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5294__B2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5294__A1 net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5597__A2 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7567__Y _3197_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5247__C net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_40_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_94_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5080_ _0707_ _0708_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__xnor2_1
XFILLER_123_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8223__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8770_ _1972_ _4276_ VGND VGND VPWR VPWR _4277_ sky130_fd_sc_hd__nor2_1
XFILLER_18_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5588__A2 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5982_ _1609_ _1610_ _1472_ _1507_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__a211oi_1
X_7721_ _3341_ _3343_ VGND VGND VPWR VPWR _3344_ sky130_fd_sc_hd__or2_2
XANTENNA__7982__B1 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4933_ net263 net392 net269 net386 VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a22o_1
XFILLER_52_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6822__B net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7652_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] net663 VGND VGND VPWR VPWR
+ _3280_ sky130_fd_sc_hd__a21oi_1
XANTENNA__4623__A net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4864_ _0477_ _0479_ _0478_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__o21ai_1
XFILLER_32_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4795_ net234 net380 net387 net228 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a22oi_1
X_7583_ _3209_ _3212_ net112 VGND VGND VPWR VPWR _3213_ sky130_fd_sc_hd__mux2_2
X_6603_ _2231_ _2232_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__xor2_1
XFILLER_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9322_ clknet_leaf_31_clk net734 _0232_ VGND VGND VPWR VPWR adder_inst.man_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_2
XANTENNA__5760__A2 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6534_ _2161_ _2163_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__nor2_1
X_9253_ clknet_leaf_8_clk net48 _0163_ VGND VGND VPWR VPWR adder_inst.exp_b\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_119_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6465_ _2015_ _2082_ _2087_ _2094_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__o31ai_1
XFILLER_137_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5416_ _0994_ _1044_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__and3_1
XFILLER_106_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8204_ net340 net162 VGND VGND VPWR VPWR _3778_ sky130_fd_sc_hd__nor2_1
X_9184_ net547 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__inv_2
X_6396_ _2010_ _2009_ _2024_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__and4bb_1
XANTENNA_fanout493_A net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8135_ net151 net149 net148 _3707_ VGND VGND VPWR VPWR _3709_ sky130_fd_sc_hd__or4_4
XFILLER_102_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5347_ _0870_ _0976_ _0871_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a21boi_1
XANTENNA__4720__B1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8066_ net486 adder_inst.exp_larger_r\[0\] net195 _3387_ VGND VGND VPWR VPWR _3645_
+ sky130_fd_sc_hd__and4_1
XFILLER_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5278_ _0800_ _0901_ _0906_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a21o_1
XFILLER_102_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7017_ net248 net427 net434 net243 VGND VGND VPWR VPWR _2647_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_126_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8214__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout281_X net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout379_X net379 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7017__A2 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8968_ net540 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__inv_2
XFILLER_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7919_ _4337_ _3504_ VGND VGND VPWR VPWR _3519_ sky130_fd_sc_hd__nor2_1
XFILLER_71_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8899_ net512 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__inv_2
XFILLER_12_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_137_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6700__A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6700__B2 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input54_A i_b[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4711__B1 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout380 net382 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__buf_6
XFILLER_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout391 net554 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__buf_12
XFILLER_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__9279__Q adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4778__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6642__B net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5539__A net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput22 i_a[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 i_a[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_4580_ _4348_ _4350_ VGND VGND VPWR VPWR _4351_ sky130_fd_sc_hd__nand2_1
Xinput33 i_b[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput44 i_b[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput55 i_b[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput66 opcode VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
XANTENNA__9391__D adder_inst.exp_larger\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4950__B1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8141__A0 net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6250_ _1864_ _1865_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__nor3_1
XANTENNA__6089__B net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5201_ _0824_ _0829_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nand3_1
X_6181_ _1718_ _1810_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__nand2_4
XFILLER_130_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5132_ _0558_ _0559_ _0576_ _0592_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__o211a_1
XFILLER_57_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6455__B1 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5063_ net239 net387 _0691_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nand4_1
XFILLER_123_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8822_ net104 _4318_ VGND VGND VPWR VPWR multiplier_inst.man_final\[10\] sky130_fd_sc_hd__nor2_1
XFILLER_80_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8753_ multiplier_inst.is_inf_r multiplier_inst.man_final_r\[22\] net178 VGND VGND
+ VPWR VPWR _4271_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_121_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5965_ _1592_ _1593_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__xnor2_1
X_7704_ _3326_ _3327_ VGND VGND VPWR VPWR _3328_ sky130_fd_sc_hd__nand2b_1
X_8684_ _4039_ _4108_ _4041_ VGND VGND VPWR VPWR _4238_ sky130_fd_sc_hd__o21a_1
X_4916_ net222 net422 VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout339_A net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5896_ _1524_ _1525_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout241_A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4847_ net360 net369 net280 net287 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and4_1
X_7635_ _3264_ _3158_ net586 VGND VGND VPWR VPWR _3265_ sky130_fd_sc_hd__mux2_1
XANTENNA__5168__B net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout506_A opcode_stage1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9305_ clknet_leaf_4_clk net701 _0215_ VGND VGND VPWR VPWR adder_inst.man_a_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_4778_ net356 net263 net268 net350 VGND VGND VPWR VPWR _4549_ sky130_fd_sc_hd__a22o_1
X_7566_ _2952_ _3186_ _2951_ VGND VGND VPWR VPWR _3196_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4800__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7497_ _0457_ _3075_ _3073_ VGND VGND VPWR VPWR _3127_ sky130_fd_sc_hd__o21ai_1
X_6517_ _2067_ _2069_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9236_ clknet_leaf_0_clk net61 _0146_ VGND VGND VPWR VPWR adder_inst.i_b\[6\] sky130_fd_sc_hd__dfrtp_1
X_6448_ _2064_ _2065_ _2076_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__nand3_1
XANTENNA__5615__C net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9167_ net526 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__inv_2
X_6379_ _1993_ _2007_ net566 _2008_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__a211oi_4
X_8118_ _3690_ _3689_ _3328_ VGND VGND VPWR VPWR _3692_ sky130_fd_sc_hd__and3_1
XFILLER_115_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_740 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9098_ net525 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__inv_2
XANTENNA__5249__A1 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5249__B2 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_50_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8049_ adder_inst.is_zero_r _3493_ VGND VGND VPWR VPWR _3630_ sky130_fd_sc_hd__nor2_1
XFILLER_102_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6997__B2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6997__A1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7839__A net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5094__A net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4710__B net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5806__B net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8674__A1 net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5822__A net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7937__B1 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5750_ _1377_ _1378_ _1376_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__a21bo_1
XFILLER_22_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4701_ _4471_ _4443_ VGND VGND VPWR VPWR _4472_ sky130_fd_sc_hd__and2b_1
XANTENNA__4604__C net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5681_ net555 net315 net321 net383 VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__a22oi_1
XFILLER_30_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4632_ net356 net244 net250 net350 VGND VGND VPWR VPWR _4403_ sky130_fd_sc_hd__a22oi_1
X_7420_ _4518_ _4520_ _4517_ VGND VGND VPWR VPWR _3050_ sky130_fd_sc_hd__o21ba_1
X_4563_ adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR _4335_ sky130_fd_sc_hd__inv_2
X_7351_ _2977_ _2980_ _2953_ VGND VGND VPWR VPWR _2981_ sky130_fd_sc_hd__a21oi_1
X_7282_ _2840_ _2842_ _2841_ VGND VGND VPWR VPWR _2912_ sky130_fd_sc_hd__a21o_1
X_6302_ _1926_ _1930_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_92_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9021_ net511 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__inv_2
X_6233_ _1751_ _1753_ _1769_ net640 VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__o22ai_2
XANTENNA__8746__C net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6828__A net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6164_ _1780_ _1792_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__xnor2_1
XFILLER_111_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5115_ _0743_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__nor2_1
XFILLER_85_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5451__B _1080_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6095_ _1627_ _1723_ _1724_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__nand3_1
X_5046_ net374 net256 VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__nand2_1
XFILLER_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout289_A net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout456_A net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9296__D adder_inst.i_a\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8805_ _3173_ _3183_ VGND VGND VPWR VPWR _4310_ sky130_fd_sc_hd__nor2_1
X_6997_ net265 net406 net412 net261 VGND VGND VPWR VPWR _2627_ sky130_fd_sc_hd__a22o_1
XFILLER_25_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout244_X net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8736_ net786 net180 net176 VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and3_1
X_5948_ net248 net434 net440 net242 VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__a22o_1
XFILLER_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4611__C1 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8667_ _4057_ _4223_ VGND VGND VPWR VPWR adder_inst.sum_raw\[16\] sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_101_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5879_ _1472_ _1473_ _1505_ _1506_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__o22ai_1
XFILLER_126_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout411_X net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8598_ _3927_ _4149_ _4162_ VGND VGND VPWR VPWR _4163_ sky130_fd_sc_hd__o21a_1
X_7618_ _3130_ _3147_ VGND VGND VPWR VPWR _3248_ sky130_fd_sc_hd__xnor2_1
XFILLER_135_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_134_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4914__B1 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclone69 net111 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__clkbuf_1
X_7549_ _3019_ _3170_ _3018_ VGND VGND VPWR VPWR _3179_ sky130_fd_sc_hd__o21ba_1
XFILLER_119_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9219_ clknet_leaf_4_clk net14 _0129_ VGND VGND VPWR VPWR adder_inst.i_a\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_107_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5642__A net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4693__A2 net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input17_A i_a[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5945__A2 net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9292__Q adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5255__C net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5633__A1 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5633__B2 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5485__A_N _1113_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6383__A net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6920_ _2412_ _2482_ VGND VGND VPWR VPWR _2550_ sky130_fd_sc_hd__or2_1
X_6851_ _2480_ _2413_ _2409_ VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand3b_2
XANTENNA__6533__D net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5802_ _1415_ _1430_ _1431_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__and3_4
X_8521_ _3976_ _3985_ _3984_ VGND VGND VPWR VPWR _4094_ sky130_fd_sc_hd__o21a_1
X_6782_ _2371_ _2410_ VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_33_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5733_ _1357_ _1361_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__nand3_1
XFILLER_136_607 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8452_ _4020_ _4021_ _4022_ _4023_ VGND VGND VPWR VPWR _4025_ sky130_fd_sc_hd__o211ai_1
X_5664_ _1291_ _1292_ _1290_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__o21ai_1
XFILLER_117_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8383_ _3954_ _3955_ VGND VGND VPWR VPWR _3956_ sky130_fd_sc_hd__nand2b_2
X_7403_ _0976_ _3032_ VGND VGND VPWR VPWR _3033_ sky130_fd_sc_hd__or2_4
X_4615_ _4363_ _4365_ VGND VGND VPWR VPWR _4386_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_13_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5595_ net237 net455 VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__nand2_1
X_7334_ _2957_ _2963_ _2956_ VGND VGND VPWR VPWR _2964_ sky130_fd_sc_hd__a21oi_1
XFILLER_132_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap152 _1862_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_6
Xmax_cap130 _1414_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_6
XFILLER_131_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7265_ _2819_ _2820_ _2832_ _2833_ VGND VGND VPWR VPWR _2895_ sky130_fd_sc_hd__a22o_1
X_9004_ net521 VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__inv_2
XFILLER_131_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7196_ _2823_ _2824_ _2825_ VGND VGND VPWR VPWR _2826_ sky130_fd_sc_hd__nand3_1
X_6216_ _1755_ _1757_ _1756_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__o21ai_1
XANTENNA_input9_A i_a[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6147_ _1694_ _1695_ _1696_ _1273_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__a22o_1
XFILLER_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6078_ _1699_ _1701_ _1276_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout361_X net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5029_ _0623_ _0626_ _0656_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__a211oi_2
XANTENNA_fanout459_X net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8719_ _4087_ _4268_ VGND VGND VPWR VPWR adder_inst.sum_raw\[23\] sky130_fd_sc_hd__xor2_1
XFILLER_110_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5312__B1 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4666__A2 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5380_ _1004_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__nand2_1
XFILLER_114_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5551__B1 net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout209 net210 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_2
X_7050_ _2582_ _2678_ VGND VGND VPWR VPWR _2680_ sky130_fd_sc_hd__xnor2_1
XFILLER_113_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6097__B net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6001_ _1288_ _1629_ _1628_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_105_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8253__C1 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7952_ net114 _3547_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and2_1
XFILLER_54_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5082__A2 net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8005__C1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6903_ _2500_ _2506_ VGND VGND VPWR VPWR _2533_ sky130_fd_sc_hd__xor2_1
X_7883_ net493 _3487_ _3488_ _4342_ VGND VGND VPWR VPWR _3489_ sky130_fd_sc_hd__o211a_1
XFILLER_63_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout154_A net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6834_ _2422_ _2451_ _2456_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_114_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6765_ net293 net299 net470 net477 VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_118_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8504_ net211 net159 _3917_ _3981_ VGND VGND VPWR VPWR _4077_ sky130_fd_sc_hd__a22oi_2
X_9484_ clknet_leaf_28_clk net813 _0394_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
XFILLER_50_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4593__B2 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4593__A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5716_ _1340_ _1344_ _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__and3_1
XFILLER_10_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout321_A net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8435_ _4007_ VGND VGND VPWR VPWR _4008_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout419_A net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6696_ _2323_ _2324_ _2325_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_131_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5647_ _1272_ _1275_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout207_X net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8366_ net143 _3865_ _3866_ VGND VGND VPWR VPWR _3939_ sky130_fd_sc_hd__and3_1
X_5578_ _1168_ _1174_ _1192_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__nand3_2
XFILLER_117_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8297_ net136 _3764_ _3786_ net138 VGND VGND VPWR VPWR _3870_ sky130_fd_sc_hd__a211o_1
Xhold252 _0031_ VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlygate4sd3_1
Xhold230 _0030_ VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
Xhold241 _0022_ VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
X_7317_ _2942_ _2944_ VGND VGND VPWR VPWR _2947_ sky130_fd_sc_hd__nand2_1
XANTENNA__5904__B net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold296 adder_inst.sign_sum_r VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold285 multiplier_inst.exp_final_r\[6\] VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 _0016_ VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7248_ _2877_ _2876_ VGND VGND VPWR VPWR _2878_ sky130_fd_sc_hd__and2b_1
Xhold263 add_res\[7\] VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_123_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_129_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7179_ _2807_ _2808_ VGND VGND VPWR VPWR _2809_ sky130_fd_sc_hd__and2b_1
XANTENNA__5920__A net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_129_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7598__A1 _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6454__C net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_2_3__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4887__A2 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4639__A2 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_71_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5830__A net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7589__A1 _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 i_a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XANTENNA__5064__A2 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4880_ net245 net251 net392 net398 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and4_1
XFILLER_51_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6550_ _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__inv_2
X_5501_ _1121_ _1125_ _1130_ _1129_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__a211oi_4
XFILLER_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6481_ _2029_ _2035_ _2034_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__a21o_1
X_5432_ _1042_ _1043_ _1060_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a21o_1
XFILLER_118_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8220_ net168 _3680_ net150 _3699_ _3716_ VGND VGND VPWR VPWR _3793_ sky130_fd_sc_hd__a41o_1
X_5363_ _4557_ _0990_ _0989_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__a21o_1
X_8151_ net340 net482 net154 VGND VGND VPWR VPWR _3725_ sky130_fd_sc_hd__mux2_1
X_7102_ _2623_ _2630_ _2729_ _2731_ VGND VGND VPWR VPWR _2732_ sky130_fd_sc_hd__a211o_1
X_8082_ net644 _4335_ _3653_ _3654_ _3655_ VGND VGND VPWR VPWR _3656_ sky130_fd_sc_hd__o221ai_4
XFILLER_99_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5294_ net270 net397 net400 net261 VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a22o_1
XFILLER_101_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7033_ _2662_ _2661_ VGND VGND VPWR VPWR _2663_ sky130_fd_sc_hd__and2b_1
XANTENNA__7029__B1 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_616 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout271_A net275 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout369_A net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8984_ net512 VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_124_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7935_ adder_inst.sum_raw_r\[7\] net189 net169 adder_inst.sum_raw_r\[6\] net184 VGND
+ VGND VPWR VPWR _3533_ sky130_fd_sc_hd__o221a_1
XFILLER_24_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout536_A net539 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7866_ net492 _3414_ VGND VGND VPWR VPWR _3472_ sky130_fd_sc_hd__nor2_1
XFILLER_23_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6817_ _2415_ _2445_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__xnor2_2
XANTENNA__6004__B2 net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7797_ _3402_ _3400_ net502 VGND VGND VPWR VPWR _3403_ sky130_fd_sc_hd__mux2_1
XANTENNA__4803__B net404 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout324_X net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5763__B1 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6748_ net448 net328 net334 net442 VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__a22oi_2
X_9467_ clknet_leaf_16_clk _0086_ _0377_ VGND VGND VPWR VPWR mul_res\[22\] sky130_fd_sc_hd__dfrtp_1
X_6679_ _2261_ _2308_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__nor2_1
XFILLER_136_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9398_ clknet_leaf_7_clk net751 _0308_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
X_8418_ net122 _3790_ _3990_ net120 VGND VGND VPWR VPWR _3991_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_21_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8349_ net446 _3342_ net649 VGND VGND VPWR VPWR _3922_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_111_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout540 net542 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__buf_4
XFILLER_116_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6746__A net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_leaf_13_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5294__A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8172__S net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_leaf_28_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6941__A_N _2570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5247__D net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8347__S net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6656__A net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8759__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7982__A1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5981_ _1472_ _1507_ _1609_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__o211a_1
X_7720_ adder_inst.exp_b_r\[7\] adder_inst.exp_a_r\[7\] VGND VGND VPWR VPWR _3343_
+ sky130_fd_sc_hd__and2b_1
XANTENNA__7982__B2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4932_ net258 net397 VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nand2_1
XFILLER_18_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7651_ adder_inst.exp_a_r\[2\] adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR _3279_
+ sky130_fd_sc_hd__xor2_4
XANTENNA__4623__B net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4863_ _0489_ _0490_ _0471_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a21o_1
X_6602_ _2090_ _2166_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4794_ net228 net234 net381 net387 VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_99_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7582_ _1146_ _3211_ VGND VGND VPWR VPWR _3212_ sky130_fd_sc_hd__xnor2_2
X_9321_ clknet_leaf_16_clk _0033_ _0231_ VGND VGND VPWR VPWR adder_inst.is_inf_r sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_99_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6533_ _2161_ _2162_ net273 net479 VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__and4bb_1
XFILLER_119_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9252_ clknet_leaf_4_clk net47 _0162_ VGND VGND VPWR VPWR adder_inst.i_b\[22\] sky130_fd_sc_hd__dfrtp_1
X_6464_ _2088_ _2089_ _2092_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__nand3_1
XANTENNA__5735__A net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5415_ _0689_ _0696_ _0695_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__a21bo_1
XFILLER_118_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8203_ net119 _3775_ _3730_ _3760_ VGND VGND VPWR VPWR _3777_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_133_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9183_ net546 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__inv_2
X_6395_ _2022_ _2023_ _2017_ _2020_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__a211o_1
X_8134_ net149 _3707_ _3699_ _3680_ VGND VGND VPWR VPWR _3708_ sky130_fd_sc_hd__and4bb_1
XFILLER_102_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5346_ _0873_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__nor2_1
XANTENNA__4720__A1 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4720__B2 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8065_ net485 net197 _3387_ net185 net195 VGND VGND VPWR VPWR _3644_ sky130_fd_sc_hd__a311o_1
XFILLER_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5277_ _0800_ _0901_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nand3_1
XANTENNA__6566__A net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7016_ net243 net248 net427 net434 VGND VGND VPWR VPWR _2646_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_126_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout274_X net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8967_ net540 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__inv_2
XFILLER_83_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7918_ adder_inst.sum_raw_r\[5\] net487 _3462_ adder_inst.sum_raw_r\[4\] _3394_ VGND
+ VGND VPWR VPWR _3518_ sky130_fd_sc_hd__a221o_1
XANTENNA_fanout441_X net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout539_X net539 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8898_ net517 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__inv_2
XFILLER_71_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7849_ net490 net191 _3453_ _3454_ VGND VGND VPWR VPWR _3455_ sky130_fd_sc_hd__or4_1
XFILLER_12_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6700__A2 net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4711__B2 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4711__A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input47_A i_b[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout370 adder_inst.man_a_r\[19\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__buf_8
Xfanout381 net382 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkbuf_2
Xfanout392 net394 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__buf_6
XFILLER_93_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4778__A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7964__B2 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7964__A1 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_26_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_45_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5539__B net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9295__Q adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7754__B _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput12 i_a[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
Xinput45 i_b[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput34 i_b[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
XANTENNA__4950__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput23 i_a[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput56 i_b[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
Xinput67 rst VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_2
XFILLER_116_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4950__B2 net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6938__X _2568_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5200_ _0571_ _0823_ _0822_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a21o_1
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6180_ _1808_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__and2_4
XFILLER_123_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5131_ _0743_ _0755_ _0759_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nand3_1
X_5062_ net375 net250 net381 net244 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a22o_1
XANTENNA__6455__B2 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6455__A1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7929__B adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8821_ _3213_ _4317_ VGND VGND VPWR VPWR _4318_ sky130_fd_sc_hd__xnor2_1
XANTENNA__7955__A1 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8752_ multiplier_inst.man_final_r\[21\] net179 net176 VGND VGND VPWR VPWR _0085_
+ sky130_fd_sc_hd__and3_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_17_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_7703_ adder_inst.exp_a_r\[6\] adder_inst.exp_b_r\[6\] VGND VGND VPWR VPWR _3327_
+ sky130_fd_sc_hd__nand2b_2
XTAP_TAPCELL_ROW_121_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5964_ _1593_ _1592_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__and2b_1
XFILLER_40_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8683_ _4041_ _4231_ _4039_ VGND VGND VPWR VPWR _4237_ sky130_fd_sc_hd__a21oi_1
X_4915_ _0543_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_23_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5895_ net367 net311 net319 net359 VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__a22oi_1
XANTENNA_fanout234_A net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4846_ _0473_ _0474_ _0472_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__o21ai_1
X_7634_ net117 _3144_ _3148_ _3263_ VGND VGND VPWR VPWR _3264_ sky130_fd_sc_hd__o211a_1
X_7565_ _4370_ net131 net562 _3187_ VGND VGND VPWR VPWR _3195_ sky130_fd_sc_hd__and4_1
X_9304_ clknet_leaf_5_clk net717 _0214_ VGND VGND VPWR VPWR adder_inst.man_a_r\[16\]
+ sky130_fd_sc_hd__dfrtp_2
X_4777_ net360 net256 VGND VGND VPWR VPWR _4548_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout401_A net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6516_ _2131_ _2133_ _2132_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__o21ba_1
XFILLER_134_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_738 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4800__C net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7496_ _3035_ _1158_ _3125_ _0458_ VGND VGND VPWR VPWR _3126_ sky130_fd_sc_hd__a211o_1
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9235_ clknet_leaf_0_clk net60 _0145_ VGND VGND VPWR VPWR adder_inst.i_b\[5\] sky130_fd_sc_hd__dfrtp_1
X_6447_ _2064_ _2065_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__and3_1
XANTENNA__5615__D net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9166_ net528 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__inv_2
X_6378_ _1908_ net564 _1920_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__a21oi_2
X_8117_ _3689_ net668 _3328_ VGND VGND VPWR VPWR _3691_ sky130_fd_sc_hd__a21oi_1
XFILLER_102_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5329_ _0917_ _0955_ _0956_ _0957_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__nand4_1
XANTENNA_fanout391_X net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9097_ net537 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout489_X net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5249__A2 net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8048_ _3628_ _3629_ net198 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__o21a_1
XFILLER_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6997__A2 net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_703 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8371__A1 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5375__A net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5094__B net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4710__C net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5822__B net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4719__A net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5541__C net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7937__B2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6940__Y _2570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7765__A adder_inst.is_zero_b_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4700_ _4454_ _4470_ VGND VGND VPWR VPWR _4471_ sky130_fd_sc_hd__xnor2_1
X_5680_ net383 net389 net315 net321 VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__and4_1
XFILLER_15_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4631_ net350 net356 net246 net252 VGND VGND VPWR VPWR _4402_ sky130_fd_sc_hd__and4_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4562_ net600 VGND VGND VPWR VPWR _4334_ sky130_fd_sc_hd__inv_2
X_7350_ _2979_ _2978_ VGND VGND VPWR VPWR _2980_ sky130_fd_sc_hd__nand2b_1
XFILLER_8_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7281_ _2896_ _2909_ VGND VGND VPWR VPWR _2911_ sky130_fd_sc_hd__xor2_1
X_6301_ _1930_ _1926_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__and2b_1
Xclkbuf_leaf_6_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
X_9020_ net513 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__inv_2
XFILLER_104_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6232_ _1844_ _1845_ _1860_ _1861_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__nor4_4
XANTENNA__6828__B net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4629__A net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6163_ _1780_ _1792_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__or2_1
XANTENNA__6428__A1 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5114_ _0685_ _0687_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6428__B2 net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6094_ _1624_ _1626_ _1625_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__o21ai_1
X_5045_ _0671_ _0672_ _0673_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__a21oi_1
XANTENNA_fanout184_A net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_0_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout351_A net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8804_ _3173_ _4309_ VGND VGND VPWR VPWR multiplier_inst.man_final\[1\] sky130_fd_sc_hd__and2_1
X_6996_ net261 net265 net406 net413 VGND VGND VPWR VPWR _2626_ sky130_fd_sc_hd__and4_1
XFILLER_26_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8735_ net793 net180 net176 VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__and3_1
XANTENNA__4611__B1 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5947_ net242 net248 net434 net440 VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__nand4_1
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8666_ _4217_ _4222_ net188 VGND VGND VPWR VPWR _4223_ sky130_fd_sc_hd__mux2_4
XFILLER_33_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7617_ _3119_ _3246_ VGND VGND VPWR VPWR _3247_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout237_X net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5878_ _1473_ _1472_ _1505_ _1506_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__or4_4
X_4829_ net349 net609 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__and2_1
X_8597_ _3909_ _3925_ _3910_ VGND VGND VPWR VPWR _4162_ sky130_fd_sc_hd__a21oi_1
Xclone37 net112 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__clkbuf_1
XANTENNA__5195__A net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout404_X net404 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4914__B2 net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4914__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7548_ _3153_ _3177_ VGND VGND VPWR VPWR _3178_ sky130_fd_sc_hd__nor2_1
X_7479_ _3108_ _3081_ VGND VGND VPWR VPWR _3109_ sky130_fd_sc_hd__and2b_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9218_ clknet_leaf_5_clk net13 _0128_ VGND VGND VPWR VPWR adder_inst.i_a\[20\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_116_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5642__B net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9149_ net541 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__inv_2
XFILLER_0_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8793__X _4300_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8592__A1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_63_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5255__D net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5633__A2 net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_89_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6383__B net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8032__B1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6850_ _2447_ _2479_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6781_ _2371_ _2410_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__nand2b_1
X_5801_ _1423_ _1424_ _1429_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__a21o_1
X_8520_ adder_inst.sum_raw\[0\] _3928_ _4090_ _4092_ VGND VGND VPWR VPWR _4093_ sky130_fd_sc_hd__or4b_1
X_5732_ _1359_ _1360_ _1358_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__a21o_1
XFILLER_15_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4631__B net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8451_ _4021_ _4020_ net678 _4023_ VGND VGND VPWR VPWR _4024_ sky130_fd_sc_hd__o211a_1
X_5663_ _1290_ _1291_ _1292_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__or3_4
XFILLER_31_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8382_ _3951_ _3953_ VGND VGND VPWR VPWR _3955_ sky130_fd_sc_hd__nand2_1
X_7402_ _0873_ _0975_ VGND VGND VPWR VPWR _3032_ sky130_fd_sc_hd__and2_1
X_4614_ _4383_ _4384_ VGND VGND VPWR VPWR _4385_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_13_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5594_ _1186_ _1188_ _1187_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__o21bai_1
X_7333_ _2958_ _2962_ VGND VGND VPWR VPWR _2963_ sky130_fd_sc_hd__xor2_2
XFILLER_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap153 _2474_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_1
XFILLER_132_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9003_ net522 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__inv_2
X_7264_ _2871_ _2893_ VGND VGND VPWR VPWR _2894_ sky130_fd_sc_hd__nand2_1
XFILLER_131_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7195_ _0923_ _0925_ VGND VGND VPWR VPWR _2825_ sky130_fd_sc_hd__xnor2_1
X_6215_ _1749_ _1843_ _1842_ _1829_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a211oi_4
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6146_ net552 _1773_ _1772_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__o21a_1
XFILLER_38_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout187_X net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6077_ net130 _1705_ _1704_ _1678_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__o211ai_2
X_5028_ _0639_ _0641_ _0655_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__o21a_1
XANTENNA__4832__B1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout354_X net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6979_ _2606_ _2607_ _2602_ VGND VGND VPWR VPWR _2609_ sky130_fd_sc_hd__a21o_1
XFILLER_139_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8718_ _4265_ _4266_ _4267_ _4264_ VGND VGND VPWR VPWR _4268_ sky130_fd_sc_hd__a31o_1
XFILLER_41_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__9393__Q adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8649_ _3962_ _3963_ VGND VGND VPWR VPWR _4207_ sky130_fd_sc_hd__nand2b_1
XFILLER_139_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4899__B1 net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5312__B2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5312__A1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8175__S net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_636 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8204__A net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5551__B2 net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5551__A1 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6000_ _1288_ _1628_ _1629_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__nand3_1
XFILLER_79_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7951_ net483 adder_inst.sum_raw_r\[11\] adder_inst.sum_raw_r\[10\] net171 _3546_
+ VGND VGND VPWR VPWR _3547_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7882_ net493 _3483_ VGND VGND VPWR VPWR _3488_ sky130_fd_sc_hd__nand2_1
XFILLER_54_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6902_ _2508_ _2531_ VGND VGND VPWR VPWR _2532_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_38_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6833_ _2460_ _2461_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_18_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6764_ _2391_ _2392_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_118_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8503_ _4075_ VGND VGND VPWR VPWR _4076_ sky130_fd_sc_hd__inv_2
X_9483_ clknet_leaf_28_clk net831 _0393_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
XANTENNA__4593__A2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5715_ _1342_ _1343_ _1341_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__a21bo_1
X_6695_ net442 net329 net334 net436 VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__a22oi_2
XANTENNA__5790__A1 net354 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8434_ _4004_ _4005_ VGND VGND VPWR VPWR _4007_ sky130_fd_sc_hd__or2_1
X_5646_ _1272_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout314_A net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5790__B2 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_131_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8365_ net122 _3937_ VGND VGND VPWR VPWR _3938_ sky130_fd_sc_hd__nor2_1
Xhold220 _0004_ VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlygate4sd3_1
X_5577_ _1201_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__and2_1
Xhold253 multiplier_inst.exp_final_r\[3\] VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlygate4sd3_1
Xhold231 add_res\[19\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
X_8296_ net143 _3864_ _3867_ net123 VGND VGND VPWR VPWR _3869_ sky130_fd_sc_hd__a211o_1
X_7316_ _2938_ _2945_ _2937_ VGND VGND VPWR VPWR _2946_ sky130_fd_sc_hd__a21oi_1
Xhold242 add_res\[4\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 adder_inst.is_nan_a_r VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7247_ _0947_ _0949_ _0946_ VGND VGND VPWR VPWR _2877_ sky130_fd_sc_hd__o21ba_1
Xhold264 _0029_ VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 add_res\[1\] VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_49_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold297 multiplier_inst.man_final_r\[12\] VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7178_ _2587_ _2692_ _2806_ VGND VGND VPWR VPWR _2808_ sky130_fd_sc_hd__or3_1
XANTENNA__5920__B net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_129_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6129_ _1756_ _1757_ _1755_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__o21bai_2
XFILLER_19_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9388__Q adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8723__S _3665_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6454__D net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5830__B net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4727__A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5500_ _1106_ _1117_ _1119_ _1128_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__o211a_1
XFILLER_9_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6480_ _2104_ _2103_ _2109_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__nor3b_4
X_5431_ _1042_ _1043_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand3_1
XANTENNA__5293__A net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5362_ _0691_ _0693_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__nand2_1
X_8150_ net134 _3723_ VGND VGND VPWR VPWR _3724_ sky130_fd_sc_hd__nor2_1
X_8081_ net644 _4335_ _3277_ VGND VGND VPWR VPWR _3655_ sky130_fd_sc_hd__a21o_1
X_7101_ _2727_ _2728_ _2713_ VGND VGND VPWR VPWR _2731_ sky130_fd_sc_hd__a21oi_1
XFILLER_101_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7032_ _1588_ _1590_ _1589_ VGND VGND VPWR VPWR _2662_ sky130_fd_sc_hd__o21ba_1
X_5293_ net255 net406 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nand2_1
XANTENNA__7029__A1 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7029__B2 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8543__S net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8983_ net518 VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__inv_2
XFILLER_55_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7934_ adder_inst.sum_raw_r\[4\] net495 _3530_ _3531_ _3473_ VGND VGND VPWR VPWR
+ _3532_ sky130_fd_sc_hd__a221o_1
XFILLER_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7865_ _3445_ _3470_ net491 VGND VGND VPWR VPWR _3471_ sky130_fd_sc_hd__a21oi_1
X_7796_ net195 _3401_ VGND VGND VPWR VPWR _3402_ sky130_fd_sc_hd__or2_1
XANTENNA_fanout431_A net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6816_ _2415_ _2445_ VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__and2b_1
XFILLER_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6004__A2 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout529_A net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5763__A1 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6747_ net324 net453 VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__nand2_1
XANTENNA__5763__B2 net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9466_ clknet_leaf_18_clk _0085_ _0376_ VGND VGND VPWR VPWR mul_res\[21\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout317_X net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6678_ _2305_ _2307_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__nor2_1
XFILLER_137_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9397_ clknet_leaf_7_clk net744 _0307_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
X_8417_ _3677_ _3811_ _3816_ VGND VGND VPWR VPWR _3990_ sky130_fd_sc_hd__or3_1
X_5629_ net237 net467 _1217_ _1218_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_117_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8348_ _3920_ VGND VGND VPWR VPWR _3921_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_57_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5634__C net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_111_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8279_ _3851_ VGND VGND VPWR VPWR _3852_ sky130_fd_sc_hd__inv_2
XFILLER_120_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout541 net542 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__buf_4
Xfanout530 net534 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__clkbuf_4
XANTENNA__6746__B net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer90 net641 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_33_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5378__A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6002__A net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6656__B net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6943__Y _2573_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5980_ _1571_ _1572_ _1608_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a21o_1
X_4931_ net386 net263 net392 net269 VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_48_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7650_ adder_inst.exp_a_r\[2\] adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR _3278_
+ sky130_fd_sc_hd__and2b_1
X_4862_ _0471_ _0489_ _0490_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand3_1
XANTENNA__6822__D net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4623__C net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6601_ _2217_ _2223_ _2216_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__a21o_1
X_9320_ clknet_leaf_7_clk net753 _0230_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_4793_ _4430_ _4432_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xnor2_2
X_7581_ _1151_ _3208_ _1149_ VGND VGND VPWR VPWR _3211_ sky130_fd_sc_hd__o21ba_1
XFILLER_119_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4920__A net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6532_ net283 net465 net472 net276 VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__a22oi_1
X_9251_ clknet_leaf_4_clk net46 _0161_ VGND VGND VPWR VPWR adder_inst.i_b\[21\] sky130_fd_sc_hd__dfrtp_1
X_6463_ _2089_ _2092_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__nand2_1
XANTENNA__5735__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput100 net100 VGND VGND VPWR VPWR o_res_vld sky130_fd_sc_hd__buf_2
X_5414_ _0991_ _0993_ _0992_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a21o_1
X_9182_ net546 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__inv_2
X_8202_ _3729_ _3775_ VGND VGND VPWR VPWR _3776_ sky130_fd_sc_hd__and2_1
XFILLER_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8133_ _3705_ _3706_ VGND VGND VPWR VPWR _3707_ sky130_fd_sc_hd__xnor2_1
X_6394_ _2017_ _2020_ _2022_ _2023_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__o211ai_2
XFILLER_99_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5345_ _0971_ _0973_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nor2_1
XANTENNA__4720__A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8064_ adder_inst.is_zero_r _3435_ VGND VGND VPWR VPWR _3643_ sky130_fd_sc_hd__nor2_1
XFILLER_114_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5276_ _0903_ _0904_ _0902_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o21bai_1
XANTENNA__6566__B net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout381_A net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_52_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7015_ net238 net441 VGND VGND VPWR VPWR _2645_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_126_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout479_A adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5681__B1 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8966_ net540 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_108_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout267_X net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7917_ adder_inst.sum_raw_r\[2\] net192 _3472_ _3516_ VGND VGND VPWR VPWR _3517_
+ sky130_fd_sc_hd__o211a_1
XFILLER_15_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8897_ net517 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout434_X net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7848_ _3388_ _3395_ VGND VGND VPWR VPWR _3454_ sky130_fd_sc_hd__nor2_1
X_7779_ net196 adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _3385_ sky130_fd_sc_hd__nand2_1
XANTENNA__8302__A net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4830__A net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_137_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9449_ clknet_leaf_28_clk _0098_ _0359_ VGND VGND VPWR VPWR mul_res\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_125_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4711__A2 net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5661__A net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout382 net588 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__buf_4
XFILLER_120_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout393 net394 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__clkbuf_2
Xfanout360 net364 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__buf_2
XFILLER_93_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone106 _3711_ VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__buf_4
Xfanout371 net583 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_704 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4778__A2 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6642__D net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5539__C net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput13 i_a[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
Xinput24 i_a[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput46 i_b[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput35 i_b[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput57 i_b[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
XFILLER_116_728 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4950__A2 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5130_ _0743_ _0755_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__and3_1
XANTENNA__7652__A1 adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5061_ net374 net244 net250 net380 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nand4_1
XFILLER_97_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6455__A2 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7929__C adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8820_ _3210_ _4315_ VGND VGND VPWR VPWR multiplier_inst.man_final\[9\] sky130_fd_sc_hd__xnor2_1
XFILLER_80_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8751_ multiplier_inst.man_final_r\[20\] net180 net177 VGND VGND VPWR VPWR _0084_
+ sky130_fd_sc_hd__and3_1
X_5963_ _1488_ _1490_ _1489_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__o21ba_1
X_7702_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR _3326_
+ sky130_fd_sc_hd__and2b_2
XTAP_TAPCELL_ROW_121_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4914_ net235 net410 net416 net229 VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a22o_1
XFILLER_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8682_ _4236_ _4042_ VGND VGND VPWR VPWR adder_inst.sum_raw\[18\] sky130_fd_sc_hd__xnor2_2
XFILLER_61_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5894_ net359 net367 net311 net319 VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__and4_1
XFILLER_139_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4845_ _0472_ _0473_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__or3_1
X_7633_ _3140_ net117 _3147_ _3130_ _3144_ VGND VGND VPWR VPWR _3263_ sky130_fd_sc_hd__o221ai_1
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4776_ net350 net356 net262 net269 VGND VGND VPWR VPWR _4547_ sky130_fd_sc_hd__and4_1
X_7564_ _3185_ _3193_ VGND VGND VPWR VPWR _3194_ sky130_fd_sc_hd__and2b_1
XFILLER_20_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_leaf_12_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9303_ clknet_leaf_3_clk net732 _0213_ VGND VGND VPWR VPWR adder_inst.man_a_r\[15\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA_fanout227_A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6515_ _2141_ _2144_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__nor2_1
XFILLER_119_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4800__D net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7495_ _3076_ _3124_ VGND VGND VPWR VPWR _3125_ sky130_fd_sc_hd__nand2_1
XFILLER_106_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9234_ clknet_leaf_0_clk net59 _0144_ VGND VGND VPWR VPWR adder_inst.i_b\[4\] sky130_fd_sc_hd__dfrtp_1
X_6446_ _2070_ _2074_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__xor2_1
X_9165_ net527 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__inv_2
X_6377_ _1993_ _1994_ _2005_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__nand3_2
X_9096_ net536 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__inv_2
XFILLER_121_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8116_ _3341_ _3663_ _3688_ VGND VGND VPWR VPWR _3690_ sky130_fd_sc_hd__or3_4
X_5328_ _0917_ _0955_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__and4_1
XANTENNA_clkbuf_leaf_27_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8047_ adder_inst.is_zero_r _3481_ VGND VGND VPWR VPWR _3629_ sky130_fd_sc_hd__nor2_1
XFILLER_102_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout384_X net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5259_ _0885_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_3_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9396__Q adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8949_ net530 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_65_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5709__A1 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5656__A net630 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5375__B net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4710__D net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5094__C net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone92_X net641 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5822__C net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4719__B net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5541__D net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout190 _4344_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_2
XFILLER_94_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7937__A2 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7111__A net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5948__B2 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5948__A1 net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4630_ net351 net246 VGND VGND VPWR VPWR _4401_ sky130_fd_sc_hd__nand2_1
XFILLER_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4561_ net288 VGND VGND VPWR VPWR _4333_ sky130_fd_sc_hd__inv_2
X_6300_ _1927_ _1929_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__nor2_2
X_7280_ _2896_ _2909_ VGND VGND VPWR VPWR _2910_ sky130_fd_sc_hd__nor2_1
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6231_ _1858_ _1859_ _1852_ _1855_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__o211a_1
XFILLER_131_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6162_ _1789_ _1791_ _1788_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__a21oi_1
XANTENNA__6828__C net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5113_ _0459_ _0602_ _0742_ _0626_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__or4bb_4
XANTENNA__4629__B net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6093_ _1720_ _1721_ _1719_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__o21bai_1
X_5044_ _0671_ _0672_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__and3_1
XFILLER_27_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout177_A net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8803_ _3163_ _3169_ _3172_ VGND VGND VPWR VPWR _4309_ sky130_fd_sc_hd__o21ai_1
XFILLER_53_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6995_ net255 net419 VGND VGND VPWR VPWR _2625_ sky130_fd_sc_hd__nand2_1
XFILLER_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8734_ net760 net180 net176 VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__and3_1
X_5946_ net237 net446 VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__nand2_1
XFILLER_41_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8665_ _4220_ _4221_ VGND VGND VPWR VPWR _4222_ sky130_fd_sc_hd__nand2_1
XFILLER_34_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5877_ _1472_ _1473_ _1505_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__nor4_2
XANTENNA_fanout511_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4828_ _4542_ _0456_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__xnor2_1
X_7616_ _3123_ _3245_ _3121_ VGND VGND VPWR VPWR _3246_ sky130_fd_sc_hd__o21ba_1
XFILLER_21_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8596_ _4159_ _4160_ net173 VGND VGND VPWR VPWR _4161_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_60_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5195__B net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4914__A2 net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4759_ _4524_ _4529_ VGND VGND VPWR VPWR _4530_ sky130_fd_sc_hd__xnor2_1
X_7547_ _3176_ VGND VGND VPWR VPWR _3177_ sky130_fd_sc_hd__inv_2
XFILLER_5_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7478_ _3106_ _3107_ VGND VGND VPWR VPWR _3108_ sky130_fd_sc_hd__or2_1
X_9217_ clknet_leaf_5_clk net11 _0127_ VGND VGND VPWR VPWR adder_inst.i_a\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_122_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6429_ _2057_ _2058_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__nor2_1
XFILLER_134_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_116_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5642__C net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9148_ net541 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__inv_2
XFILLER_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8726__S net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9079_ net520 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__inv_2
XFILLER_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4826__Y _0456_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8041__A1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6052__B1 net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7855__A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5866__B1 net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8032__A1 net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8568__C1 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6383__C net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6780_ _2407_ _2409_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__nand2_1
XFILLER_23_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5800_ _1423_ _1424_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__nand3_1
XFILLER_50_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5731_ _1358_ _1359_ _1360_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_33_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4631__C net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8450_ net476 net156 VGND VGND VPWR VPWR _4023_ sky130_fd_sc_hd__or2_1
X_5662_ net377 net331 net338 net371 VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a22oi_2
X_8381_ _3951_ _3953_ VGND VGND VPWR VPWR _3954_ sky130_fd_sc_hd__nor2_1
X_7401_ _0870_ _0871_ VGND VGND VPWR VPWR _3031_ sky130_fd_sc_hd__nand2_1
X_4613_ _4376_ _4380_ _4382_ VGND VGND VPWR VPWR _4384_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_13_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5593_ net237 net461 _1214_ _1212_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__a31o_1
X_7332_ _2960_ _2961_ VGND VGND VPWR VPWR _2962_ sky130_fd_sc_hd__nand2_1
X_7263_ _2835_ _2836_ _2869_ _2870_ VGND VGND VPWR VPWR _2893_ sky130_fd_sc_hd__a22o_1
X_9002_ net522 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__inv_2
XANTENNA__7016__A net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6214_ _1829_ _1842_ _1843_ _1749_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__o211a_4
X_7194_ _0905_ _2821_ _2822_ VGND VGND VPWR VPWR _2824_ sky130_fd_sc_hd__a21o_1
XFILLER_112_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6145_ net552 _1772_ _1773_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__or3_1
XANTENNA_fanout294_A net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6076_ _1678_ _1704_ _1705_ net130 VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__a211o_4
X_5027_ _0639_ _0641_ _0655_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__or3_1
XANTENNA__6282__B1 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4832__B2 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4832__A1 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout461_A net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout347_X net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8717_ _4081_ _4115_ _4112_ net174 VGND VGND VPWR VPWR _4267_ sky130_fd_sc_hd__o211a_1
XANTENNA__4596__B1 net346 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6978_ _2602_ _2606_ _2607_ VGND VGND VPWR VPWR _2608_ sky130_fd_sc_hd__and3_1
X_5929_ net267 net415 net421 net260 VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__a22o_1
XFILLER_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8648_ _4204_ _3966_ VGND VGND VPWR VPWR _4206_ sky130_fd_sc_hd__nand2b_1
XFILLER_119_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8579_ _3877_ _3876_ VGND VGND VPWR VPWR _4146_ sky130_fd_sc_hd__nand2b_1
XANTENNA__4899__B2 net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4899__A1 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7837__A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5312__A2 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6765__A net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input22_A i_a[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8014__B2 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8014__A1 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7775__A_N _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8204__B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5547__C net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5551__A2 net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6264__B1 net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7950_ adder_inst.sum_raw_r\[7\] _3504_ _3544_ _3545_ VGND VGND VPWR VPWR _3546_
+ sky130_fd_sc_hd__o211a_1
XFILLER_82_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7881_ net196 _3486_ net193 VGND VGND VPWR VPWR _3487_ sky130_fd_sc_hd__mux2_1
XANTENNA__8005__B2 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8005__A1 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_38_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6901_ _2490_ _2507_ VGND VGND VPWR VPWR _2531_ sky130_fd_sc_hd__nand2_1
XANTENNA__4923__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6832_ net305 net478 _2460_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_18_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6763_ _2391_ _2392_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_118_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8502_ _4067_ _4074_ VGND VGND VPWR VPWR _4075_ sky130_fd_sc_hd__or2_2
X_9482_ clknet_leaf_28_clk net821 _0392_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
XFILLER_50_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5714_ _1341_ _1342_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__nand3b_1
X_6694_ net447 net325 VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__nand2_1
X_8433_ _4005_ VGND VGND VPWR VPWR _4006_ sky130_fd_sc_hd__inv_2
X_5645_ _1245_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__nor2_1
XFILLER_136_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold210 _0013_ VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8364_ _3864_ _3871_ net144 VGND VGND VPWR VPWR _3937_ sky130_fd_sc_hd__mux2_4
XANTENNA_fanout307_A net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5576_ _1202_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__xnor2_1
Xhold221 add_res\[22\] VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlygate4sd3_1
Xhold232 _0010_ VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8295_ net144 _3864_ _3867_ VGND VGND VPWR VPWR _3868_ sky130_fd_sc_hd__a21oi_1
X_7315_ _2939_ _2943_ VGND VGND VPWR VPWR _2945_ sky130_fd_sc_hd__xnor2_1
Xhold243 _0026_ VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold254 add_res\[30\] VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 _0034_ VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold265 add_res\[18\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlygate4sd3_1
X_7246_ _2874_ _2875_ VGND VGND VPWR VPWR _2876_ sky130_fd_sc_hd__xor2_1
Xhold287 _0011_ VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_49_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold298 multiplier_inst.exp_final_r\[4\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8276__S net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7177_ _2587_ _2692_ _2806_ VGND VGND VPWR VPWR _2807_ sky130_fd_sc_hd__o21a_1
XFILLER_58_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6128_ _1755_ _1756_ _1757_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__or3_1
XANTENNA_fanout297_X net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_129_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5920__C net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_0_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout464_X net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6059_ net247 net467 net474 net241 VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__a22o_1
XFILLER_27_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_692 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8547__A2 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8799__X _4306_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9136__A net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8235__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4727__B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5830__C net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5430_ _1046_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__nand2b_1
XFILLER_118_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5361_ _4557_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__nand3_1
XANTENNA__5293__B net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8080_ _3279_ _3273_ VGND VGND VPWR VPWR _3654_ sky130_fd_sc_hd__or2_4
XFILLER_114_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8474__A1 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5292_ net261 net265 net397 net400 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__and4_1
X_7100_ _2713_ _2727_ _2728_ VGND VGND VPWR VPWR _2730_ sky130_fd_sc_hd__nand3_1
X_7031_ _2657_ _2660_ VGND VGND VPWR VPWR _2661_ sky130_fd_sc_hd__xnor2_1
XFILLER_101_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7029__A2 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8982_ net523 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__inv_2
XFILLER_27_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7933_ adder_inst.sum_raw_r\[3\] _4341_ net170 adder_inst.sum_raw_r\[2\] net192 VGND
+ VGND VPWR VPWR _3531_ sky130_fd_sc_hd__o221a_1
XFILLER_82_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7864_ net498 net494 VGND VGND VPWR VPWR _3470_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout257_A net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7795_ net197 adder_inst.exp_larger_r\[1\] adder_inst.exp_larger_r\[2\] adder_inst.exp_larger_r\[3\]
+ VGND VGND VPWR VPWR _3401_ sky130_fd_sc_hd__a31o_1
X_6815_ _2442_ _2444_ VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__nand2_1
XFILLER_51_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout424_A net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6746_ net442 net448 net328 net334 VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__and4_1
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5763__A2 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9465_ clknet_leaf_18_clk _0084_ _0375_ VGND VGND VPWR VPWR mul_res\[20\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6677_ _2298_ _2304_ _2306_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__and3_1
X_9396_ clknet_leaf_7_clk net750 _0306_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_2
X_8416_ _3988_ VGND VGND VPWR VPWR _3989_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout212_X net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5628_ _1255_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nor2_1
X_8347_ net304 _3919_ net164 VGND VGND VPWR VPWR _3920_ sky130_fd_sc_hd__mux2_2
XANTENNA__8795__A _4300_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5634__D net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5559_ _1187_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__nor2_1
XFILLER_104_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8278_ net155 _3848_ _3850_ VGND VGND VPWR VPWR _3851_ sky130_fd_sc_hd__a21oi_4
XFILLER_78_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout520 net523 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__buf_4
XFILLER_132_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout542 net548 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__buf_4
Xfanout531 net532 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7229_ net200 net454 _2856_ _2858_ VGND VGND VPWR VPWR _2859_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_58_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer91 _1770_ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5378__B net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6002__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_63_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6219__B1 net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4930_ _0526_ net616 _0531_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_72_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4861_ _0471_ _0489_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and3_1
XFILLER_45_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4623__D net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6600_ _2229_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4792_ _4420_ _4546_ _0420_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__a21oi_1
X_7580_ _3206_ _3209_ net112 VGND VGND VPWR VPWR _3210_ sky130_fd_sc_hd__mux2_2
XFILLER_119_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4920__B net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6531_ net276 net283 net465 net472 VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__and4_1
X_9250_ clknet_leaf_5_clk net45 _0160_ VGND VGND VPWR VPWR adder_inst.i_b\[20\] sky130_fd_sc_hd__dfrtp_1
XFILLER_118_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6462_ _2091_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__inv_2
Xoutput101 net101 VGND VGND VPWR VPWR overflow sky130_fd_sc_hd__buf_2
XFILLER_127_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5413_ _1012_ _1041_ _1040_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a21o_1
X_9181_ net542 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__inv_2
X_8201_ _3767_ _3774_ net126 VGND VGND VPWR VPWR _3775_ sky130_fd_sc_hd__mux2_2
X_6393_ _2002_ _2004_ _2021_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__nand3_2
X_8132_ _4351_ _4355_ VGND VGND VPWR VPWR _3706_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_81_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5344_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__inv_2
X_8063_ _3638_ _3639_ _3641_ VGND VGND VPWR VPWR _3642_ sky130_fd_sc_hd__a21oi_1
X_5275_ _0902_ _0903_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__or3_1
XFILLER_99_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7014_ net254 net425 _1559_ _1558_ VGND VGND VPWR VPWR _2644_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_126_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6863__A net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5681__B2 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5681__A1 net555 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout374_A net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8965_ net540 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_90_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout541_A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout162_X net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8896_ net512 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__inv_2
X_7916_ adder_inst.sum_raw_r\[1\] net499 _3445_ adder_inst.sum_raw_r\[0\] net496 VGND
+ VGND VPWR VPWR _3516_ sky130_fd_sc_hd__a221o_1
XFILLER_43_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7847_ net196 _3388_ adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _3453_ sky130_fd_sc_hd__o21a_1
XFILLER_102_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5197__B1 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7778_ adder_inst.sum_raw_r\[1\] net483 net171 adder_inst.sum_raw_r\[0\] VGND VGND
+ VPWR VPWR _3384_ sky130_fd_sc_hd__a22o_1
XANTENNA_fanout427_X net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8302__B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4830__B net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6729_ _2293_ _2320_ _2337_ _2351_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__o211ai_2
XFILLER_137_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9448_ clknet_leaf_29_clk _0097_ _0358_ VGND VGND VPWR VPWR mul_res\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9379_ clknet_leaf_17_clk _0053_ _0289_ VGND VGND VPWR VPWR add_res\[25\] sky130_fd_sc_hd__dfrtp_1
XFILLER_118_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7110__A1 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5661__B net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout350 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkbuf_2
XFILLER_120_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout361 net364 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__buf_2
Xclone107 _3694_ VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__clkbuf_1
Xfanout372 net583 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout383 net384 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkbuf_4
Xfanout394 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__buf_6
XFILLER_62_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5539__D net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput25 i_a[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput14 i_a[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput36 i_b[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
XANTENNA__6013__A net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput47 i_b[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
Xinput58 i_b[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
XFILLER_108_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8429__A1 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5060_ net374 net256 _0678_ _0677_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a31o_1
XFILLER_96_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8750_ multiplier_inst.man_final_r\[19\] net179 net176 VGND VGND VPWR VPWR _0082_
+ sky130_fd_sc_hd__and3_1
XFILLER_65_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5299__A net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5962_ _1588_ _1591_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__xnor2_1
XFILLER_53_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7701_ _3319_ _3325_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[4\] sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_121_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4913_ net229 net235 net410 net416 VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__and4_1
XFILLER_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8681_ net188 _4234_ _4235_ _4233_ VGND VGND VPWR VPWR _4236_ sky130_fd_sc_hd__a31o_1
XFILLER_33_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5893_ net373 net306 VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__nand2_1
X_4844_ net360 net280 net287 net355 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a22oi_2
XANTENNA__4931__A net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7632_ _3244_ _3261_ VGND VGND VPWR VPWR _3262_ sky130_fd_sc_hd__and2_1
XFILLER_21_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4775_ _4414_ _4419_ _4418_ VGND VGND VPWR VPWR _4546_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_103_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7563_ _3176_ net110 _3189_ _3190_ VGND VGND VPWR VPWR _3193_ sky130_fd_sc_hd__o211a_1
XANTENNA__5746__B net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9302_ clknet_leaf_6_clk net693 _0212_ VGND VGND VPWR VPWR adder_inst.man_a_r\[14\]
+ sky130_fd_sc_hd__dfrtp_4
X_6514_ net289 net458 _2142_ _2143_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__and4_1
XFILLER_107_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7494_ _3119_ _3123_ VGND VGND VPWR VPWR _3124_ sky130_fd_sc_hd__nor2_1
X_9233_ clknet_leaf_31_clk net58 _0143_ VGND VGND VPWR VPWR adder_inst.i_b\[3\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__5762__A net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6445_ _2070_ _2074_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__nand2_1
XFILLER_134_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_751 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9164_ net526 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__inv_2
X_6376_ _1993_ _1994_ _2005_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__and3_1
X_9095_ net543 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__inv_2
X_8115_ _3341_ _3663_ _3662_ net643 VGND VGND VPWR VPWR _3689_ sky130_fd_sc_hd__o211ai_2
XFILLER_115_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5327_ _0810_ _0876_ _0896_ _0916_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8046_ _3627_ _3628_ net198 VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__o21a_1
XFILLER_114_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7689__A net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5258_ _0885_ _0886_ _0887_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__or3_1
X_5189_ net255 net400 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout377_X net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8948_ net547 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__inv_2
XFILLER_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_727 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8879_ add_res\[31\] net794 net505 VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_42_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5709__A2 net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5656__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5375__C net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer25_A net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5094__D net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5672__A net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input52_A i_b[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8983__A net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5822__D net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4719__C net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout191 _4343_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
XFILLER_66_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7111__B net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5948__A2 net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8347__A0 net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5847__A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4560_ adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _4332_ sky130_fd_sc_hd__inv_2
XANTENNA_clone134_Y net683 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8369__S net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5582__A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6230_ _1852_ _1855_ _1858_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__a211oi_1
X_6161_ _1785_ _1787_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__xor2_1
X_5112_ _0623_ _0624_ _0625_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a21o_1
XANTENNA__7086__B1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6092_ _1720_ _1719_ _1721_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__or3_4
X_5043_ _0608_ _0611_ _0610_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a21bo_1
XFILLER_84_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8802_ _3169_ _4308_ _3163_ VGND VGND VPWR VPWR multiplier_inst.man_final\[0\] sky130_fd_sc_hd__mux2_1
XFILLER_25_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6994_ _2620_ _2621_ _2622_ VGND VGND VPWR VPWR _2624_ sky130_fd_sc_hd__a21o_1
XANTENNA__6061__A1 net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8733_ net818 net180 net176 VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__and3_1
X_5945_ net254 net434 _1461_ _1460_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__a31o_1
XFILLER_43_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8664_ _4190_ _3987_ _3977_ _4203_ _4219_ VGND VGND VPWR VPWR _4221_ sky130_fd_sc_hd__a311o_1
XANTENNA_fanout337_A adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5876_ _1503_ _1504_ _1235_ _1251_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__o211a_1
X_4827_ _4542_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__nand2_1
X_7615_ _3036_ _3076_ _3127_ VGND VGND VPWR VPWR _3245_ sky130_fd_sc_hd__a21oi_1
XFILLER_138_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8595_ _4154_ _4153_ _3911_ VGND VGND VPWR VPWR _4160_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_60_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5195__C net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_134_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout504_A opcode_stage1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4758_ _4527_ _4528_ VGND VGND VPWR VPWR _4529_ sky130_fd_sc_hd__xnor2_1
X_7546_ _3004_ _3174_ VGND VGND VPWR VPWR _3176_ sky130_fd_sc_hd__xnor2_2
XFILLER_134_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4689_ _4458_ _4459_ VGND VGND VPWR VPWR _4460_ sky130_fd_sc_hd__nor2_1
X_7477_ _3101_ _3105_ VGND VGND VPWR VPWR _3107_ sky130_fd_sc_hd__and2_1
XANTENNA__6588__A net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9216_ clknet_leaf_4_clk net10 _0126_ VGND VGND VPWR VPWR adder_inst.i_a\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6428_ net430 net314 net320 net424 VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__a22oi_1
XFILLER_122_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9147_ net541 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout494_X net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5642__D net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6359_ _1985_ _1988_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__xnor2_1
XFILLER_130_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9078_ net538 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__inv_2
XFILLER_102_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8029_ _4343_ _3398_ _3612_ _3613_ VGND VGND VPWR VPWR _3614_ sky130_fd_sc_hd__a31o_1
XANTENNA__4836__A net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8308__A net316 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6824__B1 net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6052__A1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6052__B2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5866__B2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5866__A1 net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4746__A net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7122__A net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6383__D net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7776__B adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_leaf_26_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5730_ net362 net331 net338 net354 VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__a22o_1
XFILLER_31_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4631__D net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7400_ _3027_ _2573_ _2568_ VGND VGND VPWR VPWR _3030_ sky130_fd_sc_hd__nand3b_4
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5661_ net371 net377 net333 net339 VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__and4_1
X_8380_ net159 _3950_ _3952_ VGND VGND VPWR VPWR _3953_ sky130_fd_sc_hd__a21oi_1
X_4612_ _4376_ _4380_ _4382_ VGND VGND VPWR VPWR _4383_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_13_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5592_ _1220_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__nand2_1
XFILLER_129_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7331_ _2929_ _2959_ _2730_ _2732_ VGND VGND VPWR VPWR _2961_ sky130_fd_sc_hd__o211ai_1
XFILLER_116_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7262_ _2880_ _2891_ VGND VGND VPWR VPWR _2892_ sky130_fd_sc_hd__or2_1
X_9001_ net522 VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__inv_2
XANTENNA__7016__B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6213_ _1735_ _1736_ _1748_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__a21o_1
XFILLER_131_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7193_ _0905_ _2821_ _2822_ VGND VGND VPWR VPWR _2823_ sky130_fd_sc_hd__nand3_1
XANTENNA__7059__B1 net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6144_ net552 _1772_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__nor3_1
XFILLER_112_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6075_ _1411_ _1412_ _1413_ _1281_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__o22a_1
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5026_ _0639_ _0641_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__nor3_1
XANTENNA_fanout287_A net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6282__A1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout454_A adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6977_ _2604_ _2605_ _2603_ VGND VGND VPWR VPWR _2607_ sky130_fd_sc_hd__a21bo_1
X_8716_ _4080_ net661 _4110_ VGND VGND VPWR VPWR _4266_ sky130_fd_sc_hd__or3b_1
XFILLER_81_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout242_X net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_62_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4596__A1 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4596__B2 net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5928_ net260 net267 net415 net421 VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__and4_1
XFILLER_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8647_ _3966_ _4205_ VGND VGND VPWR VPWR adder_inst.sum_raw\[14\] sky130_fd_sc_hd__xnor2_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5859_ net225 net231 net455 net461 VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__and4_1
X_8578_ _3880_ _4145_ VGND VGND VPWR VPWR adder_inst.sum_raw\[5\] sky130_fd_sc_hd__xor2_1
XFILLER_119_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4899__A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7529_ net586 _3158_ VGND VGND VPWR VPWR _3159_ sky130_fd_sc_hd__or2_1
XFILLER_119_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5372__D net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6765__B net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4566__A adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input15_A i_a[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8722__A0 adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5547__D net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6264__A1 net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6264__B2 net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7880_ _3431_ _3483_ _3485_ net500 _3484_ VGND VGND VPWR VPWR _3486_ sky130_fd_sc_hd__a221o_1
XANTENNA__7787__A net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6900_ _2529_ VGND VGND VPWR VPWR _2530_ sky130_fd_sc_hd__inv_2
XFILLER_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6831_ net305 net477 VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__nand2_1
XFILLER_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4923__B net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8501_ _4071_ _4073_ VGND VGND VPWR VPWR _4074_ sky130_fd_sc_hd__nand2_1
XANTENNA__5100__A net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6762_ _2343_ _2345_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_118_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9481_ clknet_leaf_28_clk net792 _0391_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
X_5713_ net401 net297 net302 net396 VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a22o_1
X_6693_ net436 net442 net328 net334 VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__and4_1
X_8432_ _4000_ _4002_ VGND VGND VPWR VPWR _4005_ sky130_fd_sc_hd__and2_1
X_5644_ net219 net480 _1243_ _1244_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__o2bb2a_1
X_8363_ _3933_ _3934_ VGND VGND VPWR VPWR _3936_ sky130_fd_sc_hd__or2_1
Xhold200 adder_inst.exp_b\[6\] VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7314_ _2939_ _2943_ VGND VGND VPWR VPWR _2944_ sky130_fd_sc_hd__nand2b_1
Xhold211 multiplier_inst.man_final_r\[3\] VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__7027__A net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5575_ _1203_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__nor2_1
Xhold222 _0014_ VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_fanout202_A net204 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold233 add_res\[20\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8294_ net127 _3865_ _3866_ VGND VGND VPWR VPWR _3867_ sky130_fd_sc_hd__and3_1
Xhold244 multiplier_inst.man_final_r\[4\] VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 _0023_ VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold266 _0009_ VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7245_ _0839_ _0939_ _0944_ _0951_ VGND VGND VPWR VPWR _2875_ sky130_fd_sc_hd__o31a_1
Xhold277 add_res\[3\] VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dlygate4sd3_1
Xhold299 multiplier_inst.exp_final_r\[2\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
Xhold288 multiplier_inst.man_final_r\[8\] VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlygate4sd3_1
X_7176_ _0878_ _0880_ VGND VGND VPWR VPWR _2806_ sky130_fd_sc_hd__xnor2_1
XANTENNA_input7_A i_a[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6127_ net286 net439 net445 net278 VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a22oi_2
XFILLER_112_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5920__D net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6058_ net241 net247 net467 net474 VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__nand4_1
XFILLER_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5009_ _0636_ _0637_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__and3_1
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout457_X net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5680__A net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_110_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5830__D net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7994__B2 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5360_ _4554_ _4556_ _4555_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__o21ai_1
XFILLER_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5291_ _0824_ _0830_ _0829_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__a21o_1
X_7030_ _2658_ _2659_ VGND VGND VPWR VPWR _2660_ sky130_fd_sc_hd__nor2_1
XFILLER_4_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__9212__D net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8981_ net509 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__inv_2
XANTENNA__8406__A net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7985__B2 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7985__A1 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7932_ adder_inst.sum_raw_r\[1\] net182 VGND VGND VPWR VPWR _3530_ sky130_fd_sc_hd__or2_1
XFILLER_67_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7863_ net185 _3465_ _3466_ _3468_ VGND VGND VPWR VPWR _3469_ sky130_fd_sc_hd__a31o_1
XFILLER_63_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7794_ _4347_ _3399_ VGND VGND VPWR VPWR _3400_ sky130_fd_sc_hd__nand2_1
XFILLER_50_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5748__B1 net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6814_ _2437_ _2442_ _2443_ VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__nand3_2
XFILLER_51_699 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6745_ _2323_ _2325_ _2324_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__o21ai_1
X_9464_ clknet_leaf_20_clk _0082_ _0374_ VGND VGND VPWR VPWR mul_res\[19\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__4971__A1 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8162__A1 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8415_ _3977_ _3987_ VGND VGND VPWR VPWR _3988_ sky130_fd_sc_hd__or2_1
X_6676_ _2240_ _2262_ _2295_ _2303_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__o211ai_1
XFILLER_137_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9395_ clknet_leaf_10_clk net752 _0305_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__6299__C net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5627_ _1255_ _1256_ net253 net455 VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__and4bb_1
XFILLER_136_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8346_ net120 _3913_ _3915_ _3918_ VGND VGND VPWR VPWR _3919_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout205_X net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5558_ net266 net433 net439 net259 VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__a22oi_1
XFILLER_132_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8277_ net469 _3342_ net649 VGND VGND VPWR VPWR _3850_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_57_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5489_ _1095_ _0740_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__or3_4
XFILLER_104_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7228_ _2857_ VGND VGND VPWR VPWR _2858_ sky130_fd_sc_hd__inv_2
Xfanout521 net523 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__buf_4
Xfanout510 net523 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_4
Xfanout532 net533 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__buf_2
XANTENNA__4828__B _0456_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_70_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout543 net545 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__buf_4
X_7159_ _2787_ _2788_ VGND VGND VPWR VPWR _2789_ sky130_fd_sc_hd__or2_1
XFILLER_18_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7220__A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer70 _1076_ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_68_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_696 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6219__A1 net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6219__B2 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4754__A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_29_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA__7130__A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4860_ _0482_ _0483_ _0488_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a21o_1
XFILLER_60_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4791_ _4420_ _4546_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and3_1
X_6530_ _2086_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_99_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4920__C net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6461_ net261 net265 net472 net479 VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and4_1
X_5412_ _1012_ _1040_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand3_1
X_9180_ net542 VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__inv_2
X_8200_ _3770_ _3773_ net141 VGND VGND VPWR VPWR _3774_ sky130_fd_sc_hd__mux2_2
X_6392_ _2002_ _2004_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__a21o_1
X_8131_ _4358_ net161 VGND VGND VPWR VPWR _3705_ sky130_fd_sc_hd__nand2_1
X_5343_ _0963_ _0966_ _0972_ _0971_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_110_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8062_ net488 net195 _3420_ _3640_ VGND VGND VPWR VPWR _3641_ sky130_fd_sc_hd__a31o_1
XFILLER_87_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5274_ net385 net276 net284 net573 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a22oi_2
X_7013_ _1577_ _1579_ VGND VGND VPWR VPWR _2643_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5681__A2 net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8964_ net540 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout367_A net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8895_ net517 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_108_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7915_ net194 adder_inst.sum_raw_r\[6\] net114 _3515_ VGND VGND VPWR VPWR _0063_
+ sky130_fd_sc_hd__o211a_1
XFILLER_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7846_ adder_inst.exp_larger_r\[3\] _3415_ _3417_ VGND VGND VPWR VPWR _3452_ sky130_fd_sc_hd__a21o_1
XFILLER_102_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout155_X net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout534_A net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5197__A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4989_ _0617_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__and2b_1
X_7777_ net194 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3383_ sky130_fd_sc_hd__nand2_2
XANTENNA__5197__B2 net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4830__C net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6728_ _2355_ _2357_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout322_X net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9447_ clknet_leaf_28_clk _0094_ _0357_ VGND VGND VPWR VPWR mul_res\[2\] sky130_fd_sc_hd__dfrtp_1
X_6659_ _2286_ _2287_ _2285_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__o21ba_1
X_9378_ clknet_leaf_15_clk _0052_ _0288_ VGND VGND VPWR VPWR add_res\[24\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8329_ net124 _3901_ VGND VGND VPWR VPWR _3902_ sky130_fd_sc_hd__nand2_1
XFILLER_3_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5661__C net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout340 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__buf_6
Xfanout373 net584 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_4
Xfanout384 net385 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__buf_4
Xfanout351 net352 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_4
Xfanout362 net363 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_6_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7949__B2 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7949__A1 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout395 net553 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__buf_4
XFILLER_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4632__B1 net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_794 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4935__A1 net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput15 i_a[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput37 i_b[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput26 i_a[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6013__B net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput48 i_b[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput59 i_b[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4749__A net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6964__A net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5299__B net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5961_ _1589_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nor2_1
XFILLER_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7700_ net613 _3290_ _3321_ VGND VGND VPWR VPWR _3325_ sky130_fd_sc_hd__a21o_1
X_4912_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_121_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8680_ _4046_ _4047_ _4051_ _4225_ VGND VGND VPWR VPWR _4235_ sky130_fd_sc_hd__a22oi_2
XFILLER_80_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7631_ _3250_ _3253_ _3257_ _3260_ VGND VGND VPWR VPWR _3261_ sky130_fd_sc_hd__and4b_1
XFILLER_21_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5892_ _1519_ _1520_ _1515_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__a21o_1
X_4843_ net355 net360 net280 net287 VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__and4_1
XANTENNA__4931__B net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4774_ _4441_ _4442_ VGND VGND VPWR VPWR _4545_ sky130_fd_sc_hd__xnor2_1
X_7562_ _3176_ _3189_ net110 VGND VGND VPWR VPWR _3192_ sky130_fd_sc_hd__mux2_1
X_9301_ clknet_leaf_6_clk net741 _0211_ VGND VGND VPWR VPWR adder_inst.man_a_r\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_7493_ _3121_ _3122_ VGND VGND VPWR VPWR _3123_ sky130_fd_sc_hd__nand2b_1
X_6513_ net300 net447 net452 net294 VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_136_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_9_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_119_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9232_ clknet_leaf_31_clk net55 _0142_ VGND VGND VPWR VPWR adder_inst.i_b\[2\] sky130_fd_sc_hd__dfrtp_1
X_6444_ _2071_ _2072_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5762__B net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4659__A net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9163_ net526 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__inv_2
XANTENNA__7035__A net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6375_ _1999_ _2003_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__xor2_1
X_9094_ net536 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__inv_2
X_8114_ net642 _3662_ _3687_ VGND VGND VPWR VPWR _3688_ sky130_fd_sc_hd__a21o_1
XFILLER_115_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5326_ _0919_ _0920_ _0954_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a21o_1
XFILLER_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8045_ adder_inst.is_nan_r adder_inst.is_inf_r VGND VGND VPWR VPWR _3628_ sky130_fd_sc_hd__or2_2
XFILLER_102_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5257_ net367 net295 net301 net359 VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a22oi_1
XFILLER_130_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout484_A net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5188_ net263 net391 net269 net397 VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_3_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout272_X net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8947_ net535 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__inv_2
XFILLER_73_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8878_ net803 mul_res\[30\] net505 VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7829_ _3425_ _3433_ _3434_ VGND VGND VPWR VPWR _3435_ sky130_fd_sc_hd__nor3_4
XFILLER_51_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4917__A1 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5375__D net404 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5672__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input45_A i_b[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4719__D net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout192 net193 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__buf_2
Xfanout170 _3446_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_2
XANTENNA__7599__B _1158_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7398__A2 _3022_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5847__B net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5566__C net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5582__B net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6160_ net242 net247 net475 net481 VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__nand4_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_139_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5111_ _0722_ _0723_ _0739_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a21o_1
XFILLER_111_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7086__A1 net641 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7086__B2 net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6091_ net395 net331 net338 net389 VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__a22oi_2
XANTENNA__6694__A net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5042_ net355 net274 _0669_ _0670_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__a22o_1
XANTENNA__4844__B1 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8035__B1 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8801_ _4274_ _4307_ _3169_ VGND VGND VPWR VPWR _4308_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_0_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6993_ _2620_ _2621_ _2622_ VGND VGND VPWR VPWR _2623_ sky130_fd_sc_hd__nand3_2
XANTENNA__6061__A2 net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8732_ net767 net180 net176 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__and3_1
X_5944_ _1478_ _1480_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__nand2_1
X_8663_ _3956_ _3966_ _4219_ VGND VGND VPWR VPWR _4220_ sky130_fd_sc_hd__a21o_1
X_5875_ _1235_ _1251_ _1503_ _1504_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__a211oi_2
X_8594_ _3908_ _3906_ VGND VGND VPWR VPWR _4159_ sky130_fd_sc_hd__nand2b_1
X_4826_ _0453_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__nand2_2
X_7614_ _3243_ _3203_ _3221_ net109 VGND VGND VPWR VPWR _3244_ sky130_fd_sc_hd__and4_4
XANTENNA_fanout232_A net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5021__B1 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7561__A2 _3189_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7545_ _3021_ _3170_ _3026_ VGND VGND VPWR VPWR _3175_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_134_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4757_ net200 net378 VGND VGND VPWR VPWR _4528_ sky130_fd_sc_hd__nand2_1
XANTENNA__5195__D net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6869__A net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4688_ net220 net372 _4457_ VGND VGND VPWR VPWR _4459_ sky130_fd_sc_hd__a21oi_1
X_7476_ _3101_ _3105_ VGND VGND VPWR VPWR _3106_ sky130_fd_sc_hd__nor2_1
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6588__B net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9215_ clknet_leaf_4_clk net9 _0125_ VGND VGND VPWR VPWR adder_inst.i_a\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_104_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6427_ net424 net430 net311 net320 VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_116_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9146_ net531 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6358_ _1986_ _1987_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__nor2_1
XFILLER_103_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5309_ net220 net432 _0837_ _0838_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9077_ net538 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__inv_2
XFILLER_103_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6824__A1 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6289_ _1917_ _1918_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__and2b_1
XFILLER_130_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8028_ net500 net494 _3404_ adder_inst.sum_raw_r\[16\] net489 VGND VGND VPWR VPWR
+ _3613_ sky130_fd_sc_hd__a221o_1
XFILLER_102_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4836__B net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8308__B net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6824__B2 net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6052__A2 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5866__A2 net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4746__B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7122__B net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5858__A net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5660_ net383 net326 VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_100_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4611_ _4374_ _4381_ net345 net219 VGND VGND VPWR VPWR _4382_ sky130_fd_sc_hd__o211a_1
XFILLER_31_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5591_ _1210_ _1215_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__xnor2_1
XFILLER_129_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7330_ _2730_ _2732_ _2929_ _2959_ VGND VGND VPWR VPWR _2960_ sky130_fd_sc_hd__a211o_1
XFILLER_128_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7261_ _2872_ _2873_ _2879_ VGND VGND VPWR VPWR _2891_ sky130_fd_sc_hd__o21a_1
X_9000_ net535 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__inv_2
Xmax_cap167 _1501_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_1
X_6212_ _1828_ _1830_ _1841_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__and3_4
XANTENNA__6201__B net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7016__C net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7192_ _2714_ _2716_ _2715_ VGND VGND VPWR VPWR _2822_ sky130_fd_sc_hd__o21bai_1
XANTENNA__7059__A1 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7059__B2 net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6143_ _1656_ net595 _1673_ _1674_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_112_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6074_ _1677_ _1679_ _1701_ _1702_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__or4_4
X_5025_ _0649_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__xnor2_1
XFILLER_85_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6282__A2 net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5768__A net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout447_A net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6976_ _2603_ _2604_ _2605_ VGND VGND VPWR VPWR _2606_ sky130_fd_sc_hd__nand3b_1
X_8715_ _4079_ _4258_ VGND VGND VPWR VPWR _4265_ sky130_fd_sc_hd__nand2_1
XFILLER_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4596__A2 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5927_ net254 net425 VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__nand2_1
XFILLER_41_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout235_X net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8646_ _4202_ _4204_ net187 VGND VGND VPWR VPWR _4205_ sky130_fd_sc_hd__mux2_4
X_5858_ net219 net468 VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__nand2_1
X_4809_ _4545_ _0437_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__xor2_1
X_8577_ _4144_ net173 _4141_ VGND VGND VPWR VPWR _4145_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5789_ net348 net354 net332 net338 VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__and4_1
X_7528_ _4393_ _3150_ VGND VGND VPWR VPWR _3158_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout402_X net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7459_ _3045_ _3048_ _3088_ VGND VGND VPWR VPWR _3089_ sky130_fd_sc_hd__o21a_1
XFILLER_122_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9129_ net537 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__inv_2
XANTENNA__4847__A net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6765__C net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4757__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7133__A net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7787__B adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6830_ _2458_ _2459_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__nor2_1
XFILLER_62_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6761_ net305 net464 _2383_ _2382_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__a31o_1
X_8500_ _4072_ VGND VGND VPWR VPWR _4073_ sky130_fd_sc_hd__inv_2
XANTENNA__5100__B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5712_ net396 net402 net297 net302 VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_118_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9480_ clknet_leaf_28_clk net827 _0390_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
X_6692_ _2266_ _2268_ _2267_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__o21ai_1
XFILLER_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8431_ _4000_ _4002_ VGND VGND VPWR VPWR _4004_ sky130_fd_sc_hd__nor2_1
X_5643_ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__inv_2
XFILLER_136_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8362_ _3931_ _3932_ VGND VGND VPWR VPWR _3935_ sky130_fd_sc_hd__nand2_1
X_5574_ net266 net439 net445 net259 VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a22oi_1
Xhold201 adder_inst.exp_b\[1\] VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_129_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7313_ _2940_ _2941_ VGND VGND VPWR VPWR _2943_ sky130_fd_sc_hd__xnor2_1
XANTENNA__7027__B net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold234 _0012_ VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold212 add_res\[17\] VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlygate4sd3_1
X_8293_ net136 _3733_ _3808_ net140 VGND VGND VPWR VPWR _3866_ sky130_fd_sc_hd__a211o_1
Xhold223 add_res\[14\] VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlygate4sd3_1
Xhold245 mul_res\[31\] VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
Xhold256 add_res\[25\] VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 add_res\[28\] VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7244_ _2865_ _2868_ _2867_ VGND VGND VPWR VPWR _2874_ sky130_fd_sc_hd__a21boi_1
Xhold278 _0025_ VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold289 multiplier_inst.man_final_r\[9\] VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlygate4sd3_1
X_7175_ _0890_ _0891_ _0893_ VGND VGND VPWR VPWR _2805_ sky130_fd_sc_hd__a21oi_1
XFILLER_100_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout397_A net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6126_ net271 net450 VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__nand2_1
XFILLER_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout185_X net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6057_ _1264_ _1684_ _1685_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__or3_4
X_5008_ _0514_ _0521_ _0520_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21bo_1
XFILLER_73_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout352_X net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6959_ _2587_ _2588_ VGND VGND VPWR VPWR _2589_ sky130_fd_sc_hd__nor2_1
XFILLER_26_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8629_ _4169_ _3997_ _4007_ _3947_ _4189_ VGND VGND VPWR VPWR _4190_ sky130_fd_sc_hd__a41o_1
XFILLER_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_10_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__9206__Q adder_inst.i_a\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5680__B net389 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_leaf_25_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4727__D net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clone60_X net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_rebuffer88_X net637 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7400__B _2573_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6942__D _2570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5290_ _0849_ _0918_ _0912_ _0899_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o211ai_2
XANTENNA__7131__B1 net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_128_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8980_ net508 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__inv_2
X_7931_ _3528_ _3529_ net115 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__o21a_1
XFILLER_67_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5996__A1 net630 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5996__B2 net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7862_ net485 net197 _3435_ _3467_ VGND VGND VPWR VPWR _3468_ sky130_fd_sc_hd__a211o_1
XFILLER_63_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7793_ _4346_ _3386_ VGND VGND VPWR VPWR _3399_ sky130_fd_sc_hd__and2_1
XANTENNA__5748__A1 net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5748__B2 net389 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6813_ _2399_ _2416_ _2433_ _2441_ VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__o211ai_2
X_6744_ _2328_ _2334_ _2333_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__a21o_1
X_9463_ clknet_leaf_20_clk _0081_ _0373_ VGND VGND VPWR VPWR mul_res\[18\] sky130_fd_sc_hd__dfrtp_1
X_6675_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__inv_2
X_8414_ _3984_ _3986_ VGND VGND VPWR VPWR _3987_ sky130_fd_sc_hd__nand2_2
XANTENNA__4971__A2 net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7038__A net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5626_ net266 net446 net451 net259 VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a22oi_1
X_9394_ clknet_leaf_13_clk adder_inst.is_inf_a _0304_ VGND VGND VPWR VPWR adder_inst.is_inf_a_r
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout312_A net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8345_ net121 _3916_ VGND VGND VPWR VPWR _3918_ sky130_fd_sc_hd__nor2_1
XANTENNA__6299__D net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5557_ net259 net266 net433 net439 VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__and4_1
X_5488_ _1091_ _1092_ _1094_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__a21oi_1
X_8276_ net327 _3848_ net164 VGND VGND VPWR VPWR _3849_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_57_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7227_ net212 adder_inst.man_a_r\[6\] net449 net205 VGND VGND VPWR VPWR _2857_ sky130_fd_sc_hd__a22o_1
Xfanout522 net523 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__buf_2
XFILLER_132_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout500 adder_inst.sum_raw_r\[18\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout511 net523 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__clkbuf_4
Xfanout533 net534 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout544 net545 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_2
XFILLER_116_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7158_ _2680_ _2681_ VGND VGND VPWR VPWR _2788_ sky130_fd_sc_hd__xnor2_1
XFILLER_86_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7089_ _2617_ _2619_ _2618_ VGND VGND VPWR VPWR _2719_ sky130_fd_sc_hd__o21bai_1
X_6109_ net296 net426 net302 net420 VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__a22oi_1
XFILLER_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7220__B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer71 _1076_ VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__buf_1
XFILLER_82_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer82 _1409_ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer93 _3661_ VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__buf_6
XFILLER_14_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6219__A2 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4754__B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7130__B net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4790_ _4558_ _4559_ _4553_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a21bo_1
XFILLER_60_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5667__A2_N net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4920__D net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6460_ net265 net479 VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__nand2_1
XANTENNA__6155__A1 net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5411_ _0996_ _0997_ _1011_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o21ai_1
X_6391_ _1932_ _1933_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__xnor2_2
X_8130_ net151 net149 net148 _3702_ VGND VGND VPWR VPWR _3704_ sky130_fd_sc_hd__or4_4
X_5342_ _0865_ _0874_ _0960_ _0969_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a211oi_2
X_8061_ net186 _3421_ VGND VGND VPWR VPWR _3640_ sky130_fd_sc_hd__nand2_1
XFILLER_114_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_110_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5273_ net641 net273 VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nand2_1
X_7012_ _1548_ _1562_ _1563_ _1566_ VGND VGND VPWR VPWR _2642_ sky130_fd_sc_hd__a31o_1
XFILLER_114_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6863__C net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8963_ net540 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_108_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4641__A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8894_ net512 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout262_A net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7914_ adder_inst.sum_raw_r\[5\] _3383_ _3513_ _3514_ VGND VGND VPWR VPWR _3515_
+ sky130_fd_sc_hd__o22a_1
XANTENNA__8851__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7845_ _3385_ _3395_ net193 VGND VGND VPWR VPWR _3451_ sky130_fd_sc_hd__a21oi_1
XANTENNA__4641__B2 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5197__A2 net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4988_ net375 net262 net268 net368 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a22o_1
X_7776_ net194 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3382_ sky130_fd_sc_hd__and2_1
XANTENNA__4830__D net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6727_ _2340_ _2347_ _2354_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__and3_1
X_9446_ clknet_leaf_29_clk _0083_ _0356_ VGND VGND VPWR VPWR mul_res\[1\] sky130_fd_sc_hd__dfrtp_1
X_6658_ _2285_ _2287_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout315_X net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9377_ clknet_leaf_16_clk _0051_ _0287_ VGND VGND VPWR VPWR add_res\[23\] sky130_fd_sc_hd__dfrtp_1
X_5609_ net225 net231 net462 net468 VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__and4_1
X_8328_ net127 _3809_ _3810_ _3900_ VGND VGND VPWR VPWR _3901_ sky130_fd_sc_hd__a31oi_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6589_ net289 net464 VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__nand2_1
XFILLER_105_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_807 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8259_ net655 _3755_ _3753_ net137 VGND VGND VPWR VPWR _3832_ sky130_fd_sc_hd__o211a_1
Xfanout341 net344 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkbuf_4
Xfanout330 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__clkbuf_2
Xfanout374 net376 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkbuf_4
Xfanout352 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
XANTENNA__4855__A net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout363 net364 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__buf_4
XFILLER_74_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout385 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_6
Xfanout396 net553 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4632__A1 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4590__A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8997__A net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4935__A2 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput16 i_a[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput27 i_a[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput49 i_b[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
Xinput38 i_b[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_124_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4749__B net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6964__B net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5960_ net232 net451 net457 net226 VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__a22oi_1
XANTENNA__5299__C net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4911_ net222 net416 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_121_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5891_ _1515_ _1519_ _1520_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__nand3_1
X_7630_ _3259_ VGND VGND VPWR VPWR _3260_ sky130_fd_sc_hd__inv_2
XANTENNA__5596__A net243 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4842_ net368 net274 VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand2_1
XANTENNA__4931__C net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7573__A0 _3197_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4773_ net343 net256 VGND VGND VPWR VPWR _4544_ sky130_fd_sc_hd__nand2_1
X_7561_ net618 _3189_ _3190_ VGND VGND VPWR VPWR _3191_ sky130_fd_sc_hd__o21a_1
XFILLER_21_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9300_ clknet_leaf_3_clk net697 _0210_ VGND VGND VPWR VPWR adder_inst.man_a_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
X_7492_ _3068_ _3071_ _3120_ VGND VGND VPWR VPWR _3122_ sky130_fd_sc_hd__or3b_1
X_6512_ net294 net300 net447 net452 VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_136_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9231_ clknet_leaf_31_clk net44 _0141_ VGND VGND VPWR VPWR adder_inst.i_b\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6443_ _2071_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__nand2b_1
X_9162_ net539 VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__inv_2
XANTENNA__4659__B net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5762__C net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6374_ _1999_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__nand2_1
X_9093_ net519 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__inv_2
XANTENNA__9304__Q adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8113_ _3298_ _3305_ _3656_ VGND VGND VPWR VPWR _3687_ sky130_fd_sc_hd__and3_1
X_5325_ _0919_ _0920_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand3_2
XANTENNA__7628__A1 _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7035__B net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8044_ adder_inst.is_zero_r _3469_ VGND VGND VPWR VPWR _3627_ sky130_fd_sc_hd__nor2_1
XFILLER_88_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5256_ net373 net292 VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nand2_1
XFILLER_102_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4675__A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5187_ _0567_ _0573_ _0572_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__a21o_1
XFILLER_56_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout477_A net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8946_ net519 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__inv_2
XFILLER_73_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout265_X net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8877_ net810 mul_res\[29\] net505 VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7828_ _3426_ _3427_ _3429_ VGND VGND VPWR VPWR _3434_ sky130_fd_sc_hd__or3_1
XANTENNA_fanout432_X net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6367__A1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7759_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] adder_inst.exp_b\[3\] adder_inst.exp_b\[2\]
+ VGND VGND VPWR VPWR _3373_ sky130_fd_sc_hd__and4_1
XANTENNA__4917__A2 net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9429_ clknet_leaf_27_clk multiplier_inst.man_final\[17\] _0339_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_138_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7226__A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input38_A i_b[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_2
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_2
Xfanout171 _3382_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout193 _4340_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7111__D net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5566__D net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5582__C net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5110_ _0722_ _0723_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nand3_2
XFILLER_111_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7086__A2 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6090_ net402 net327 VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__nand2_1
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5041_ net355 net274 _0669_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__nand4_2
XFILLER_97_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4844__A1 net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4844__B2 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8035__A1 net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8800_ net340 net482 _3153_ _4306_ VGND VGND VPWR VPWR _4307_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_0_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8731_ net819 net180 net176 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__and3_1
XFILLER_53_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6992_ _1549_ _1551_ _1550_ VGND VGND VPWR VPWR _2622_ sky130_fd_sc_hd__o21bai_2
XANTENNA__6061__A3 net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5943_ _1486_ _1501_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__nor2_1
X_8662_ _4218_ VGND VGND VPWR VPWR _4219_ sky130_fd_sc_hd__inv_2
XFILLER_61_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6349__A1 net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6349__B2 net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5874_ net167 _1502_ _1405_ _1407_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__o211a_1
XANTENNA__5021__A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4825_ _0444_ _0447_ _0453_ _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__o211ai_2
X_8593_ _3911_ _4158_ VGND VGND VPWR VPWR adder_inst.sum_raw\[7\] sky130_fd_sc_hd__xor2_1
X_7613_ _3232_ _3235_ _3238_ _3240_ VGND VGND VPWR VPWR _3243_ sky130_fd_sc_hd__nor4b_2
XANTENNA__5021__B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7544_ _3021_ _3170_ _3026_ VGND VGND VPWR VPWR _3174_ sky130_fd_sc_hd__o21a_1
XFILLER_21_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4756_ _4525_ _4526_ VGND VGND VPWR VPWR _4527_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout225_A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4687_ net220 net372 _4457_ VGND VGND VPWR VPWR _4458_ sky130_fd_sc_hd__and3_1
X_7475_ _3103_ _3104_ VGND VGND VPWR VPWR _3105_ sky130_fd_sc_hd__or2_1
X_9214_ clknet_leaf_5_clk net8 _0124_ VGND VGND VPWR VPWR adder_inst.i_a\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_119_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6426_ net438 net306 VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_116_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9145_ net532 VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6357_ net424 net314 net320 net418 VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__a22oi_1
X_5308_ _0831_ _0921_ _0936_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9076_ net545 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__inv_2
XFILLER_103_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6288_ _1834_ _1916_ _1915_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__a21o_1
XFILLER_130_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout382_X net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8027_ adder_inst.sum_raw_r\[14\] adder_inst.sum_raw_r\[15\] net501 VGND VGND VPWR
+ VPWR _3612_ sky130_fd_sc_hd__mux2_1
XFILLER_102_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4836__C net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5239_ _0858_ _0861_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__o21a_1
XFILLER_76_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8577__A2 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8929_ net511 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__inv_2
XFILLER_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6125__A net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6795__A net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8017__A1 net486 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8568__A2 _4115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5251__A1 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5858__B net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4610_ _4379_ _4380_ VGND VGND VPWR VPWR _4381_ sky130_fd_sc_hd__nor2_1
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5590_ _1217_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__or2_1
XFILLER_128_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap102 _4320_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_6
X_7260_ _2885_ _2889_ VGND VGND VPWR VPWR _2890_ sky130_fd_sc_hd__or2_4
XANTENNA__6503__A1 net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap146 _1018_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_2
XFILLER_104_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7191_ _0902_ _0904_ _0903_ VGND VGND VPWR VPWR _2821_ sky130_fd_sc_hd__o21ai_1
XANTENNA__6503__B2 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6211_ _1835_ _1840_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6201__C net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7016__D net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6142_ _1753_ _1769_ _1770_ _1752_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__o31a_1
XFILLER_124_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6073_ _1677_ _1679_ _1701_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__nor4_1
XFILLER_39_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5024_ _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__xor2_1
XFILLER_100_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6975_ net573 net294 net300 net373 VGND VGND VPWR VPWR _2605_ sky130_fd_sc_hd__a22o_1
XFILLER_110_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout342_A net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8714_ net188 _4261_ _4082_ _4263_ _4078_ VGND VGND VPWR VPWR _4264_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_62_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5926_ _1552_ _1553_ _1554_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__a21o_1
XFILLER_13_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8645_ _3977_ _3987_ _4190_ _4203_ VGND VGND VPWR VPWR _4204_ sky130_fd_sc_hd__a31oi_1
XFILLER_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5857_ _1484_ _1485_ _1474_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_32_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4808_ _4545_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__and2b_1
X_8576_ net671 _4142_ _4143_ VGND VGND VPWR VPWR _4144_ sky130_fd_sc_hd__a21oi_2
X_5788_ net347 net328 VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7527_ _3154_ _3156_ VGND VGND VPWR VPWR _3157_ sky130_fd_sc_hd__nand2_1
X_4739_ _4497_ _4502_ _4496_ VGND VGND VPWR VPWR _4510_ sky130_fd_sc_hd__a21oi_1
X_7458_ net345 net219 _4374_ _3087_ VGND VGND VPWR VPWR _3088_ sky130_fd_sc_hd__a31oi_1
X_6409_ _1962_ _2037_ _2036_ _2029_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__o211ai_2
X_7389_ _3016_ _3017_ VGND VGND VPWR VPWR _3019_ sky130_fd_sc_hd__xnor2_2
XFILLER_135_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9128_ net537 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__inv_2
XFILLER_103_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4847__B net369 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9059_ net541 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__inv_2
XFILLER_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6765__D net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5959__A net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4757__B net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7133__B net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4773__A net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6760_ _2335_ _2374_ _2389_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__nand3_2
XFILLER_62_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5711_ net408 net291 VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__nand2_1
X_6691_ _2271_ _2277_ _2276_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__a21o_1
XFILLER_31_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8430_ _3998_ _3999_ _4001_ VGND VGND VPWR VPWR _4003_ sky130_fd_sc_hd__or3_1
X_5642_ net225 net231 net474 net480 VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__and4_1
XFILLER_31_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8361_ _3931_ _3932_ VGND VGND VPWR VPWR _3934_ sky130_fd_sc_hd__and2_1
X_5573_ net259 net266 net439 net445 VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__and4_1
Xhold202 adder_inst.exp_b\[3\] VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_129_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7312_ _2854_ _2862_ _2940_ VGND VGND VPWR VPWR _2942_ sky130_fd_sc_hd__o21ai_1
Xhold235 add_res\[26\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 _0008_ VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlygate4sd3_1
X_8292_ net135 _3738_ _3812_ net138 VGND VGND VPWR VPWR _3865_ sky130_fd_sc_hd__a211o_1
Xhold224 _0005_ VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlygate4sd3_1
Xhold246 _0024_ VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
Xhold257 _0017_ VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd3_1
Xhold268 _0020_ VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7243_ _0958_ _2803_ _2835_ _2871_ VGND VGND VPWR VPWR _2873_ sky130_fd_sc_hd__o211a_1
XANTENNA__8229__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold279 add_res\[11\] VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlygate4sd3_1
X_7174_ _0912_ _0913_ _0914_ _0896_ VGND VGND VPWR VPWR _2804_ sky130_fd_sc_hd__a22oi_2
XFILLER_131_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8854__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6125_ net279 net286 net441 net445 VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__and4_1
XFILLER_112_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout292_A adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6056_ _1264_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout178_X net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5007_ _0634_ _0635_ _0627_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a21o_1
XFILLER_100_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout345_X net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6958_ net347 net325 net330 net341 VGND VGND VPWR VPWR _2588_ sky130_fd_sc_hd__a22oi_1
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4974__B1 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6889_ _2495_ _2518_ VGND VGND VPWR VPWR _2519_ sky130_fd_sc_hd__nor2_1
XFILLER_22_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5909_ _1533_ _1537_ _1538_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__and3_1
XFILLER_139_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8628_ _3997_ _4188_ _4187_ VGND VGND VPWR VPWR _4189_ sky130_fd_sc_hd__a21o_1
XFILLER_10_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_hold302_A adder_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8559_ _3854_ _4123_ VGND VGND VPWR VPWR _4129_ sky130_fd_sc_hd__nand2b_1
XFILLER_10_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4577__B adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5680__C net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7979__A0 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input20_A i_a[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7400__C _2568_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7131__B2 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7131__A1 net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7930_ net483 adder_inst.sum_raw_r\[8\] _3526_ _3527_ VGND VGND VPWR VPWR _3529_
+ sky130_fd_sc_hd__a22o_1
XFILLER_83_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7861_ net197 _3383_ VGND VGND VPWR VPWR _3467_ sky130_fd_sc_hd__nor2_1
XFILLER_48_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6812_ _2433_ _2441_ _2399_ _2416_ VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_34_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7792_ net497 net499 VGND VGND VPWR VPWR _3398_ sky130_fd_sc_hd__nor2_1
XFILLER_91_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5748__A2 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4956__B1 net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5205__A2_N net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6743_ _2337_ _2349_ _2348_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__a21oi_1
X_9462_ clknet_leaf_20_clk _0080_ _0372_ VGND VGND VPWR VPWR mul_res\[17\] sky130_fd_sc_hd__dfrtp_1
X_6674_ _2295_ _2303_ _2240_ _2262_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__a211o_1
X_8413_ _3980_ _3982_ VGND VGND VPWR VPWR _3986_ sky130_fd_sc_hd__or2_1
XANTENNA__7038__B net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_51_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5625_ net259 net266 net446 net451 VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__and4_1
X_9393_ clknet_leaf_10_clk adder_inst.exp_larger\[7\] _0303_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__8849__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8344_ _3916_ VGND VGND VPWR VPWR _3917_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout305_A net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5556_ net253 net445 VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__nand2_1
X_5487_ _1097_ _1105_ _1104_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__a21oi_2
XFILLER_117_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8275_ net120 _3836_ _3843_ _3847_ VGND VGND VPWR VPWR _3848_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_57_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7226_ net205 net212 net444 net449 VGND VGND VPWR VPWR _2856_ sky130_fd_sc_hd__and4_1
Xfanout523 net67 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__buf_4
Xfanout512 net518 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__buf_4
Xfanout501 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout545 net548 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout534 net549 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__buf_2
XFILLER_86_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout295_X net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7157_ _1612_ _1617_ _1611_ VGND VGND VPWR VPWR _2787_ sky130_fd_sc_hd__o21ba_1
XFILLER_100_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7088_ _2715_ _2716_ _2714_ VGND VGND VPWR VPWR _2718_ sky130_fd_sc_hd__o21ai_1
X_6108_ net290 net434 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__nand2_1
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout462_X net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6039_ _1666_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__and2_1
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7220__C net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer72 _1067_ VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__buf_6
Xrebuffer50 net598 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer61 _2191_ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__buf_1
Xrebuffer94 net642 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_68_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer83 _1411_ VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA__8138__A0 net560 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7890__C adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4588__A net352 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_749 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5212__A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4754__C net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7130__C net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_123_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6155__A2 net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5410_ _0728_ _0735_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__a21oi_1
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6390_ _2018_ _2019_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__and2_1
XFILLER_114_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5341_ _0960_ _0969_ _0865_ _0874_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__o211a_1
X_8060_ _3412_ _3632_ _3633_ _3418_ net488 VGND VGND VPWR VPWR _3639_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_110_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5272_ net573 net385 net276 net284 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__and4_1
X_7011_ _1586_ _1603_ VGND VGND VPWR VPWR _2641_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_52_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8962_ net540 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__inv_2
XFILLER_55_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6863__D net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6218__A net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7913_ adder_inst.sum_raw_r\[4\] net487 _3462_ adder_inst.sum_raw_r\[3\] _3394_ VGND
+ VGND VPWR VPWR _3514_ sky130_fd_sc_hd__a221o_1
XANTENNA__6091__A1 net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6091__B2 net389 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8893_ net512 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__inv_2
XFILLER_55_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7844_ net183 _3444_ _3449_ VGND VGND VPWR VPWR _3450_ sky130_fd_sc_hd__o21a_1
XFILLER_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout255_A adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_47_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7775_ _3371_ _3375_ _3376_ VGND VGND VPWR VPWR adder_inst.is_nan_a sky130_fd_sc_hd__and3b_1
XFILLER_51_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4987_ net368 net375 net262 net268 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__and4_1
XANTENNA_clkbuf_leaf_24_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6726_ _2355_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout422_A net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9445_ clknet_leaf_29_clk _0072_ _0355_ VGND VGND VPWR VPWR mul_res\[0\] sky130_fd_sc_hd__dfrtp_1
X_6657_ net299 net458 net464 net293 VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__a22oi_1
X_9376_ clknet_leaf_17_clk _0050_ _0286_ VGND VGND VPWR VPWR add_res\[22\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout210_X net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6588_ net293 net299 net452 net458 VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__and4_1
X_5608_ net219 net475 VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout308_X net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8327_ net143 _3788_ _3789_ VGND VGND VPWR VPWR _3900_ sky130_fd_sc_hd__and3_1
X_5539_ net407 net414 net297 net302 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__and4_1
XFILLER_127_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_787 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8258_ _3828_ _3830_ VGND VGND VPWR VPWR _3831_ sky130_fd_sc_hd__nor2_1
XFILLER_79_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5657__A1 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8189_ _3761_ _3762_ net136 VGND VGND VPWR VPWR _3763_ sky130_fd_sc_hd__mux2_1
X_7209_ _0929_ _0931_ _0930_ VGND VGND VPWR VPWR _2839_ sky130_fd_sc_hd__o21ai_1
XANTENNA__5657__B2 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout320 net321 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_4
Xfanout331 net333 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_4
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_2
Xfanout364 adder_inst.man_a_r\[20\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__buf_8
Xfanout342 net343 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__buf_2
XANTENNA__4855__B net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout353 net358 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__buf_2
XANTENNA__8071__A2 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout386 net388 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__buf_2
XFILLER_86_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout397 net553 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4632__A2 net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8359__A0 net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6028__A1_N net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4590__B net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 i_a[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 i_a[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6798__A net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput39 i_b[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XANTENNA__6013__D net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_94_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5207__A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7422__A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6964__C net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9410__Q multiplier_inst.is_nan_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_125_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4910_ _0538_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2b_1
XFILLER_46_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5890_ _1517_ _1518_ _1516_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__a21o_1
X_4841_ _0464_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and2_1
XFILLER_61_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5596__B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4931__D net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4772_ _4478_ _4508_ VGND VGND VPWR VPWR _4543_ sky130_fd_sc_hd__and2_1
X_7560_ _4370_ net131 net562 _3187_ VGND VGND VPWR VPWR _3190_ sky130_fd_sc_hd__a31o_1
X_7491_ _3068_ _3071_ _3120_ VGND VGND VPWR VPWR _3121_ sky130_fd_sc_hd__o21ba_1
X_6511_ net293 net300 net447 net452 VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_136_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9230_ clknet_leaf_0_clk net33 _0140_ VGND VGND VPWR VPWR adder_inst.i_b\[0\] sky130_fd_sc_hd__dfrtp_1
X_6442_ _1996_ _1998_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__xnor2_1
X_9161_ net539 VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__inv_2
XFILLER_106_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8112_ _3298_ _3684_ _3683_ VGND VGND VPWR VPWR _3686_ sky130_fd_sc_hd__and3_1
XANTENNA__5762__D net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6373_ _2000_ _2001_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__xnor2_1
X_9092_ net537 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__inv_2
XFILLER_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5324_ _0937_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__or2_1
XANTENNA__7035__C net463 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8043_ net198 _3626_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and2_1
XFILLER_102_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8428__A net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5255_ net359 net367 net295 net301 VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__and4_1
XFILLER_87_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5186_ _0591_ _0813_ _0807_ _0794_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__o211ai_2
XFILLER_84_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8589__B1 _4115_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4675__B net344 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout372_A net583 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_3_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8945_ net519 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__inv_2
XFILLER_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8876_ net816 mul_res\[28\] net505 VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__mux2_1
XFILLER_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5787__A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout258_X net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7827_ adder_inst.sum_raw_r\[2\] net496 net182 VGND VGND VPWR VPWR _3433_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_65_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8761__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6367__A2 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7758_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r net175 net824 adder_inst.is_nan_b_r
+ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__a311o_1
XANTENNA_fanout425_X net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_22_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6772__C1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7689_ net113 _3286_ _3314_ VGND VGND VPWR VPWR _3315_ sky130_fd_sc_hd__and3_1
X_6709_ _2286_ _2288_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__xnor2_1
X_9428_ clknet_leaf_26_clk multiplier_inst.man_final\[16\] _0338_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7226__B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_732 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9359_ clknet_leaf_27_clk _0063_ _0269_ VGND VGND VPWR VPWR add_res\[5\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__4866__A net379 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout183 _3430_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_2
Xfanout161 _3666_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_2
Xfanout172 _3382_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_2
Xfanout194 _4336_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8073__A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7417__A net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6321__A net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clone122_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5582__D net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5040_ net349 net280 net287 net343 VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a22o_1
XANTENNA__4844__A2 net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6991_ _2618_ _2619_ _2617_ VGND VGND VPWR VPWR _2621_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_0_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8730_ multiplier_inst.overflow_calc_r multiplier_inst.is_zero_r VGND VGND VPWR VPWR
+ _4270_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_105_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5942_ _1569_ _1570_ _1447_ _1470_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__o211ai_2
XANTENNA__6061__A4 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8661_ _3949_ _3950_ _3952_ _3957_ _4207_ VGND VGND VPWR VPWR _4218_ sky130_fd_sc_hd__o32a_1
X_5873_ _1405_ _1407_ net167 _1502_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_138_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4824_ _4509_ _4543_ _0442_ _0452_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__o211ai_2
X_8592_ net187 _4153_ _4154_ _4157_ VGND VGND VPWR VPWR _4158_ sky130_fd_sc_hd__a31o_1
X_7612_ _3238_ _3241_ VGND VGND VPWR VPWR _3242_ sky130_fd_sc_hd__nor2_1
XFILLER_61_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5021__A2 net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4755_ net215 net365 net372 net210 VGND VGND VPWR VPWR _4526_ sky130_fd_sc_hd__a22oi_1
X_7543_ net110 _3171_ _3160_ _3162_ _3168_ VGND VGND VPWR VPWR _3173_ sky130_fd_sc_hd__a2111o_1
XFILLER_21_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4780__A1 net361 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9213_ clknet_leaf_3_clk net7 _0123_ VGND VGND VPWR VPWR adder_inst.i_a\[15\] sky130_fd_sc_hd__dfrtp_1
X_4686_ _4455_ _4456_ VGND VGND VPWR VPWR _4457_ sky130_fd_sc_hd__nor2_1
X_7474_ _3059_ _3092_ VGND VGND VPWR VPWR _3104_ sky130_fd_sc_hd__xor2_1
XANTENNA__6588__D net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8857__S net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6425_ _1980_ _2053_ _2052_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_116_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9144_ net531 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__inv_2
XANTENNA__6381__A2_N net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6356_ net418 net424 net314 net320 VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__and4_1
X_9075_ net538 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__inv_2
XFILLER_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5307_ _0831_ _0921_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__and3_1
X_8026_ net116 _3611_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__and2_1
XFILLER_103_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6287_ _1834_ _1915_ _1916_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__and3_1
X_5238_ _0866_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nor2_1
XFILLER_69_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout375_X net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5169_ net573 net277 net284 net373 VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a22oi_2
XFILLER_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout542_X net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8928_ net512 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
XFILLER_83_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8859_ net828 mul_res\[11\] net504 VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__mux2_1
XFILLER_71_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6125__B net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input50_A i_b[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6795__B net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5251__A2 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6316__A net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_711 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7218__A1_N net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_10_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_13_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6051__A net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6503__A2 net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xmax_cap147 _0854_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_6
X_7190_ _0894_ _2805_ _2818_ VGND VGND VPWR VPWR _2820_ sky130_fd_sc_hd__o21bai_1
X_6210_ _1838_ _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__nand2b_1
XANTENNA__6201__D net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6141_ _1751_ _1770_ _1769_ _1753_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__or4_4
XFILLER_98_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6072_ _1699_ _1700_ net587 _1697_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__o211a_1
X_5023_ net202 net428 VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__nand2_1
XFILLER_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7767__B2 adder_inst.is_zero_b_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6974_ net373 net574 net294 net300 VGND VGND VPWR VPWR _2604_ sky130_fd_sc_hd__nand4_1
XFILLER_110_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8713_ net174 _4077_ VGND VGND VPWR VPWR _4263_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_62_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5925_ _1552_ _1553_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__nand3_2
X_8644_ _3972_ _3973_ _3987_ _3983_ _3980_ VGND VGND VPWR VPWR _4203_ sky130_fd_sc_hd__a32o_1
X_5856_ _1474_ _1484_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__and3_1
X_4807_ _0421_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__nand2b_1
XANTENNA_fanout335_A net337 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8575_ _3894_ _4098_ net683 _3892_ VGND VGND VPWR VPWR _4143_ sky130_fd_sc_hd__o211a_1
XANTENNA__7057__A net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5787_ net364 net326 VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__nand2_1
X_7526_ net168 net572 VGND VGND VPWR VPWR _3156_ sky130_fd_sc_hd__or2_1
X_4738_ _4478_ _4508_ VGND VGND VPWR VPWR _4509_ sky130_fd_sc_hd__nor2_2
XFILLER_119_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4669_ _4438_ _4439_ VGND VGND VPWR VPWR _4440_ sky130_fd_sc_hd__xnor2_1
X_7457_ net351 net221 net226 net346 VGND VGND VPWR VPWR _3087_ sky130_fd_sc_hd__a22oi_1
XFILLER_123_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6408_ _2029_ _2036_ _2037_ _1962_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__a211o_2
X_9127_ net537 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_79_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7388_ _3016_ _3017_ VGND VGND VPWR VPWR _3018_ sky130_fd_sc_hd__nor2_1
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4847__C net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6339_ _1964_ _1967_ _1968_ _1885_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__a211o_4
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9058_ net541 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__inv_2
XFILLER_103_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8009_ net502 net189 _3463_ adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR _3597_
+ sky130_fd_sc_hd__o22a_1
XFILLER_48_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5959__B net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_88_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clone43_A net113 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5215__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4773__B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5710_ _1309_ _1311_ _1310_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__o21bai_1
XANTENNA__8174__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6690_ _2280_ _2292_ _2291_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__a21oi_1
X_5641_ net231 net480 VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__nand2_1
XFILLER_129_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8360_ _3931_ _3932_ VGND VGND VPWR VPWR _3933_ sky130_fd_sc_hd__nor2_1
X_5572_ net253 net450 VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__nand2_1
X_8291_ _3862_ _3863_ VGND VGND VPWR VPWR _3864_ sky130_fd_sc_hd__and2_1
X_7311_ _2854_ _2862_ VGND VGND VPWR VPWR _2941_ sky130_fd_sc_hd__nor2_1
XFILLER_8_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold203 adder_inst.exp_b\[0\] VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlygate4sd3_1
Xhold214 multiplier_inst.exp_final_r\[0\] VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 add_res\[10\] VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlygate4sd3_1
X_7242_ _2871_ _2835_ _0958_ _2803_ VGND VGND VPWR VPWR _2872_ sky130_fd_sc_hd__a211oi_4
Xhold258 add_res\[23\] VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlygate4sd3_1
Xhold236 _0018_ VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
Xhold247 add_res\[27\] VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold269 multiplier_inst.man_final_r\[2\] VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7173_ _0955_ _0956_ _0957_ _0917_ VGND VGND VPWR VPWR _2803_ sky130_fd_sc_hd__a22oi_2
X_6124_ _1660_ _1662_ _1661_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__o21ai_1
XANTENNA__7988__A1 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_55_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6055_ net237 net474 _1262_ _1263_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__o2bb2a_1
X_5006_ _0627_ _0634_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__nand3_1
XFILLER_85_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout285_A net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8870__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout452_A net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_37_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6957_ net347 net341 net325 net330 VGND VGND VPWR VPWR _2587_ sky130_fd_sc_hd__and4_1
XFILLER_26_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout240_X net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5795__A net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4974__B2 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4974__A1 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6888_ net324 net473 _2493_ _2494_ VGND VGND VPWR VPWR _2518_ sky130_fd_sc_hd__o2bb2a_1
X_5908_ _1535_ _1536_ _1534_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__a21bo_1
X_8627_ _4008_ _4174_ _4003_ VGND VGND VPWR VPWR _4188_ sky130_fd_sc_hd__o21ai_1
X_5839_ _1466_ _1467_ _1449_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a21o_1
XFILLER_10_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout505_X net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8558_ _3854_ _4095_ _3853_ VGND VGND VPWR VPWR _4128_ sky130_fd_sc_hd__o21ba_1
XFILLER_10_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7509_ _3136_ _3138_ VGND VGND VPWR VPWR _3139_ sky130_fd_sc_hd__and2b_1
X_8489_ net637 net160 VGND VGND VPWR VPWR _4062_ sky130_fd_sc_hd__or2_1
XFILLER_107_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5680__D net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_rebuffer90_A net641 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input13_A i_a[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7425__A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7131__A2 net454 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4784__A net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4653__B1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7860_ _3462_ _3464_ net197 VGND VGND VPWR VPWR _3466_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6811_ _2433_ _2438_ _2439_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_34_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7791_ _3388_ _3396_ net493 VGND VGND VPWR VPWR _3397_ sky130_fd_sc_hd__o21ai_1
XFILLER_63_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4956__B2 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4956__A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6742_ _2352_ _2359_ _2358_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__a21o_1
X_9461_ clknet_leaf_20_clk _0079_ _0371_ VGND VGND VPWR VPWR mul_res\[16\] sky130_fd_sc_hd__dfrtp_1
X_6673_ _2295_ _2300_ _2301_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__nand3_1
XFILLER_31_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9392_ clknet_leaf_15_clk adder_inst.exp_larger\[6\] _0302_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[6\]
+ sky130_fd_sc_hd__dfrtp_2
X_8412_ _3980_ _3982_ VGND VGND VPWR VPWR _3985_ sky130_fd_sc_hd__nor2_1
X_5624_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__inv_2
X_8343_ net144 net138 _3728_ _3763_ VGND VGND VPWR VPWR _3916_ sky130_fd_sc_hd__or4b_1
XFILLER_129_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5555_ _1178_ _1183_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__xnor2_1
X_5486_ _1109_ _1111_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__xnor2_2
XFILLER_104_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8274_ net144 _3844_ _3845_ net122 net119 VGND VGND VPWR VPWR _3847_ sky130_fd_sc_hd__o2111a_1
XANTENNA_fanout200_A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8865__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7225_ _2849_ _2853_ VGND VGND VPWR VPWR _2855_ sky130_fd_sc_hd__xnor2_1
XANTENNA__9323__Q adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout513 net518 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__buf_4
Xfanout502 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_2
Xfanout524 net534 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7156_ _2581_ _2785_ VGND VGND VPWR VPWR _2786_ sky130_fd_sc_hd__xnor2_1
Xfanout535 net536 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__buf_4
XANTENNA_input5_A i_a[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout546 net547 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__buf_4
XFILLER_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6107_ net420 net296 net426 net302 VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__and4_1
XANTENNA_fanout288_X net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7087_ _2714_ _2715_ _2716_ VGND VGND VPWR VPWR _2717_ sky130_fd_sc_hd__or3_1
XFILLER_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_717 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6038_ _1257_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__nor2_1
XFILLER_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7220__D net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer51 net599 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer40 _1883_ VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer62 _2112_ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__clkbuf_1
Xrebuffer73 _1719_ VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA_fanout455_X net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer95 net650 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__buf_6
X_7989_ net483 adder_inst.sum_raw_r\[16\] net171 adder_inst.sum_raw_r\[15\] _3579_
+ VGND VGND VPWR VPWR _3580_ sky130_fd_sc_hd__a221o_1
XFILLER_81_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer84 _1414_ VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8138__A1 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4588__B net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_20_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6888__A1_N net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5212__B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7130__D net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_123_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5340_ _0960_ _0967_ _0968_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__or3_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5271_ _0797_ _0799_ _0798_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7010_ _2583_ _2638_ VGND VGND VPWR VPWR _2640_ sky130_fd_sc_hd__xnor2_2
XANTENNA__4874__B1 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8065__B1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8961_ net540 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__inv_2
XFILLER_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8136__D net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7912_ adder_inst.sum_raw_r\[2\] net191 _3413_ _3512_ VGND VGND VPWR VPWR _3513_
+ sky130_fd_sc_hd__o211a_1
XANTENNA__6218__B net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8892_ net510 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__inv_2
XFILLER_36_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7843_ _3387_ _3399_ _3446_ _3447_ _3448_ VGND VGND VPWR VPWR _3449_ sky130_fd_sc_hd__o32a_1
XFILLER_102_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7774_ _3363_ _3373_ _3374_ VGND VGND VPWR VPWR adder_inst.is_nan_b sky130_fd_sc_hd__and3b_1
X_4986_ net381 net256 VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nand2_1
XFILLER_63_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout248_A net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6725_ _2340_ _2347_ _2354_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__a21oi_1
XFILLER_137_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9444_ clknet_leaf_17_clk _0104_ _0354_ VGND VGND VPWR VPWR mul_ovf sky130_fd_sc_hd__dfrtp_1
XFILLER_109_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout415_A net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6656_ net289 net470 VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__nand2_1
X_9375_ clknet_leaf_18_clk _0049_ _0285_ VGND VGND VPWR VPWR add_res\[21\] sky130_fd_sc_hd__dfrtp_1
X_6587_ _2213_ _2215_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__xor2_1
X_5607_ net214 net480 VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__nand2_1
XFILLER_133_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8326_ net125 _3803_ _3804_ net124 VGND VGND VPWR VPWR _3899_ sky130_fd_sc_hd__a31o_1
XANTENNA_fanout203_X net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5538_ _1162_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__nand2b_1
XFILLER_133_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8257_ _3822_ _3823_ _3825_ _3826_ VGND VGND VPWR VPWR _3830_ sky130_fd_sc_hd__o22a_1
XFILLER_133_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5469_ _1002_ _1048_ _1050_ _1057_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__o31a_1
XFILLER_87_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7208_ net255 net413 _2724_ _2723_ VGND VGND VPWR VPWR _2838_ sky130_fd_sc_hd__a31o_1
XANTENNA__5657__A2 net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8188_ net352 net208 net166 VGND VGND VPWR VPWR _3762_ sky130_fd_sc_hd__mux2_1
XFILLER_99_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout310 net312 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__buf_2
Xfanout332 net333 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__buf_4
Xfanout321 net322 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__clkbuf_4
Xfanout343 net344 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__buf_2
XFILLER_101_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout354 net358 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_2
Xfanout365 net551 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_4
XFILLER_59_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7139_ _2633_ _2635_ _2767_ _2768_ VGND VGND VPWR VPWR _2769_ sky130_fd_sc_hd__a211o_1
Xfanout398 net399 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__buf_6
Xfanout376 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkbuf_4
Xfanout387 net388 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__buf_2
XANTENNA__4855__C net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_6_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5593__A1 net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput18 i_a[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput29 i_a[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_109_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5207__B net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9190__A net548 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4856__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7422__B net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6964__D net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_125_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4840_ _0465_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_44_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5596__C net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4771_ _4540_ _4541_ VGND VGND VPWR VPWR _4542_ sky130_fd_sc_hd__and2_1
XFILLER_60_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6510_ _2061_ _2138_ _2137_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__a21o_1
XANTENNA__5893__A net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7490_ _3114_ _3115_ VGND VGND VPWR VPWR _3120_ sky130_fd_sc_hd__xnor2_1
XFILLER_13_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6441_ _2056_ _2058_ _2057_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__o21ba_1
XANTENNA__6501__B net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9160_ net543 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__inv_2
XFILLER_134_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6372_ _2000_ _2001_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__nand2b_1
X_8111_ _3683_ _3684_ _3298_ VGND VGND VPWR VPWR _3685_ sky130_fd_sc_hd__a21oi_1
X_5323_ _0937_ _0938_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nor3_1
X_9091_ net535 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__inv_2
XFILLER_88_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7035__D net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8042_ _3497_ _3498_ _3625_ adder_inst.is_nan_r VGND VGND VPWR VPWR _3626_ sky130_fd_sc_hd__a31o_1
X_5254_ _0785_ _0882_ _0881_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a21o_1
X_5185_ _0794_ _0807_ _0813_ _0591_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a211o_1
XANTENNA_fanout198_A net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4675__C net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8944_ net521 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__inv_2
XANTENNA__4972__A net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout365_A net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6890__C net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8875_ net796 mul_res\[27\] net506 VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__mux2_1
XFILLER_37_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5787__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7826_ net498 net183 VGND VGND VPWR VPWR _3432_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_65_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7757_ net851 _3372_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__nor2_1
X_4969_ _0598_ _0597_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_22_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6772__B1 net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7688_ _3313_ VGND VGND VPWR VPWR _3314_ sky130_fd_sc_hd__inv_2
XFILLER_20_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6708_ _2330_ _2332_ _2329_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__o21ba_1
XANTENNA_fanout418_X net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9427_ clknet_leaf_27_clk multiplier_inst.man_final\[15\] _0337_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6639_ _2266_ _2267_ _2268_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__or3_1
XFILLER_137_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7226__C net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9358_ clknet_leaf_28_clk _0062_ _0268_ VGND VGND VPWR VPWR add_res\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8309_ net125 _3756_ _3757_ VGND VGND VPWR VPWR _3882_ sky130_fd_sc_hd__nor3_1
X_9289_ clknet_leaf_31_clk net747 _0199_ VGND VGND VPWR VPWR adder_inst.man_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4866__B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout140 net142 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_2
XFILLER_105_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4838__B1 net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout151 _3679_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_2
Xfanout162 net164 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
Xfanout173 net175 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_2
XFILLER_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout195 adder_inst.exp_larger_r\[4\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
Xfanout184 net186 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_2
XFILLER_35_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8504__A1 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7417__B net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6321__B net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4776__B net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_leaf_23_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6990_ _2617_ _2618_ _2619_ VGND VGND VPWR VPWR _2620_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_0_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5941_ _1447_ _1470_ _1569_ _1570_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__a211o_1
XFILLER_19_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8660_ _4106_ _4216_ net107 VGND VGND VPWR VPWR _4217_ sky130_fd_sc_hd__mux2_4
XFILLER_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5872_ _1486_ _1487_ _1500_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_138_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4823_ _0442_ _0452_ _4509_ _4543_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a211o_1
X_8591_ net671 _4156_ net187 _4155_ VGND VGND VPWR VPWR _4157_ sky130_fd_sc_hd__a211oi_2
X_7611_ _3240_ VGND VGND VPWR VPWR _3241_ sky130_fd_sc_hd__inv_2
X_4754_ net210 net215 net365 net372 VGND VGND VPWR VPWR _4525_ sky130_fd_sc_hd__and4_1
X_7542_ _3162_ _3171_ net618 VGND VGND VPWR VPWR _3172_ sky130_fd_sc_hd__mux2_1
XANTENNA__6512__A net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_117_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7473_ _3080_ _3102_ VGND VGND VPWR VPWR _3103_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9212_ clknet_leaf_6_clk net6 _0122_ VGND VGND VPWR VPWR adder_inst.i_a\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_119_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4685_ net362 net233 net366 net227 VGND VGND VPWR VPWR _4456_ sky130_fd_sc_hd__a22oi_1
XANTENNA_fanout113_A _3152_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6424_ _1980_ _2052_ _2053_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_116_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9143_ net531 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6355_ net431 net308 VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__nand2_1
X_9074_ net538 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__inv_2
XFILLER_103_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5306_ _0933_ _0934_ _0928_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__a21bo_1
X_6286_ _1831_ _1833_ _1832_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__o21ai_1
XANTENNA__8873__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8025_ net486 net490 net493 net172 _3610_ VGND VGND VPWR VPWR _3611_ sky130_fd_sc_hd__a221o_1
XFILLER_102_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5237_ _0769_ _0775_ _0855_ _0864_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_126_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8726__X adder_inst.exp_larger\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout482_A adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5168_ net385 net273 VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nand2_1
XFILLER_57_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout270_X net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5099_ _0726_ _0727_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout368_X net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8927_ net511 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
XFILLER_71_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8858_ net774 mul_res\[10\] net504 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__mux2_1
XANTENNA__6125__C net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_135_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7809_ adder_inst.exp_larger_r\[1\] net196 VGND VGND VPWR VPWR _3415_ sky130_fd_sc_hd__or2_1
XFILLER_25_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8789_ _2547_ _4288_ _4290_ _2542_ _4295_ VGND VGND VPWR VPWR _4296_ sky130_fd_sc_hd__a221o_1
XANTENNA_rebuffer6_X net555 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8349__A net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6795__C net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input43_A i_b[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6316__B net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6051__B net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6140_ _1767_ _1768_ _1760_ _1765_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__o211a_1
XFILLER_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_717 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6071_ net587 _1697_ _1699_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__a211oi_2
X_5022_ _0650_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__or2_1
XFILLER_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6975__B1 net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6973_ net385 net289 VGND VGND VPWR VPWR _2603_ sky130_fd_sc_hd__nand2_1
X_8712_ _4082_ _4262_ VGND VGND VPWR VPWR adder_inst.sum_raw\[22\] sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_62_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5924_ _1451_ _1453_ _1452_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8643_ _4104_ _4201_ net106 VGND VGND VPWR VPWR _4202_ sky130_fd_sc_hd__mux2_4
X_5855_ _1482_ _1483_ _1475_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__a21o_1
X_4806_ _0421_ _0422_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__or3_4
XFILLER_119_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8574_ _3894_ _4135_ _3892_ VGND VGND VPWR VPWR _4142_ sky130_fd_sc_hd__o21ai_1
XANTENNA__7057__B net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout328_A net330 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_32_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5786_ _1358_ _1360_ _1359_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a21bo_1
XANTENNA__8868__S net506 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7525_ _4354_ _3154_ VGND VGND VPWR VPWR _3155_ sky130_fd_sc_hd__xor2_1
XFILLER_119_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__9326__Q adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4737_ _4479_ _4506_ VGND VGND VPWR VPWR _4508_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4668_ net200 net398 VGND VGND VPWR VPWR _4439_ sky130_fd_sc_hd__nand2_1
X_7456_ _3084_ _3085_ VGND VGND VPWR VPWR _3086_ sky130_fd_sc_hd__xor2_2
X_6407_ _1943_ _1945_ _1961_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__a21oi_1
X_9126_ net538 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__inv_2
X_4599_ _4359_ _4369_ _4360_ VGND VGND VPWR VPWR _4370_ sky130_fd_sc_hd__a21o_2
X_7387_ _2581_ _2785_ _2784_ VGND VGND VPWR VPWR _3017_ sky130_fd_sc_hd__a21oi_2
XFILLER_115_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4847__D net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_73_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6338_ _1884_ _1883_ _1876_ _1878_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__o211a_1
XFILLER_135_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9057_ net541 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__inv_2
XFILLER_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6269_ _1897_ _1815_ _1896_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__a21o_1
X_8008_ _3414_ _3595_ VGND VGND VPWR VPWR _3596_ sky130_fd_sc_hd__or2_1
XFILLER_29_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5959__C net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6152__A net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7930__A2 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5215__B net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5640_ _1261_ _1267_ _1268_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5571_ _1197_ _1199_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__xnor2_1
X_8290_ net135 _3768_ _3787_ net140 VGND VGND VPWR VPWR _3863_ sky130_fd_sc_hd__a211o_1
X_7310_ _2930_ _2934_ _2933_ VGND VGND VPWR VPWR _2940_ sky130_fd_sc_hd__a21o_1
Xhold204 adder_inst.exp_a\[7\] VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold215 add_res\[12\] VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlygate4sd3_1
Xhold226 _0001_ VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dlygate4sd3_1
X_7241_ _2835_ _2836_ _2869_ _2870_ VGND VGND VPWR VPWR _2871_ sky130_fd_sc_hd__nand4_2
XFILLER_8_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold259 _0015_ VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlygate4sd3_1
Xhold248 _0019_ VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold237 multiplier_inst.man_final_r\[5\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_125_691 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7172_ _0960_ _0968_ _0967_ VGND VGND VPWR VPWR _2802_ sky130_fd_sc_hd__o21ai_1
X_6123_ _1750_ _1654_ _1749_ _1735_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_55_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6054_ _1681_ _1683_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__nor2_1
XANTENNA__5999__A1 net555 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5005_ _0632_ _0633_ _0628_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a21o_1
XFILLER_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout180_A net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6237__A net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout278_A net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4980__A net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout445_A net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6956_ _1516_ _1518_ _1517_ VGND VGND VPWR VPWR _2586_ sky130_fd_sc_hd__a21bo_1
XFILLER_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5907_ _1534_ _1535_ _1536_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__nand3b_1
XANTENNA__5795__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4974__A2 net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6887_ _2501_ _2502_ VGND VGND VPWR VPWR _2517_ sky130_fd_sc_hd__xnor2_1
XFILLER_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7912__A2 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8626_ _3993_ _3994_ VGND VGND VPWR VPWR _4187_ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout233_X net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5838_ _1449_ _1466_ _1467_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8557_ _3849_ _3852_ VGND VGND VPWR VPWR _4127_ sky130_fd_sc_hd__nand2_1
X_5769_ net260 net267 net427 net433 VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__and4_1
XFILLER_10_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout400_X net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7508_ _3135_ _3137_ VGND VGND VPWR VPWR _3138_ sky130_fd_sc_hd__nor2_1
X_8488_ net160 _4059_ _4060_ VGND VGND VPWR VPWR _4061_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5316__A net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7439_ _4536_ _3067_ VGND VGND VPWR VPWR _3069_ sky130_fd_sc_hd__nor2_1
XFILLER_89_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9109_ net529 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__inv_2
XFILLER_39_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4662__A1 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8561__C1 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5992__Y _1622_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7425__B net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4784__B net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_128_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4653__A1 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4653__B2 net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6810_ _2433_ _2438_ _2439_ VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__and3_1
X_7790_ net195 _3395_ VGND VGND VPWR VPWR _3396_ sky130_fd_sc_hd__or2_1
XFILLER_23_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4956__A2 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6741_ _2356_ _2364_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__xnor2_1
XANTENNA_clkbuf_0_clk_X clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9460_ clknet_leaf_25_clk _0078_ _0370_ VGND VGND VPWR VPWR mul_res\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6672_ _2295_ _2300_ _2301_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__and3_1
X_9391_ clknet_leaf_15_clk adder_inst.exp_larger\[5\] _0301_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_8411_ _3980_ _3982_ VGND VGND VPWR VPWR _3984_ sky130_fd_sc_hd__nand2_1
X_5623_ _1193_ _1209_ _1250_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__a211o_1
XFILLER_129_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8342_ net143 _3844_ _3914_ net123 VGND VGND VPWR VPWR _3915_ sky130_fd_sc_hd__a211o_1
XFILLER_129_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5554_ _1178_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__and2b_1
XFILLER_105_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8273_ net144 _3844_ _3845_ VGND VGND VPWR VPWR _3846_ sky130_fd_sc_hd__o21ai_1
X_5485_ _1113_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_57_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7224_ _2853_ _2849_ VGND VGND VPWR VPWR _2854_ sky130_fd_sc_hd__and2b_1
Xfanout514 net518 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__clkbuf_2
Xfanout503 opcode_stage1 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7155_ _2682_ _2783_ VGND VGND VPWR VPWR _2785_ sky130_fd_sc_hd__xor2_1
Xfanout547 net548 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__buf_4
Xfanout536 net539 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__buf_2
XFILLER_113_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout525 net528 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__buf_4
XANTENNA_fanout395_A net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6106_ _1637_ _1734_ _1733_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__a21o_1
XFILLER_100_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7086_ net641 net277 net284 net385 VGND VGND VPWR VPWR _2716_ sky130_fd_sc_hd__a22oi_2
XFILLER_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6037_ net253 net455 _1255_ _1256_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_39_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer30 _1108_ VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_67_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer63 _2110_ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__clkbuf_1
Xrebuffer52 _2189_ VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer41 _1694_ VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__buf_6
Xrebuffer96 _3664_ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlymetal6s2s_1
X_7988_ adder_inst.sum_raw_r\[12\] _3504_ _3577_ _3578_ VGND VGND VPWR VPWR _3579_
+ sky130_fd_sc_hd__o211a_1
XANTENNA__7594__B1 _1082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout448_X net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer85 net635 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__buf_2
XFILLER_41_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6939_ _2193_ _2247_ _2248_ _2189_ VGND VGND VPWR VPWR _2569_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_81_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8609_ _4172_ _3947_ VGND VGND VPWR VPWR adder_inst.sum_raw\[9\] sky130_fd_sc_hd__xnor2_1
XFILLER_50_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7526__A net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5046__A net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8357__A adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5212__C net432 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8092__A _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5060__A1 net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5270_ _0805_ _0898_ _0897_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a21o_1
XFILLER_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4874__B2 net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4874__A1 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8960_ net540 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__inv_2
XFILLER_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7911_ adder_inst.sum_raw_r\[1\] net496 _3404_ adder_inst.sum_raw_r\[0\] net492 VGND
+ VGND VPWR VPWR _3512_ sky130_fd_sc_hd__a221o_1
XANTENNA__5823__B1 net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8891_ net508 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__inv_2
XFILLER_48_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7842_ net196 adder_inst.exp_larger_r\[3\] _3406_ _3398_ VGND VGND VPWR VPWR _3448_
+ sky130_fd_sc_hd__a31o_1
XFILLER_63_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7773_ multiplier_inst.exp_final\[5\] _3380_ _3381_ _3378_ VGND VGND VPWR VPWR multiplier_inst.overflow_calc
+ sky130_fd_sc_hd__a31o_1
X_4985_ _0612_ _0613_ _0607_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a21o_1
XFILLER_91_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6724_ _2236_ _2353_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__or2_1
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9443_ clknet_leaf_14_clk net175 _0353_ VGND VGND VPWR VPWR multiplier_inst.sign_res_r
+ sky130_fd_sc_hd__dfrtp_1
X_6655_ net293 net299 net458 net464 VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__and4_1
X_9374_ clknet_leaf_18_clk _0048_ _0284_ VGND VGND VPWR VPWR add_res\[20\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout408_A net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6586_ _2213_ _2215_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__and2_1
X_5606_ _1216_ _1222_ _1234_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__nand3_1
XANTENNA__8876__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8325_ net143 _3814_ _3815_ VGND VGND VPWR VPWR _3898_ sky130_fd_sc_hd__and3_1
X_5537_ _1163_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__xnor2_1
X_8256_ _3823_ _3822_ _3825_ _3826_ VGND VGND VPWR VPWR _3829_ sky130_fd_sc_hd__or4_4
X_5468_ _1089_ _1091_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__nand2b_4
X_7207_ _0928_ _0934_ _0933_ VGND VGND VPWR VPWR _2837_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout398_X net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8187_ net202 net346 net161 VGND VGND VPWR VPWR _3761_ sky130_fd_sc_hd__mux2_1
X_5399_ _0979_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__and2_1
Xfanout300 net301 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__clkbuf_4
Xfanout322 net323 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__buf_4
Xfanout311 net312 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__buf_2
Xfanout344 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout355 net356 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_4
Xfanout366 net551 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7138_ _2750_ _2751_ _2766_ VGND VGND VPWR VPWR _2768_ sky130_fd_sc_hd__o21a_1
Xfanout333 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_6
Xfanout399 adder_inst.man_a_r\[14\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__buf_8
Xfanout388 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4855__D net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout377 net378 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_6
X_7069_ _2604_ _2606_ VGND VGND VPWR VPWR _2699_ sky130_fd_sc_hd__nand2_1
XFILLER_100_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5042__A1 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5593__A2 net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xinput19 i_a[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6160__A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5207__C net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4856__A1 net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4856__B2 net374 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7422__C net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4608__A1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5596__D net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4770_ _4538_ _4539_ _4474_ _4477_ VGND VGND VPWR VPWR _4541_ sky130_fd_sc_hd__a211o_1
XFILLER_60_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6440_ net289 net453 _2068_ _2066_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_136_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6371_ _1911_ _1913_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__xnor2_1
X_8110_ _3342_ _3664_ _3682_ VGND VGND VPWR VPWR _3684_ sky130_fd_sc_hd__a21o_1
XFILLER_115_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5322_ _0945_ _0950_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__xnor2_1
X_9090_ net537 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__inv_2
XFILLER_115_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8041_ net186 _3622_ _3624_ _3619_ VGND VGND VPWR VPWR _3625_ sky130_fd_sc_hd__a31o_1
XFILLER_87_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5253_ _0785_ _0881_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nand3_1
XANTENNA__8038__A1 net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5184_ _0794_ _0807_ _0813_ _0591_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a211oi_1
XANTENNA__4675__D net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8943_ net521 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__inv_2
XANTENNA__4972__B net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8874_ net784 mul_res\[26\] net505 VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__mux2_1
XANTENNA_fanout260_A net264 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7825_ net183 VGND VGND VPWR VPWR _3431_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_65_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7756_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r VGND VGND VPWR VPWR _3372_ sky130_fd_sc_hd__nor2_1
X_4968_ _0551_ _0553_ _0550_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_22_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7687_ _3309_ _3310_ VGND VGND VPWR VPWR _3313_ sky130_fd_sc_hd__xnor2_1
X_4899_ net251 net397 net400 net245 VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a22oi_1
XFILLER_20_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6707_ _2278_ _2321_ _2336_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__nand3_2
X_9426_ clknet_leaf_27_clk multiplier_inst.man_final\[14\] _0336_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[14\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout313_X net313 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6638_ net436 net329 net334 net430 VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__a22oi_2
XFILLER_106_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9357_ clknet_leaf_30_clk _0061_ _0267_ VGND VGND VPWR VPWR add_res\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8308_ net316 net156 VGND VGND VPWR VPWR _3881_ sky130_fd_sc_hd__nand2_1
XANTENNA__7226__D net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6569_ _2196_ _2197_ _2198_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__or3_1
XFILLER_133_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9288_ clknet_leaf_0_clk net722 _0198_ VGND VGND VPWR VPWR adder_inst.man_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_3_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8239_ _4358_ net151 net656 net148 _3736_ VGND VGND VPWR VPWR _3812_ sky130_fd_sc_hd__o41a_1
XANTENNA__4838__A1 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_76_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_748 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4838__B2 net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_2
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_2
Xfanout163 net164 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_1
Xfanout196 adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__buf_2
Xfanout185 net186 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5994__A net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8370__A net429 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_rebuffer49_X net598 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4776__C net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_662 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8545__A net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8440__A1 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5940_ _1545_ _1546_ _1568_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_105_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7610_ net113 _3237_ _3239_ VGND VGND VPWR VPWR _3240_ sky130_fd_sc_hd__o21ai_1
X_5871_ _1486_ _1487_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nor3_1
XANTENNA__6203__B1 net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_138_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7951__B1 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4822_ _0449_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nand2_1
X_8590_ _3925_ _4150_ _3924_ VGND VGND VPWR VPWR _4156_ sky130_fd_sc_hd__o21ai_1
XFILLER_61_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4753_ _4521_ _4522_ VGND VGND VPWR VPWR _4524_ sky130_fd_sc_hd__xnor2_1
X_7541_ _3019_ _3170_ VGND VGND VPWR VPWR _3171_ sky130_fd_sc_hd__xnor2_2
XANTENNA__6512__B net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7472_ _3078_ _3079_ VGND VGND VPWR VPWR _3102_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9211_ clknet_leaf_8_clk net5 _0121_ VGND VGND VPWR VPWR adder_inst.i_a\[13\] sky130_fd_sc_hd__dfrtp_1
X_4684_ net227 net362 net233 net366 VGND VGND VPWR VPWR _4455_ sky130_fd_sc_hd__and4_1
X_6423_ _1977_ _1979_ _1978_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__o21ai_1
XFILLER_134_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout106_A net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9142_ net532 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__inv_2
XANTENNA__5190__B1 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_8_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6354_ _1982_ _1895_ _1981_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__a21o_1
X_9073_ net545 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5305_ _0928_ _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nand3_1
X_6285_ _1900_ _1902_ _1901_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__o21bai_1
X_8024_ net498 net190 net185 _3609_ VGND VGND VPWR VPWR _3610_ sky130_fd_sc_hd__o211a_1
X_5236_ _0855_ _0864_ _0769_ _0775_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__o211a_1
XFILLER_124_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8455__A net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5167_ net373 net573 net277 net284 VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and4_1
XFILLER_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout475_A net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5098_ _0669_ _0671_ _0726_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a21o_1
XFILLER_84_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8926_ net512 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout263_X net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8195__A0 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8857_ net800 mul_res\[9\] net503 VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__mux2_1
XANTENNA__6125__D net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7808_ net491 net487 VGND VGND VPWR VPWR _3414_ sky130_fd_sc_hd__or2_2
XANTENNA_fanout430_X net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8788_ _2537_ _2545_ _4294_ VGND VGND VPWR VPWR _4295_ sky130_fd_sc_hd__a21oi_1
XFILLER_40_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7739_ adder_inst.i_b\[9\] adder_inst.i_b\[10\] adder_inst.i_b\[12\] adder_inst.i_b\[15\]
+ VGND VGND VPWR VPWR _3358_ sky130_fd_sc_hd__or4_1
XFILLER_12_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5319__A net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9409_ clknet_leaf_16_clk _0069_ _0319_ VGND VGND VPWR VPWR multiplier_inst.is_inf_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_78_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8349__B _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6795__D net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7540__Y _3170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input36_A i_b[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6316__C net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8304__S net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4747__B1 net232 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6051__C net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6070_ _1279_ _1698_ _1673_ _1671_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__o211a_1
XFILLER_112_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5021_ net216 net416 net422 net207 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__a22oi_1
XFILLER_100_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8711_ _4259_ _4261_ net188 VGND VGND VPWR VPWR _4262_ sky130_fd_sc_hd__mux2_4
XFILLER_81_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6975__B2 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6975__A1 net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6972_ _1523_ _1525_ _1524_ VGND VGND VPWR VPWR _2602_ sky130_fd_sc_hd__o21bai_1
XANTENNA__8177__A0 net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_80_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5923_ _1550_ _1551_ _1549_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__o21ai_1
X_8642_ _3988_ _4186_ _4200_ VGND VGND VPWR VPWR _4201_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_62_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5854_ _1475_ _1482_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__nand3_1
XFILLER_22_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4805_ _0429_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__xnor2_1
X_8573_ net187 _4139_ _4140_ VGND VGND VPWR VPWR _4141_ sky130_fd_sc_hd__and3_1
XFILLER_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7524_ net168 net113 VGND VGND VPWR VPWR _3154_ sky130_fd_sc_hd__nand2_1
XFILLER_21_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5785_ _1364_ _1369_ _1363_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout223_A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4736_ _4479_ _4506_ VGND VGND VPWR VPWR _4507_ sky130_fd_sc_hd__nor2_1
XFILLER_107_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4978__A net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4667_ _4436_ _4437_ VGND VGND VPWR VPWR _4438_ sky130_fd_sc_hd__nor2_1
X_7455_ net203 net366 VGND VGND VPWR VPWR _3085_ sky130_fd_sc_hd__nand2_2
XFILLER_134_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7386_ _3010_ _3011_ VGND VGND VPWR VPWR _3016_ sky130_fd_sc_hd__xnor2_2
X_6406_ _2029_ _2034_ _2035_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__nand3_2
X_9125_ net537 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__inv_2
XFILLER_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4598_ _4366_ _4368_ VGND VGND VPWR VPWR _4369_ sky130_fd_sc_hd__nand2_1
X_6337_ _1957_ _1960_ _1964_ _1965_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__o211ai_2
XFILLER_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9056_ net541 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__inv_2
X_6268_ _1815_ _1896_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout380_X net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8007_ adder_inst.sum_raw_r\[15\] net492 _3593_ _3594_ VGND VGND VPWR VPWR _3595_
+ sky130_fd_sc_hd__a22o_1
X_5219_ _0833_ _0834_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nor3_1
X_6199_ _1828_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__inv_2
XFILLER_69_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7758__A3 net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5959__D net457 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8909_ net522 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__inv_2
XFILLER_71_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8707__A2 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_leaf_22_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6152__B net468 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4888__A net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5154__B1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_36_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkload1_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8159__A0 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5570_ _1197_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__and2b_1
XFILLER_117_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold216 _0003_ VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlygate4sd3_1
X_7240_ _2867_ _2868_ _2865_ VGND VGND VPWR VPWR _2870_ sky130_fd_sc_hd__a21o_1
Xhold205 multiplier_inst.man_final_r\[6\] VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold227 add_ovf VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_wire181_X net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold238 add_res\[16\] VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
Xhold249 add_res\[15\] VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7171_ _0971_ _0972_ _0963_ _0966_ VGND VGND VPWR VPWR _2801_ sky130_fd_sc_hd__o211ai_1
XFILLER_124_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6122_ _1735_ _1749_ _1750_ _1654_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__a211o_1
XFILLER_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6053_ _1681_ _1682_ net253 net461 VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__and4bb_1
XANTENNA__5422__A net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5004_ _0628_ _0632_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nand3_1
XANTENNA__5999__A2 net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6237__B net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout173_A net175 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4980__B net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6955_ _1522_ _1527_ _1521_ VGND VGND VPWR VPWR _2585_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout340_A adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5906_ net385 net293 net300 net573 VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__a22o_1
XFILLER_41_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8625_ _4010_ _4177_ _4185_ VGND VGND VPWR VPWR _4186_ sky130_fd_sc_hd__a21boi_1
XANTENNA_fanout438_A adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6886_ _2509_ _2515_ VGND VGND VPWR VPWR _2516_ sky130_fd_sc_hd__or2_1
XANTENNA__8879__S net505 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5837_ _1464_ _1465_ _1450_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__a21o_1
XFILLER_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8556_ _4120_ _4121_ _3855_ VGND VGND VPWR VPWR _4126_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout226_X net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5768_ net254 net440 VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__nand2_1
XFILLER_10_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8487_ net224 net165 VGND VGND VPWR VPWR _4060_ sky130_fd_sc_hd__or2_1
X_4719_ net357 net226 net362 net232 VGND VGND VPWR VPWR _4490_ sky130_fd_sc_hd__and4_1
X_7507_ _3098_ _3099_ _3134_ VGND VGND VPWR VPWR _3137_ sky130_fd_sc_hd__o21a_1
XFILLER_5_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7438_ _4536_ _3065_ _3066_ VGND VGND VPWR VPWR _3068_ sky130_fd_sc_hd__and3_1
XANTENNA__7084__A net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5699_ net555 net308 VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__nand2_1
XFILLER_123_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5316__B net212 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7369_ _2992_ _2994_ VGND VGND VPWR VPWR _2999_ sky130_fd_sc_hd__nand2_1
XFILLER_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9108_ net529 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__inv_2
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9039_ net519 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__inv_2
XFILLER_131_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7833__C1 _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4662__A2 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4653__A2 net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6740_ _2316_ _2366_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__xnor2_2
XFILLER_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8001__C1 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6671_ _2226_ _2263_ _2280_ _2294_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__o211ai_2
X_9390_ clknet_leaf_15_clk adder_inst.exp_larger\[4\] _0300_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_8410_ _3982_ VGND VGND VPWR VPWR _3983_ sky130_fd_sc_hd__inv_2
X_5622_ _1235_ _1236_ _1249_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__a21oi_1
XFILLER_136_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8341_ net141 _3773_ _3837_ net127 VGND VGND VPWR VPWR _3914_ sky130_fd_sc_hd__o211a_1
X_5553_ _1179_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__xnor2_1
X_5484_ _1085_ net580 _1112_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__or3_2
X_8272_ net140 _3763_ net128 VGND VGND VPWR VPWR _3845_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_57_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7223_ _2850_ _2852_ VGND VGND VPWR VPWR _2853_ sky130_fd_sc_hd__nor2_1
Xfanout515 net516 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__buf_4
XFILLER_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout504 opcode_stage1 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_2
X_7154_ _2682_ _2783_ VGND VGND VPWR VPWR _2784_ sky130_fd_sc_hd__nor2_1
Xfanout537 net539 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__buf_4
Xfanout548 net549 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__buf_2
XFILLER_112_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout526 net528 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6105_ _1637_ _1733_ _1734_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout388_A adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5152__A net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7085_ net385 net391 net277 net284 VGND VGND VPWR VPWR _2715_ sky130_fd_sc_hd__and4_1
XANTENNA_fanout290_A net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6036_ _1659_ _1664_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__xnor2_2
Xrebuffer20 _0764_ VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__buf_1
XFILLER_27_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer53 _1097_ VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__buf_2
Xrebuffer31 net579 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_27_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer42 _1899_ VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__buf_1
Xrebuffer97 _3664_ VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlymetal6s2s_1
X_7987_ adder_inst.sum_raw_r\[14\] net190 net169 adder_inst.sum_raw_r\[13\] net184
+ VGND VGND VPWR VPWR _3578_ sky130_fd_sc_hd__o221a_1
XANTENNA__7594__A1 _1153_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer86 _1511_ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_1
XANTENNA_fanout343_X net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8750__X _0082_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6938_ _2567_ _2313_ _2311_ VGND VGND VPWR VPWR _2568_ sky130_fd_sc_hd__a21o_4
XFILLER_25_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6869_ net317 net478 VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__nand2_1
XANTENNA__7807__A net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8608_ _4168_ net187 _4171_ VGND VGND VPWR VPWR _4172_ sky130_fd_sc_hd__o21ai_2
Xrebuffer110 _3710_ VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd1_1
X_8539_ _4083_ _4085_ _4079_ VGND VGND VPWR VPWR _4112_ sky130_fd_sc_hd__a21o_1
XFILLER_135_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__9444__D _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5046__B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8357__B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5212__D net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5060__A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7452__A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4874__A2 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7596__B1_N _1035_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7910_ net114 _3508_ _3511_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__and3_1
X_8890_ net508 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__inv_2
XANTENNA__5823__B2 net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5823__A1 net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7841_ net497 _3408_ VGND VGND VPWR VPWR _3447_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_108_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5700__A net378 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7772_ _3291_ _3313_ _3348_ _3350_ _3325_ VGND VGND VPWR VPWR _3381_ sky130_fd_sc_hd__o221a_1
X_4984_ _0607_ _0612_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__nand3_1
XFILLER_23_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6723_ net283 net470 net477 net276 VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__a22oi_1
X_9442_ clknet_leaf_14_clk multiplier_inst.exp_final\[7\] _0352_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__6531__A net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6654_ _2281_ _2282_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5605_ _1216_ _1222_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__a21o_1
X_9373_ clknet_leaf_19_clk _0046_ _0283_ VGND VGND VPWR VPWR add_res\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6585_ _2144_ _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__and2b_1
XFILLER_127_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8324_ _3896_ VGND VGND VPWR VPWR _3897_ sky130_fd_sc_hd__inv_2
X_5536_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout303_A net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5467_ _1096_ _1087_ _1065_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__or3_4
XANTENNA__4986__A net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8255_ _3824_ _3827_ VGND VGND VPWR VPWR _3828_ sky130_fd_sc_hd__and2b_1
X_7206_ _0915_ _2804_ _2819_ _2834_ VGND VGND VPWR VPWR _2836_ sky130_fd_sc_hd__o211ai_2
X_5398_ net146 _1019_ _1027_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21o_1
XFILLER_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8186_ _3677_ _3758_ _3745_ net119 VGND VGND VPWR VPWR _3760_ sky130_fd_sc_hd__a31o_1
Xfanout301 net304 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout323 adder_inst.man_b_r\[3\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_2
Xfanout312 net313 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout356 net358 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__buf_4
XFILLER_86_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout345 net346 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__buf_2
X_7137_ _2750_ _2751_ _2766_ VGND VGND VPWR VPWR _2767_ sky130_fd_sc_hd__nor3_1
XANTENNA_fanout293_X net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout334 net337 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout367 net551 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkbuf_4
Xfanout378 net379 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__buf_6
XFILLER_74_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5313__C net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7068_ _2694_ _2695_ VGND VGND VPWR VPWR _2698_ sky130_fd_sc_hd__xnor2_1
Xfanout389 net391 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__buf_8
XFILLER_101_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout460_X net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6019_ _1171_ _1648_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__nor2_1
XFILLER_36_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8764__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_83_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_638 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5042__A2 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_25_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_rebuffer39_A adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7971__S net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6160__B net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_108_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_input66_A opcode VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5207__D net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4856__A2 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_719 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4608__A2 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_5_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6370_ _1985_ _1987_ _1986_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__o21ba_1
XFILLER_115_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5321_ _0945_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__nand2_1
XFILLER_114_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8040_ net496 net190 _3428_ _3623_ net491 VGND VGND VPWR VPWR _3624_ sky130_fd_sc_hd__a221o_1
XFILLER_130_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5252_ _0782_ _0784_ _0783_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__o21ai_1
X_5183_ _0576_ _0577_ _0590_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a21oi_1
XFILLER_110_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8942_ net519 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__inv_2
XFILLER_113_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8873_ net805 mul_res\[25\] net505 VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__mux2_1
XFILLER_83_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7824_ net502 net499 VGND VGND VPWR VPWR _3430_ sky130_fd_sc_hd__or2_1
XFILLER_91_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_65_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout253_A adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6221__A1 net271 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7755_ adder_inst.is_zero_b_r adder_inst.is_zero_a_r VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__and2_1
X_4967_ _0595_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_22_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout518_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7686_ _3302_ _3311_ VGND VGND VPWR VPWR _3312_ sky130_fd_sc_hd__xnor2_1
X_4898_ net240 net410 VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_31_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_8
X_6706_ _2333_ _2334_ _2328_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout420_A net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9425_ clknet_leaf_24_clk multiplier_inst.man_final\[13\] _0335_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6637_ net442 net325 VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__nand2_1
X_9356_ clknet_leaf_28_clk _0058_ _0266_ VGND VGND VPWR VPWR add_res\[2\] sky130_fd_sc_hd__dfrtp_1
X_6568_ net430 net329 net336 net424 VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__a22oi_2
XANTENNA_clkbuf_2_1__f_clk_X clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5519_ _1148_ _1147_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__nor2_2
X_8307_ _3876_ _3877_ VGND VGND VPWR VPWR _3880_ sky130_fd_sc_hd__xor2_2
XFILLER_133_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9287_ clknet_leaf_22_clk adder_inst.sum_raw\[24\] _0197_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_106_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7092__A net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6499_ _2051_ _2127_ _2128_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__nand3_1
X_8238_ net143 _3809_ _3810_ VGND VGND VPWR VPWR _3811_ sky130_fd_sc_hd__and3_1
XFILLER_78_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout120 net121 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_2
X_8169_ net133 _3742_ _3740_ net140 VGND VGND VPWR VPWR _3743_ sky130_fd_sc_hd__o211a_1
XANTENNA__4838__A2 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout131 _4391_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_2
Xfanout142 _3708_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_2
Xfanout164 _3665_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_2
XFILLER_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout175 multiplier_inst.sign_res VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_2
Xfanout197 adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_2
Xfanout186 _3393_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_4
XFILLER_75_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8127__S net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6436__A net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5994__B net389 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8370__B net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_41_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_22_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4776__D net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5870_ _1495_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__xnor2_1
X_4821_ _0442_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2_1
XANTENNA__6203__A1 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7951__B2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_13_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_4752_ _4522_ _4521_ VGND VGND VPWR VPWR _4523_ sky130_fd_sc_hd__and2b_1
X_7540_ _2574_ _2795_ _2799_ _3022_ VGND VGND VPWR VPWR _3170_ sky130_fd_sc_hd__a31oi_4
XANTENNA__6512__C net447 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4683_ _4451_ _4452_ VGND VGND VPWR VPWR _4454_ sky130_fd_sc_hd__xor2_1
X_7471_ _3100_ VGND VGND VPWR VPWR _3101_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_60_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9210_ clknet_leaf_3_clk net4 _0120_ VGND VGND VPWR VPWR adder_inst.i_a\[12\] sky130_fd_sc_hd__dfrtp_1
X_6422_ _2049_ _2050_ _2048_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__o21bai_1
X_9141_ net531 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__inv_2
XANTENNA__5425__A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_116_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5190__B2 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5190__A1 net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6353_ _1895_ _1981_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__nand3_1
X_9072_ net545 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5304_ _0828_ _0927_ _0926_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21o_1
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6284_ net290 net443 _1912_ _1910_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__a31o_1
X_8023_ _4342_ _3608_ _3607_ net488 VGND VGND VPWR VPWR _3609_ sky130_fd_sc_hd__a211o_1
XFILLER_103_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5235_ _0855_ _0862_ _0863_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__or3_4
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_803 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8455__B net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5166_ _0495_ _0497_ _0496_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5097_ _0669_ _0671_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_3_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout468_A net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8925_ net512 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__inv_2
XFILLER_83_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8195__A1 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout256_X net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8856_ net778 mul_res\[8\] net503 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__mux2_1
XFILLER_25_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7807_ net491 net487 VGND VGND VPWR VPWR _3413_ sky130_fd_sc_hd__nor2_2
XANTENNA__7942__B2 adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7942__A1 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8787_ _4293_ _2537_ _2542_ VGND VGND VPWR VPWR _4294_ sky130_fd_sc_hd__nor3b_1
X_5999_ net555 net327 _1285_ _1287_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__a22o_1
XFILLER_40_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout423_X net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7738_ adder_inst.i_b\[1\] adder_inst.i_b\[0\] adder_inst.i_b\[3\] adder_inst.i_b\[2\]
+ VGND VGND VPWR VPWR _3357_ sky130_fd_sc_hd__or4_1
XFILLER_40_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5319__B net449 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9408_ clknet_leaf_13_clk net841 _0318_ VGND VGND VPWR VPWR multiplier_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_1
X_7669_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR _3295_
+ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_78_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_49_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9339_ clknet_leaf_4_clk net719 _0249_ VGND VGND VPWR VPWR adder_inst.man_b_r\[17\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_input29_A i_a[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6316__D net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4747__A1 net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4747__B2 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_100_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6051__D net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap117 _3142_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_1
XFILLER_124_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8110__A1 _3342_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5020_ net207 net216 net416 net423 VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__and4_1
XFILLER_98_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8710_ _4254_ _4074_ _4260_ VGND VGND VPWR VPWR _4261_ sky130_fd_sc_hd__a21o_1
XFILLER_93_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6975__A2 net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6971_ _1535_ _1537_ VGND VGND VPWR VPWR _2601_ sky130_fd_sc_hd__nand2_1
XANTENNA__8177__A1 net428 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5922_ _1549_ _1550_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__or3_1
XFILLER_110_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8641_ _3974_ _3984_ _3985_ VGND VGND VPWR VPWR _4200_ sky130_fd_sc_hd__a21o_1
XFILLER_80_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5853_ _1480_ _1481_ _1476_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__a21o_1
XFILLER_22_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4804_ _0432_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__xnor2_1
X_8572_ _3889_ _3891_ VGND VGND VPWR VPWR _4140_ sky130_fd_sc_hd__nand2_1
XFILLER_61_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5784_ _1281_ _1412_ _1411_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__nor4_4
XFILLER_34_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4735_ _4504_ _4505_ VGND VGND VPWR VPWR _4506_ sky130_fd_sc_hd__nand2_1
X_7523_ net586 VGND VGND VPWR VPWR _3153_ sky130_fd_sc_hd__inv_2
XFILLER_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4978__B net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout216_A net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4666_ net216 net388 net394 net208 VGND VGND VPWR VPWR _4437_ sky130_fd_sc_hd__a22oi_1
X_7454_ _3082_ _3083_ VGND VGND VPWR VPWR _3084_ sky130_fd_sc_hd__or2_1
XFILLER_135_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7385_ _3013_ _3014_ VGND VGND VPWR VPWR _3015_ sky130_fd_sc_hd__and2b_1
X_4597_ _4359_ _4360_ _4367_ VGND VGND VPWR VPWR _4368_ sky130_fd_sc_hd__o21a_1
X_6405_ _1941_ _2028_ _2026_ net567 VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__a211o_1
X_9124_ net538 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__inv_2
X_6336_ _1957_ _1960_ _1964_ _1965_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__o211a_4
XFILLER_135_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_811 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9055_ net541 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_73_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6267_ net638 _1814_ _1813_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__o21ai_1
XFILLER_130_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8006_ _4338_ _3432_ _3524_ adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR _3594_
+ sky130_fd_sc_hd__o2bb2a_1
X_5218_ _0841_ _0846_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__xnor2_1
X_6198_ _1732_ _1826_ _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__nand3_2
XFILLER_96_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout373_X net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5149_ _0460_ _0462_ _0461_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8908_ net521 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__inv_2
XFILLER_71_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8839_ _3244_ _3257_ _3260_ _3253_ VGND VGND VPWR VPWR _4328_ sky130_fd_sc_hd__a31o_1
XFILLER_80_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4888__B net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_10_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5154__B2 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5154__A1 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6055__A2_N net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8376__A net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_66_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clone81_X net630 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8159__A1 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_75_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7455__A net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6590__B1 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold217 multiplier_inst.exp_final_r\[1\] VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlygate4sd3_1
Xwire181 _4269_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_2
Xhold206 add_res\[0\] VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlygate4sd3_1
Xhold228 _0032_ VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
Xhold239 _0007_ VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
X_7170_ _2795_ _2799_ VGND VGND VPWR VPWR _2800_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_113_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6121_ _1735_ _1749_ _1750_ _1654_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a211oi_1
XFILLER_105_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6052_ net266 net451 net455 net259 VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__a22oi_1
XANTENNA__5422__B net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5003_ _0630_ _0631_ _0629_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a21bo_1
XFILLER_85_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8398__A1 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8733__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout166_A _3665_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4980__C net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6954_ _1531_ _1542_ _1530_ VGND VGND VPWR VPWR _2584_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_93_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5905_ net377 net383 net294 net300 VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__nand4_1
XFILLER_41_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8624_ _3996_ _4006_ _3995_ VGND VGND VPWR VPWR _4185_ sky130_fd_sc_hd__a21o_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6885_ _2478_ _2485_ _2487_ _2508_ VGND VGND VPWR VPWR _2515_ sky130_fd_sc_hd__a22oi_1
X_5836_ _1450_ _1464_ _1465_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__nand3_2
XANTENNA_fanout333_A adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8555_ _3855_ _4125_ VGND VGND VPWR VPWR adder_inst.sum_raw\[2\] sky130_fd_sc_hd__xor2_2
X_5767_ _1394_ _1395_ _1390_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a21o_1
XFILLER_22_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8486_ net122 net121 _3886_ VGND VGND VPWR VPWR _4059_ sky130_fd_sc_hd__and3_1
X_4718_ _4487_ _4488_ VGND VGND VPWR VPWR _4489_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout219_X net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7506_ _3059_ _3086_ _3089_ _3096_ _3097_ VGND VGND VPWR VPWR _3136_ sky130_fd_sc_hd__a32oi_2
X_5698_ _1326_ _1325_ _1321_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__a21o_1
X_4649_ _4414_ _4418_ _4419_ VGND VGND VPWR VPWR _4420_ sky130_fd_sc_hd__nand3_1
X_7437_ _3065_ _3066_ VGND VGND VPWR VPWR _3067_ sky130_fd_sc_hd__and2_1
XANTENNA__7084__B net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8748__X _0080_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5316__C net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7368_ _2996_ _2997_ VGND VGND VPWR VPWR _2998_ sky130_fd_sc_hd__nand2_1
XFILLER_89_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9107_ net524 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__inv_2
X_7299_ _2914_ _2915_ _2928_ VGND VGND VPWR VPWR _2929_ sky130_fd_sc_hd__nor3_1
X_6319_ _1946_ _1948_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__and2b_1
X_9038_ net537 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__inv_2
XFILLER_131_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5613__A net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7546__Y _3176_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer24_X net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6670_ _2298_ _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__nor2_1
X_5621_ _1235_ _1236_ _1249_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__nand3_1
X_8340_ net145 _3841_ _3912_ net124 VGND VGND VPWR VPWR _3913_ sky130_fd_sc_hd__a211o_1
X_5552_ _1180_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__and2b_1
XFILLER_117_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8271_ _3766_ _3770_ net141 VGND VGND VPWR VPWR _3844_ sky130_fd_sc_hd__mux2_2
X_5483_ net579 _1112_ _1085_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_57_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7222_ _2850_ _2851_ net220 net444 VGND VGND VPWR VPWR _2852_ sky130_fd_sc_hd__and4bb_1
Xfanout505 net506 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__clkbuf_4
X_7153_ _2775_ _2782_ VGND VGND VPWR VPWR _2783_ sky130_fd_sc_hd__xnor2_2
Xfanout516 net517 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__clkbuf_4
Xfanout538 net539 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__buf_4
XFILLER_101_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout527 net528 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7084_ net397 net273 VGND VGND VPWR VPWR _2714_ sky130_fd_sc_hd__nand2_1
X_6104_ _1630_ _1631_ _1636_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__a21o_1
Xfanout549 net67 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__clkbuf_4
XFILLER_112_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5152__B net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6035_ _1664_ _1659_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__and2b_1
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_21_clk_A clknet_2_2__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout283_A net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer10 _2249_ VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__buf_1
Xrebuffer21 net576 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__clkbuf_2
XFILLER_27_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer32 _1864_ VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer54 _2113_ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__buf_1
XANTENNA_fanout450_A net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout548_A net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7986_ adder_inst.sum_raw_r\[11\] net495 _3575_ _3576_ _3473_ VGND VGND VPWR VPWR
+ _3577_ sky130_fd_sc_hd__a221o_1
XFILLER_81_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7594__A2 _3222_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer87 _1620_ VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer65 _1920_ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__buf_6
XFILLER_26_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer98 net646 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlymetal6s2s_1
XANTENNA__4801__B1 net399 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_81_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6937_ _2565_ _2369_ _2368_ VGND VGND VPWR VPWR _2567_ sky130_fd_sc_hd__a21o_1
X_6868_ net318 net470 net477 net310 VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__a22oi_1
X_8607_ net173 _4169_ _4170_ VGND VGND VPWR VPWR _4171_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_81_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5819_ _1396_ _1403_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__nand2_1
XFILLER_22_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8538_ _4088_ _4110_ VGND VGND VPWR VPWR _4111_ sky130_fd_sc_hd__nand2b_4
Xrebuffer111 net659 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer100 net648 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_fanout503_X net503 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5608__A net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6799_ _2427_ _2428_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__xnor2_1
XFILLER_135_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8469_ _4039_ _4040_ VGND VGND VPWR VPWR _4042_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_20_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input11_A i_a[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_123_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7557__X _3187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__7452__B net214 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput90 net90 VGND VGND VPWR VPWR o_res[2] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_52_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5823__A2 net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7840_ net502 _4341_ VGND VGND VPWR VPWR _3446_ sky130_fd_sc_hd__nand2_1
XFILLER_76_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5700__B net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7771_ _3289_ _3294_ _3379_ multiplier_inst.exp_final\[0\] VGND VGND VPWR VPWR _3380_
+ sky130_fd_sc_hd__and4b_1
X_4983_ _0610_ _0611_ _0608_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a21o_1
XFILLER_24_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6722_ _2337_ _2351_ _2293_ _2320_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__a211o_1
X_9441_ clknet_leaf_13_clk multiplier_inst.exp_final\[6\] _0351_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_6653_ _2281_ _2282_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__nand2b_1
XFILLER_32_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6531__B net283 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5604_ _1232_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__or2_1
X_9372_ clknet_leaf_20_clk _0045_ _0282_ VGND VGND VPWR VPWR add_res\[18\] sky130_fd_sc_hd__dfrtp_1
X_6584_ net289 net459 _2142_ _2143_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a22o_1
XFILLER_118_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8323_ _3880_ _3895_ VGND VGND VPWR VPWR _3896_ sky130_fd_sc_hd__nand2_1
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5535_ net407 net297 net303 net401 VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__a22oi_1
X_5466_ _1091_ _1092_ _1094_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nand3_1
XANTENNA__4986__B net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8254_ _3825_ _3826_ VGND VGND VPWR VPWR _3827_ sky130_fd_sc_hd__nor2_1
XANTENNA__6839__A1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7205_ _2819_ _2834_ _0915_ _2804_ VGND VGND VPWR VPWR _2835_ sky130_fd_sc_hd__a211o_4
XFILLER_132_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5397_ _1026_ _1025_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nor2_2
X_8185_ _3745_ _3758_ VGND VGND VPWR VPWR _3759_ sky130_fd_sc_hd__nand2_1
Xfanout313 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__clkbuf_2
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_4
XANTENNA_input3_A i_a[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout346 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkbuf_4
Xfanout357 net358 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkbuf_4
X_7136_ _2759_ _2764_ VGND VGND VPWR VPWR _2766_ sky130_fd_sc_hd__xnor2_1
Xfanout335 net337 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__buf_1
Xfanout324 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__buf_2
Xfanout368 net369 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__buf_6
XANTENNA__5450__X _1080_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout379 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__buf_8
XANTENNA__5313__D net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7067_ _2694_ _2695_ VGND VGND VPWR VPWR _2697_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout286_X net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6018_ net420 net291 _1169_ _1170_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_39_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout453_X net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7969_ adder_inst.sum_raw_r\[8\] _4341_ net170 adder_inst.sum_raw_r\[7\] net193 VGND
+ VGND VPWR VPWR _3562_ sky130_fd_sc_hd__o221a_1
XFILLER_70_723 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7818__A adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6160__C net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input59_A i_b[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_125_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5248__A net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_136_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer1 _1131_ VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlymetal6s4s_1
X_5320_ _0948_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__xnor2_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5251_ net353 net307 _0879_ _0877_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a31o_1
XFILLER_130_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5182_ _0791_ _0811_ _0759_ _0777_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a211oi_4
XFILLER_84_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8941_ net519 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__inv_2
XFILLER_110_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5257__B1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5711__A net408 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8872_ net822 mul_res\[24\] net505 VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__mux2_1
XANTENNA__7549__A2 _3170_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7823_ adder_inst.sum_raw_r\[0\] adder_inst.sum_raw_r\[1\] _3394_ _3428_ VGND VGND
+ VPWR VPWR _3429_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_65_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7754_ adder_inst.man_a\[23\] _3371_ VGND VGND VPWR VPWR adder_inst.is_zero_a sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_65_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6221__A2 net456 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4966_ _0558_ _0593_ _0594_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_22_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6705_ _2328_ _2333_ _2334_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__nand3_1
X_7685_ _3309_ _3310_ _3307_ VGND VGND VPWR VPWR _3311_ sky130_fd_sc_hd__a21oi_1
X_4897_ net245 net251 net398 net403 VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__and4_1
XFILLER_20_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9424_ clknet_leaf_27_clk multiplier_inst.man_final\[12\] _0334_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[12\] sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout413_A net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6636_ net430 net436 net329 net334 VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__and4_1
X_9355_ clknet_leaf_29_clk _0047_ _0265_ VGND VGND VPWR VPWR add_res\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6567_ net436 net324 VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__nand2_1
X_5518_ _0600_ _0772_ _0770_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a21oi_1
X_8306_ _3876_ _3877_ VGND VGND VPWR VPWR _3879_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout201_X net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9286_ clknet_leaf_22_clk adder_inst.sum_raw\[23\] _0196_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[23\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_105_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7092__B net412 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6498_ _2048_ _2050_ _2049_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__o21ai_1
XFILLER_133_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5449_ _1070_ _1073_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a21o_1
X_8237_ net135 _3771_ _3807_ net140 VGND VGND VPWR VPWR _3810_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_76_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout121 _3731_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_2
X_8168_ _3741_ VGND VGND VPWR VPWR _3742_ sky130_fd_sc_hd__inv_2
XFILLER_78_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_8
XANTENNA_input6_X net6 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout165 _3665_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_2
Xfanout143 _3704_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7820__B adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
X_7119_ _2643_ _2651_ _2650_ VGND VGND VPWR VPWR _2749_ sky130_fd_sc_hd__a21bo_1
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__buf_2
X_8099_ _3277_ _3653_ net685 _3278_ _3341_ VGND VGND VPWR VPWR _3673_ sky130_fd_sc_hd__a2111o_1
Xfanout187 _3355_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_4
Xfanout176 net177 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6436__B net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8379__A net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9271__Q adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_131_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4820_ _0440_ _0441_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nand2_1
XFILLER_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6203__A2 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_138_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7951__A2 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4751_ _4491_ _4493_ _4490_ VGND VGND VPWR VPWR _4522_ sky130_fd_sc_hd__o21ba_1
X_4682_ _4452_ _4451_ VGND VGND VPWR VPWR _4453_ sky130_fd_sc_hd__and2b_1
X_7470_ _3098_ _3099_ VGND VGND VPWR VPWR _3100_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_60_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6421_ _2048_ _2049_ _2050_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__or3_1
X_9140_ net527 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__inv_2
XFILLER_127_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5190__A2 net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6352_ _1892_ _1894_ _1893_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__o21ai_1
X_9071_ net537 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__inv_2
XANTENNA__5425__B net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_116_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5303_ _0929_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__nand2b_1
X_6283_ _1910_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__and2b_1
X_8022_ adder_inst.sum_raw_r\[14\] _3523_ _3605_ _4343_ VGND VGND VPWR VPWR _3608_
+ sky130_fd_sc_hd__a22o_1
XFILLER_103_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5234_ _0855_ _0862_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__nor3_1
X_5165_ _0507_ _0793_ _0792_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a21o_1
XFILLER_69_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8736__B net180 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout196_A adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5096_ _0724_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__or2_1
XFILLER_84_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8924_ net511 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout363_A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8855_ net812 mul_res\[7\] net503 VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__mux2_1
X_7806_ _3397_ _3411_ net490 VGND VGND VPWR VPWR _3412_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout530_A net534 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout249_X net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5998_ _1625_ _1626_ _1624_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__o21bai_1
X_8786_ _2516_ _4292_ net118 VGND VGND VPWR VPWR _4293_ sky130_fd_sc_hd__a21oi_1
XFILLER_40_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4949_ net229 net235 net416 net422 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__and4_1
X_7737_ adder_inst.i_b\[5\] adder_inst.i_b\[4\] adder_inst.i_b\[7\] adder_inst.i_b\[6\]
+ VGND VGND VPWR VPWR _3356_ sky130_fd_sc_hd__or4_1
XFILLER_137_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout416_X net416 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7668_ _3289_ _3294_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[2\] sky130_fd_sc_hd__and2b_1
XFILLER_138_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9407_ clknet_leaf_7_clk adder_inst.is_zero_b _0317_ VGND VGND VPWR VPWR adder_inst.is_zero_b_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_78_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6619_ _2193_ _2247_ _2189_ _2248_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__or4bb_4
XPHY_EDGE_ROW_104_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7599_ _0458_ _1158_ _3035_ VGND VGND VPWR VPWR _3229_ sky130_fd_sc_hd__and3_1
XFILLER_4_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9338_ clknet_leaf_5_clk net737 _0248_ VGND VGND VPWR VPWR adder_inst.man_b_r\[16\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_106_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9269_ clknet_leaf_24_clk adder_inst.sum_raw\[6\] _0179_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[6\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__7458__A1 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8138__S net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_113_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6182__A net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4747__A2 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_122_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap129 _1703_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
XFILLER_99_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_131_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6970_ _2585_ _2598_ VGND VGND VPWR VPWR _2600_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_49_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5921_ net402 net279 net288 net395 VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__a22oi_2
X_8640_ _4199_ _3987_ VGND VGND VPWR VPWR adder_inst.sum_raw\[13\] sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_62_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4605__A net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5852_ _1476_ _1480_ _1481_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__nand3_1
X_4803_ net202 net404 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nand2_1
X_8571_ _4134_ _4133_ _3895_ VGND VGND VPWR VPWR _4139_ sky130_fd_sc_hd__a21o_1
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5783_ _1253_ _1280_ _1279_ _1269_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__a211oi_1
X_4734_ _4489_ _4503_ VGND VGND VPWR VPWR _4505_ sky130_fd_sc_hd__nand2_1
X_7522_ _4370_ _4391_ _3151_ VGND VGND VPWR VPWR _3152_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_32_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4665_ net208 net216 net388 net394 VGND VGND VPWR VPWR _4436_ sky130_fd_sc_hd__and4_1
X_7453_ net214 net357 net363 net209 VGND VGND VPWR VPWR _3083_ sky130_fd_sc_hd__a22oi_2
X_7384_ _3006_ _3009_ _3012_ VGND VGND VPWR VPWR _3014_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout209_A net210 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4596_ net351 net203 net346 net209 VGND VGND VPWR VPWR _4367_ sky130_fd_sc_hd__a22o_1
X_6404_ _2032_ _2033_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__nor2_1
X_9123_ net538 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__inv_2
XFILLER_115_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6335_ _1963_ _1881_ _1962_ _1944_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a211o_4
XFILLER_135_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9054_ net533 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__inv_2
XFILLER_89_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8005_ adder_inst.sum_raw_r\[14\] net192 _3405_ adder_inst.sum_raw_r\[13\] net191
+ VGND VGND VPWR VPWR _3593_ sky130_fd_sc_hd__o221a_1
X_6266_ _1893_ _1894_ _1892_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__o21bai_1
XANTENNA_fanout199_X net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5217_ _0841_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__nand2_1
XFILLER_69_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout480_A net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6197_ _1725_ _1726_ _1731_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__a21o_1
XFILLER_29_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5148_ net348 net341 net307 net313 VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__and4_1
XFILLER_57_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5079_ _0708_ _0707_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2b_1
XFILLER_56_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8907_ net535 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8838_ net104 _4327_ VGND VGND VPWR VPWR multiplier_inst.man_final\[17\] sky130_fd_sc_hd__nor2_1
XFILLER_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8769_ _3164_ _1975_ VGND VGND VPWR VPWR _4276_ sky130_fd_sc_hd__and2b_1
XFILLER_138_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer4_X net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__9463__D _0081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5154__A2 net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_input41_A i_b[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5081__A net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8800__B1 _4306_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5614__B1 net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7736__A _3355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6590__A1 net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6590__B2 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5256__A net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold207 _0000_ VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlygate4sd3_1
Xhold229 add_res\[8\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
Xhold218 multiplier_inst.man_final_r\[1\] VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_113_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6120_ _1640_ _1642_ _1653_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a21oi_1
XFILLER_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4656__A1 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6051_ net259 net266 net451 net455 VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__and4_1
XANTENNA__5422__C net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5002_ _0629_ _0630_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nand3b_1
XFILLER_78_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6953_ _1546_ _1568_ _1545_ VGND VGND VPWR VPWR _2583_ sky130_fd_sc_hd__a21boi_2
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4980__D net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_62_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6884_ _2512_ _2513_ _2480_ VGND VGND VPWR VPWR _2514_ sky130_fd_sc_hd__a21bo_1
X_5904_ net641 net289 VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout159_A net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8623_ _3997_ _4184_ VGND VGND VPWR VPWR adder_inst.sum_raw\[11\] sky130_fd_sc_hd__xnor2_1
X_5835_ _1457_ _1458_ _1463_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__a21o_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8554_ net187 _4120_ _4121_ _4124_ _4122_ VGND VGND VPWR VPWR _4125_ sky130_fd_sc_hd__a32o_2
X_5766_ _1390_ _1394_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout326_A net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8485_ _4050_ _4054_ _4056_ VGND VGND VPWR VPWR _4058_ sky130_fd_sc_hd__and3_1
X_4717_ _4450_ _4486_ VGND VGND VPWR VPWR _4488_ sky130_fd_sc_hd__or2_1
X_7505_ _3098_ _3099_ _3134_ VGND VGND VPWR VPWR _3135_ sky130_fd_sc_hd__nor3_1
X_5697_ _1321_ _1325_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__nand3_1
X_4648_ _4396_ _4413_ _4412_ VGND VGND VPWR VPWR _4419_ sky130_fd_sc_hd__a21o_1
X_7436_ _3042_ _3064_ VGND VGND VPWR VPWR _3066_ sky130_fd_sc_hd__or2_1
XFILLER_135_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4579_ _4349_ VGND VGND VPWR VPWR _4350_ sky130_fd_sc_hd__inv_2
X_9106_ net527 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__inv_2
XANTENNA__5316__D net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7367_ _2967_ _2974_ VGND VGND VPWR VPWR _2997_ sky130_fd_sc_hd__xor2_1
XFILLER_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7298_ _2920_ _2926_ VGND VGND VPWR VPWR _2928_ sky130_fd_sc_hd__xor2_1
X_6318_ net265 net465 net472 net261 VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__a22o_1
XFILLER_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9037_ net536 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__inv_2
XFILLER_130_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7833__A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6249_ _1873_ _1877_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5613__B net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_86_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6460__A net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_128_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7588__A0 _3212_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8001__A1 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5620_ _1235_ _1236_ _1249_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__and3_1
X_5551_ net286 net414 net420 net279 VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__a22o_1
XFILLER_117_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8270_ net126 _3841_ _3838_ net122 VGND VGND VPWR VPWR _3843_ sky130_fd_sc_hd__a211o_1
XFILLER_117_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5482_ _1109_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__and2_1
X_7221_ net233 net435 net438 net227 VGND VGND VPWR VPWR _2851_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_57_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout506 opcode_stage1 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__clkbuf_4
X_7152_ _2776_ _2780_ VGND VGND VPWR VPWR _2782_ sky130_fd_sc_hd__xnor2_2
Xfanout539 net549 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__buf_2
Xfanout517 net518 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__clkbuf_4
Xfanout528 net534 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6103_ _1726_ _1731_ _1725_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__a21bo_1
X_7083_ _2601_ _2609_ _2608_ VGND VGND VPWR VPWR _2713_ sky130_fd_sc_hd__a21o_1
XANTENNA__5152__C net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6034_ _1660_ _1663_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__and2b_1
XFILLER_86_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8744__B net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer11 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_fanout276_A net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer55 net605 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__buf_1
Xrebuffer33 _0987_ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA__8240__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7985_ adder_inst.sum_raw_r\[10\] _4341_ net182 adder_inst.sum_raw_r\[8\] net193
+ VGND VGND VPWR VPWR _3576_ sky130_fd_sc_hd__o221a_1
Xrebuffer44 _0556_ VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer22 _1409_ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__buf_2
XFILLER_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer88 net364 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_82_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer66 _2872_ VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd1_1
X_6936_ _2369_ _2565_ VGND VGND VPWR VPWR _2566_ sky130_fd_sc_hd__nand2_1
XFILLER_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer99 net647 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA__4801__B2 net208 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4801__A1 net216 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout443_A net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6867_ _2496_ _2492_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__nand2b_1
X_8606_ _3931_ _3932_ VGND VGND VPWR VPWR _4170_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_81_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout231_X net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5818_ _1445_ _1446_ _1372_ _1385_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__o211ai_2
XFILLER_22_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6798_ net305 net471 VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__nand2_1
Xrebuffer101 adder_inst.exp_b_r\[3\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlymetal6s2s_1
X_8537_ _4064_ _4072_ _4109_ _4075_ _4071_ VGND VGND VPWR VPWR _4110_ sky130_fd_sc_hd__o221ai_4
X_5749_ _1376_ _1377_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nand3b_1
XFILLER_6_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5608__B net475 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8468_ _4040_ VGND VGND VPWR VPWR _4041_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_20_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8399_ _3971_ VGND VGND VPWR VPWR _3972_ sky130_fd_sc_hd__inv_2
X_7419_ _3046_ _3047_ VGND VGND VPWR VPWR _3049_ sky130_fd_sc_hd__xor2_1
XFILLER_104_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8782__A2 net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_123_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6190__A net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9274__Q adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7452__C net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6132__A1_N net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput91 net91 VGND VGND VPWR VPWR o_res[30] sky130_fd_sc_hd__buf_2
Xoutput80 net80 VGND VGND VPWR VPWR o_res[20] sky130_fd_sc_hd__buf_2
XFILLER_110_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5808__B1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5700__C net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_108_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7770_ _3155_ _3288_ _3338_ VGND VGND VPWR VPWR _3379_ sky130_fd_sc_hd__and3_1
X_4982_ _0608_ _0610_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_47_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4795__B1 net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6721_ _2337_ _2348_ _2349_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__nand3_1
X_9440_ clknet_leaf_14_clk multiplier_inst.exp_final\[5\] _0350_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_6652_ _2219_ _2221_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9371_ clknet_leaf_20_clk _0044_ _0281_ VGND VGND VPWR VPWR add_res\[17\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__6531__C net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5603_ _1230_ _1231_ _1223_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__a21oi_1
XFILLER_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8322_ _3889_ _3891_ VGND VGND VPWR VPWR _3895_ sky130_fd_sc_hd__xnor2_2
X_6583_ net306 net447 _2204_ _2203_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__a31o_1
XFILLER_117_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5534_ net401 net407 net297 net304 VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__and4_1
X_5465_ _1091_ _1092_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__and3_1
X_8253_ net120 _3791_ _3820_ _3821_ net155 VGND VGND VPWR VPWR _3826_ sky130_fd_sc_hd__o221a_1
XFILLER_132_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8184_ net145 _3756_ _3757_ VGND VGND VPWR VPWR _3758_ sky130_fd_sc_hd__or3_4
X_7204_ _2819_ _2820_ _2832_ _2833_ VGND VGND VPWR VPWR _2834_ sky130_fd_sc_hd__nand4_2
X_5396_ net146 _1019_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__xnor2_1
XFILLER_99_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7135_ _2759_ _2764_ VGND VGND VPWR VPWR _2765_ sky130_fd_sc_hd__and2_1
Xfanout314 net315 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__buf_2
Xfanout303 net304 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_4
XANTENNA_fanout393_A net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout347 net348 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_4
Xfanout325 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__clkbuf_2
Xfanout336 net337 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__buf_6
Xfanout369 net370 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__buf_6
Xfanout358 adder_inst.man_a_r\[21\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkbuf_8
XFILLER_100_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7066_ _2694_ _2695_ VGND VGND VPWR VPWR _2696_ sky130_fd_sc_hd__nor2_1
XFILLER_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6017_ _1632_ _1634_ _1633_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__o21ba_1
XFILLER_39_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8213__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout279_X net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7968_ adder_inst.sum_raw_r\[6\] net182 VGND VGND VPWR VPWR _3561_ sky130_fd_sc_hd__or2_1
XFILLER_70_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout446_X net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7818__B adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7899_ net194 adder_inst.sum_raw_r\[3\] adder_inst.sum_raw_r\[2\] _3383_ VGND VGND
+ VPWR VPWR _3503_ sky130_fd_sc_hd__o22a_1
XFILLER_70_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6919_ _2412_ _2481_ _2482_ VGND VGND VPWR VPWR _2549_ sky130_fd_sc_hd__nand3_1
XFILLER_23_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__6160__D net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5309__A1_N net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5529__A net555 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5248__B net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer2 adder_inst.man_a_r\[19\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__clkbuf_4
XANTENNA_clkbuf_leaf_20_clk_A clknet_2_3__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6529__A2_N net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5250_ _0877_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__and2b_1
XFILLER_47_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5181_ _0807_ _0808_ _0809_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand3_1
XFILLER_96_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8940_ net519 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__inv_2
XFILLER_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5257__A1 net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5257__B2 net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5711__B net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8871_ net807 mul_res\[23\] net505 VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__mux2_1
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7822_ net492 net487 VGND VGND VPWR VPWR _3428_ sky130_fd_sc_hd__nor2_1
XFILLER_91_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6823__A net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7753_ _3367_ _3370_ VGND VGND VPWR VPWR _3371_ sky130_fd_sc_hd__nor2_2
X_4965_ _0558_ _0593_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_65_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout141_A net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6704_ _2269_ _2322_ _2327_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__a21o_1
X_7684_ _3275_ _3283_ _3274_ VGND VGND VPWR VPWR _3310_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout239_A net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4896_ _0513_ _0524_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nand3_1
X_9423_ clknet_leaf_27_clk multiplier_inst.man_final\[11\] _0333_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_22_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6635_ _2196_ _2198_ _2197_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__o21ai_1
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout406_A net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9354_ clknet_leaf_29_clk _0036_ _0264_ VGND VGND VPWR VPWR add_res\[0\] sky130_fd_sc_hd__dfrtp_1
X_6566_ net424 net430 net329 net336 VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__and4_1
XFILLER_118_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9285_ clknet_leaf_22_clk adder_inst.sum_raw\[22\] _0195_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_5517_ _1140_ _1142_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__xnor2_2
X_8305_ _3876_ _3877_ VGND VGND VPWR VPWR _3878_ sky130_fd_sc_hd__nand2_1
XANTENNA__4940__B1 net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8236_ net136 _3733_ _3808_ net138 VGND VGND VPWR VPWR _3809_ sky130_fd_sc_hd__a211o_1
X_6497_ _2124_ _2125_ _2123_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__o21bai_1
XFILLER_121_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5448_ _1077_ _1038_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__xor2_2
XFILLER_105_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5379_ _1007_ _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__xnor2_1
X_8167_ net269 net411 net158 VGND VGND VPWR VPWR _3741_ sky130_fd_sc_hd__mux2_1
Xfanout122 net123 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_2
Xfanout111 net112 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_8
XANTENNA_fanout396_X net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8098_ _3277_ _3657_ _3278_ VGND VGND VPWR VPWR _3672_ sky130_fd_sc_hd__a21oi_1
Xfanout144 _3704_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout133 _3711_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_8
Xfanout155 _3666_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_4
XANTENNA__7820__C adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7118_ _2745_ _2746_ _2739_ VGND VGND VPWR VPWR _2748_ sky130_fd_sc_hd__a21o_1
Xfanout199 adder_inst.i_vld_r2 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_2
Xfanout166 _3665_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
Xfanout188 _3355_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_2
XFILLER_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout177 net178 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7049_ _2678_ _2582_ VGND VGND VPWR VPWR _2679_ sky130_fd_sc_hd__and2b_1
XFILLER_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8198__A0 net246 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6748__A1 net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6748__B2 net442 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_120_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__9466__D _0085_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5084__A net202 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_131_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4750_ _4519_ _4520_ VGND VGND VPWR VPWR _4521_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4681_ _4399_ _4405_ _4407_ VGND VGND VPWR VPWR _4452_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_60_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6420_ net418 net332 net336 net412 VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__a22oi_2
X_6351_ _1978_ _1979_ _1977_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__o21bai_1
XFILLER_108_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5302_ _0929_ _0930_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__or3_1
X_9070_ net544 VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6282_ net303 net431 net438 net296 VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__a22o_1
XFILLER_130_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8021_ net501 _4342_ net493 _3606_ net500 VGND VGND VPWR VPWR _3607_ sky130_fd_sc_hd__a32o_1
XFILLER_102_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5233_ _0764_ _0776_ _0812_ _0854_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5164_ _0507_ _0792_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand3_2
XFILLER_68_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5095_ net349 net274 net280 net342 VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a22oi_1
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8923_ net510 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
XFILLER_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8854_ net830 mul_res\[6\] net503 VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__mux2_1
X_7805_ net191 _3410_ VGND VGND VPWR VPWR _3411_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout356_A net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5997_ _1624_ _1625_ _1626_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__or3_1
XFILLER_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8785_ _2543_ _4291_ _2532_ _2533_ VGND VGND VPWR VPWR _4292_ sky130_fd_sc_hd__and4b_1
X_7736_ _3355_ VGND VGND VPWR VPWR multiplier_inst.sign_res sky130_fd_sc_hd__inv_2
XANTENNA_fanout523_A net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4948_ _0545_ _0546_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7667_ net613 _3272_ _3293_ VGND VGND VPWR VPWR _3294_ sky130_fd_sc_hd__a21o_1
X_4879_ _0492_ _0493_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__and3_4
X_9406_ clknet_leaf_13_clk net690 _0316_ VGND VGND VPWR VPWR adder_inst.sign_a_r sky130_fd_sc_hd__dfrtp_2
XFILLER_137_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6618_ _2114_ _2188_ _2187_ _2184_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__o211ai_2
XANTENNA_fanout311_X net311 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7598_ _1081_ _3224_ _1035_ VGND VGND VPWR VPWR _3228_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_78_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout409_X net409 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9337_ clknet_leaf_3_clk net727 _0247_ VGND VGND VPWR VPWR adder_inst.man_b_r\[15\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_106_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6549_ _2092_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__or2_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9268_ clknet_leaf_24_clk adder_inst.sum_raw\[5\] _0178_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[5\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA__7458__A2 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8219_ net122 _3790_ net120 VGND VGND VPWR VPWR _3792_ sky130_fd_sc_hd__a21o_1
X_9199_ clknet_leaf_31_clk net12 _0109_ VGND VGND VPWR VPWR adder_inst.i_a\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_7_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8407__A1 net404 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5632__A net241 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clone64_A net104 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8040__C1 net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8591__B1 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6182__B net402 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5807__A net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_133_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7854__C1 _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6657__B1 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_2__f_clk_A clknet_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5920_ net395 net402 net282 net286 VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__and4_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4605__B net209 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5851_ _1478_ _1479_ _1477_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__a21bo_1
X_4802_ _0430_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8570_ _3895_ _4138_ VGND VGND VPWR VPWR adder_inst.sum_raw\[4\] sky130_fd_sc_hd__xor2_1
XFILLER_22_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5782_ net631 _1410_ _1352_ _1355_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__o211a_1
XFILLER_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4733_ _4489_ _4503_ VGND VGND VPWR VPWR _4504_ sky130_fd_sc_hd__or2_1
X_7521_ _3149_ _3148_ _4393_ VGND VGND VPWR VPWR _3151_ sky130_fd_sc_hd__a21o_4
XTAP_TAPCELL_ROW_32_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7452_ net210 net214 net357 net363 VGND VGND VPWR VPWR _3082_ sky130_fd_sc_hd__and4_1
XFILLER_30_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4664_ _4428_ _4433_ VGND VGND VPWR VPWR _4435_ sky130_fd_sc_hd__xor2_1
X_6403_ _2022_ _2024_ _2031_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__and3_1
XFILLER_134_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7383_ _3009_ _3012_ _3006_ VGND VGND VPWR VPWR _3013_ sky130_fd_sc_hd__a21oi_1
X_4595_ net203 net358 _4364_ _4362_ VGND VGND VPWR VPWR _4366_ sky130_fd_sc_hd__a31o_1
X_9122_ net538 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__inv_2
X_6334_ _1944_ _1962_ _1963_ _1881_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__o211ai_4
XFILLER_115_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9053_ net533 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__inv_2
XANTENNA__8747__B net181 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6265_ _1892_ _1893_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__or3_4
XFILLER_135_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8004_ net116 _3592_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__and2_1
X_5216_ _0844_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_73_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6196_ net585 _1824_ _1818_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a21bo_1
XFILLER_130_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5147_ _0509_ _0756_ _0758_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__o21a_1
XFILLER_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout473_A net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5078_ _0643_ _0645_ _0642_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__o21ba_1
XANTENNA__7073__B1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8906_ net515 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__inv_2
XFILLER_72_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout261_X net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_fanout359_X net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8837_ _3259_ _4326_ VGND VGND VPWR VPWR _4327_ sky130_fd_sc_hd__xnor2_1
XFILLER_52_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8768_ _1810_ _3165_ VGND VGND VPWR VPWR _4275_ sky130_fd_sc_hd__xor2_1
XFILLER_13_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7719_ adder_inst.exp_a_r\[7\] adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR _3342_
+ sky130_fd_sc_hd__nand2b_4
XFILLER_40_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8699_ _4067_ _4251_ VGND VGND VPWR VPWR adder_inst.sum_raw\[20\] sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_10_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7229__A1_N net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5081__B net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input34_A i_b[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8800__A1 net340 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5614__A1 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5614__B2 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9277__Q adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold208 multiplier_inst.exp_final_r\[7\] VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__5256__B net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7752__A _3364_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold219 add_res\[13\] VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8567__B net683 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5272__A net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_112_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6050_ _1266_ _1265_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5422__D net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5001_ net250 net380 net387 net244 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__a22o_1
XANTENNA__4656__A2 net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6952_ _1572_ _1608_ _1571_ VGND VGND VPWR VPWR _2582_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_37_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6883_ _2482_ _2483_ _2484_ _2509_ VGND VGND VPWR VPWR _2513_ sky130_fd_sc_hd__a22o_1
X_5903_ _1425_ _1427_ _1426_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__o21bai_1
X_8622_ _4183_ net174 _4180_ VGND VGND VPWR VPWR _4184_ sky130_fd_sc_hd__a21o_1
XFILLER_62_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5834_ _1457_ _1458_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__nand3_1
XANTENNA__6831__A net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8553_ _4123_ _4115_ net173 VGND VGND VPWR VPWR _4124_ sky130_fd_sc_hd__o21a_1
X_5765_ _1392_ _1393_ _1391_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__a21o_1
X_8484_ _4054_ _4056_ VGND VGND VPWR VPWR _4057_ sky130_fd_sc_hd__and2_1
X_4716_ _4450_ _4486_ VGND VGND VPWR VPWR _4487_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout221_A net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7504_ _4387_ _3133_ VGND VGND VPWR VPWR _3134_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout319_A net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5696_ _1323_ _1324_ _1322_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__o21ai_1
X_4647_ _4415_ _4417_ VGND VGND VPWR VPWR _4418_ sky130_fd_sc_hd__nand2_1
X_7435_ _3042_ _3064_ VGND VGND VPWR VPWR _3065_ sky130_fd_sc_hd__nand2_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7366_ _2988_ _2995_ _2987_ VGND VGND VPWR VPWR _2996_ sky130_fd_sc_hd__a21o_1
X_4578_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] VGND VGND VPWR VPWR _4349_
+ sky130_fd_sc_hd__and2b_1
XFILLER_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9105_ net527 VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__inv_2
X_6317_ net255 net479 VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__nand2_1
XFILLER_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7297_ _2921_ _2926_ VGND VGND VPWR VPWR _2927_ sky130_fd_sc_hd__nor2_1
XFILLER_131_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9036_ net546 VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__inv_2
X_6248_ _1873_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__nand2_1
XANTENNA__5613__C net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6179_ _1715_ _1807_ _1806_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__a21bo_1
XFILLER_130_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout476_X net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__6460__B net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5076__B net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7588__A1 _3217_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5550_ net279 net286 net414 net420 VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__and4_1
XANTENNA__7753__Y _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5481_ _1108_ _1110_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__nor2_2
XFILLER_8_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7220_ net227 net233 net432 net437 VGND VGND VPWR VPWR _2850_ sky130_fd_sc_hd__and4_1
XANTENNA__5523__B1 _1113_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_57_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7151_ _2776_ _2780_ VGND VGND VPWR VPWR _2781_ sky130_fd_sc_hd__nand2b_1
Xfanout518 net523 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__clkbuf_2
XFILLER_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout529 net534 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__buf_4
XFILLER_86_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout507 net508 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__buf_4
X_7082_ _2685_ _2710_ VGND VGND VPWR VPWR _2712_ sky130_fd_sc_hd__xnor2_2
X_6102_ _1725_ _1726_ _1731_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__nand3_1
X_6033_ _1660_ _1661_ _1662_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__or3_4
XFILLER_112_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5152__D net301 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer12 net560 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_67_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer34 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__buf_2
Xrebuffer45 net593 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlymetal6s2s_1
X_7984_ adder_inst.sum_raw_r\[9\] net170 VGND VGND VPWR VPWR _3575_ sky130_fd_sc_hd__or2_1
XFILLER_82_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer56 net606 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__buf_1
XANTENNA_fanout269_A net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer67 _0532_ VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_81_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6935_ _2370_ _2558_ _2553_ _2564_ VGND VGND VPWR VPWR _2565_ sky130_fd_sc_hd__o31ai_4
XFILLER_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4801__A2 net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer89 _1812_ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_41_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6866_ _2493_ _2495_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout436_A net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8605_ _4160_ _4159_ _3936_ VGND VGND VPWR VPWR _4169_ sky130_fd_sc_hd__a21boi_2
XTAP_TAPCELL_ROW_81_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5817_ _1372_ _1385_ _1445_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__a211o_4
XANTENNA__6280__B net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6797_ _2425_ _2426_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__nor2_1
XANTENNA_fanout224_X net224 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer102 net650 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer113 _3279_ VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd1_1
X_8536_ _4032_ _4039_ _4108_ _4045_ _4031_ VGND VGND VPWR VPWR _4109_ sky130_fd_sc_hd__a221oi_4
X_5748_ net396 net297 net302 net389 VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__a22o_1
Xrebuffer135 _3690_ VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__buf_1
XFILLER_41_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8467_ _4036_ _4037_ VGND VGND VPWR VPWR _4040_ sky130_fd_sc_hd__and2_1
XFILLER_108_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5905__A net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5679_ net396 net308 VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__nand2_1
X_8398_ net156 _3969_ _3970_ VGND VGND VPWR VPWR _3971_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_96_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7418_ net357 net221 _3046_ VGND VGND VPWR VPWR _3048_ sky130_fd_sc_hd__and3_1
XFILLER_116_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7349_ _2975_ _2976_ VGND VGND VPWR VPWR _2979_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9019_ net511 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__inv_2
XFILLER_1_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6190__B net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__9290__Q adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7452__D net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5534__B net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput70 net70 VGND VGND VPWR VPWR o_res[11] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR o_res[31] sky130_fd_sc_hd__buf_2
Xoutput81 net81 VGND VGND VPWR VPWR o_res[21] sky130_fd_sc_hd__buf_2
XFILLER_122_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5808__B2 net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5808__A1 net630 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5550__A net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8758__B1 _0104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6365__B net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5700__D net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4981_ net355 net280 net287 net349 VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a22o_1
XFILLER_51_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6720_ _2337_ _2348_ _2349_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__and3_1
XANTENNA_clkbuf_leaf_9_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6651_ _2273_ _2275_ _2272_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__o21ba_1
X_9370_ clknet_leaf_20_clk _0043_ _0280_ VGND VGND VPWR VPWR add_res\[16\] sky130_fd_sc_hd__dfrtp_1
XANTENNA__6531__D net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6582_ _2136_ _2210_ _2211_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__nand3_2
X_5602_ _1223_ _1230_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__and3_1
X_8321_ _3893_ VGND VGND VPWR VPWR _3894_ sky130_fd_sc_hd__inv_2
X_5533_ net414 net290 VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nand2_1
XFILLER_118_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5464_ _1040_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__nor2_1
X_8252_ net463 net154 VGND VGND VPWR VPWR _3825_ sky130_fd_sc_hd__nor2_1
XFILLER_132_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5395_ _1022_ _1023_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__xnor2_1
X_8183_ net133 _3750_ _3748_ net137 VGND VGND VPWR VPWR _3757_ sky130_fd_sc_hd__o211a_1
X_7203_ _2830_ _2831_ _2827_ VGND VGND VPWR VPWR _2833_ sky130_fd_sc_hd__a21o_1
Xfanout304 adder_inst.man_b_r\[6\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
X_7134_ _2762_ _2763_ VGND VGND VPWR VPWR _2764_ sky130_fd_sc_hd__xnor2_1
XANTENNA__8755__B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout348 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout337 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__buf_6
Xfanout326 net327 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__buf_2
Xfanout315 net316 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__buf_2
XFILLER_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout386_A net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout359 net364 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__buf_2
X_7065_ _2591_ _2597_ _2590_ VGND VGND VPWR VPWR _2695_ sky130_fd_sc_hd__a21oi_1
X_6016_ _1643_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__nor2_1
XFILLER_55_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7972__B2 adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7972__A1 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7967_ net114 _3560_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__and2_1
XFILLER_54_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7818__C adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7898_ adder_inst.sum_raw_r\[1\] net487 _3462_ adder_inst.sum_raw_r\[0\] _3394_ VGND
+ VGND VPWR VPWR _3502_ sky130_fd_sc_hd__a221o_1
XANTENNA_fanout341_X net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout439_X net439 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6918_ _2481_ _2546_ _2514_ _2511_ VGND VGND VPWR VPWR _2548_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_25_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6849_ _2478_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__inv_2
XFILLER_10_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9499_ clknet_leaf_17_clk net771 _0409_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
XFILLER_108_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8519_ _4025_ _4091_ VGND VGND VPWR VPWR _4092_ sky130_fd_sc_hd__and2_1
XANTENNA__5073__C net392 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_125_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7963__A1 adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_25_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_61_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5529__B net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_136_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7744__B _3362_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer3 _1675_ VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__buf_6
XANTENNA__5545__A net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5180_ _0807_ _0808_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__and3_1
XFILLER_69_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_666 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5257__A2 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_700 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8870_ net770 mul_res\[22\] net505 VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__mux2_1
XFILLER_37_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7821_ adder_inst.sum_raw_r\[3\] adder_inst.sum_raw_r\[5\] adder_inst.sum_raw_r\[4\]
+ adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR _3427_ sky130_fd_sc_hd__or4_1
XFILLER_52_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6823__B net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_16_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
X_7752_ _3364_ _3365_ _3368_ _3369_ VGND VGND VPWR VPWR _3370_ sky130_fd_sc_hd__or4_1
X_4964_ _0549_ _0554_ _0548_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_65_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6703_ _2331_ _2332_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__xnor2_1
X_7683_ _3307_ _3308_ VGND VGND VPWR VPWR _3309_ sky130_fd_sc_hd__nor2_1
X_4895_ _0510_ _0512_ _0511_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__o21ai_1
X_9422_ clknet_leaf_27_clk multiplier_inst.man_final\[10\] _0332_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_137_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6634_ _2202_ _2208_ _2207_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__a21o_1
X_9353_ clknet_leaf_8_clk adder_inst.is_nan_b _0263_ VGND VGND VPWR VPWR adder_inst.is_nan_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_6565_ _2182_ _2194_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__and2_1
XFILLER_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9284_ clknet_leaf_23_clk adder_inst.sum_raw\[21\] _0194_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_fanout301_A net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5516_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__nand2b_4
X_8304_ _4334_ _3874_ net156 VGND VGND VPWR VPWR _3877_ sky130_fd_sc_hd__mux2_2
XANTENNA__4940__A1 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4940__B2 net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6496_ _2123_ _2124_ _2125_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__or3_1
X_5447_ net621 _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__nor2_4
X_8235_ _4358_ net151 net656 net148 _3772_ VGND VGND VPWR VPWR _3808_ sky130_fd_sc_hd__o41a_1
XFILLER_105_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5378_ net202 net411 VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__nand2_1
X_8166_ net168 _3680_ net150 _3699_ _3739_ VGND VGND VPWR VPWR _3740_ sky130_fd_sc_hd__a41o_1
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_8
X_8097_ _3669_ _3670_ VGND VGND VPWR VPWR _3671_ sky130_fd_sc_hd__nand2_1
Xfanout123 _3729_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_2
Xfanout156 _3666_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_4
Xfanout145 _3704_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_4
Xfanout134 net659 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
XANTENNA__7820__D adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7117_ _2739_ _2745_ _2746_ VGND VGND VPWR VPWR _2747_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout291_X net291 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout178 _4270_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_2
Xfanout189 _4344_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_2
XFILLER_86_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7048_ _2640_ _2677_ VGND VGND VPWR VPWR _2678_ sky130_fd_sc_hd__xnor2_2
XANTENNA_fanout389_X net389 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6436__D net448 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8198__A1 net388 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8999_ net535 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__inv_2
XFILLER_27_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5084__B net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input64_A i_b[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8673__A2 net683 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_131_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4998__A1 net381 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7755__A adder_inst.is_zero_b_r VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4680_ _4444_ _4449_ VGND VGND VPWR VPWR _4451_ sky130_fd_sc_hd__xnor2_1
XANTENNA__9392__D adder_inst.exp_larger\[6\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_60_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6350_ _1977_ _1978_ _1979_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__or3_1
XFILLER_115_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5301_ net249 net413 net419 net243 VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__a22oi_1
XFILLER_6_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6281_ net290 net443 VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_5_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_115_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8020_ adder_inst.sum_raw_r\[15\] _3470_ net491 VGND VGND VPWR VPWR _3606_ sky130_fd_sc_hd__a21o_1
X_5232_ _0859_ _0860_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_75_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5163_ _0500_ _0501_ _0506_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__a21o_1
XFILLER_96_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5094_ net349 net342 net274 net281 VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__and4_1
XFILLER_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8922_ net510 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__inv_2
XFILLER_83_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8853_ net820 mul_res\[5\] net503 VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__mux2_1
XFILLER_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout251_A net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7804_ net497 _3396_ _3398_ _3403_ _3409_ VGND VGND VPWR VPWR _3410_ sky130_fd_sc_hd__a221o_1
XFILLER_52_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout349_A adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5996_ net630 net331 net338 net384 VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__a22oi_2
X_8784_ _2487_ _2508_ VGND VGND VPWR VPWR _4291_ sky130_fd_sc_hd__xnor2_1
X_7735_ adder_inst.sign_b_r adder_inst.sign_a_r VGND VGND VPWR VPWR _3355_ sky130_fd_sc_hd__xnor2_4
X_4947_ _0533_ _0560_ _0575_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a21o_1
XFILLER_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout516_A net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7666_ _3282_ _3292_ VGND VGND VPWR VPWR _3293_ sky130_fd_sc_hd__xnor2_1
X_4878_ _0500_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nand2_1
XFILLER_137_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9405_ clknet_leaf_13_clk adder_inst.is_zero_a _0315_ VGND VGND VPWR VPWR adder_inst.is_zero_a_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_123_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6617_ _2243_ _2246_ _2195_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__o21ai_2
XFILLER_20_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9336_ clknet_leaf_1_clk net698 _0246_ VGND VGND VPWR VPWR adder_inst.man_b_r\[14\]
+ sky130_fd_sc_hd__dfrtp_4
XANTENNA_fanout304_X net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7597_ _1035_ _1081_ _3224_ VGND VGND VPWR VPWR _3227_ sky130_fd_sc_hd__and3_1
XFILLER_106_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6548_ _2169_ _2171_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_91_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9267_ clknet_leaf_24_clk adder_inst.sum_raw\[4\] _0177_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[4\]
+ sky130_fd_sc_hd__dfrtp_4
X_6479_ _2107_ _2108_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8218_ _3729_ _3790_ VGND VGND VPWR VPWR _3791_ sky130_fd_sc_hd__nand2_1
X_9198_ clknet_leaf_0_clk net1 _0108_ VGND VGND VPWR VPWR adder_inst.i_a\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_7_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8407__A2 net162 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8149_ net476 net164 _3722_ VGND VGND VPWR VPWR _3723_ sky130_fd_sc_hd__o21ai_1
XANTENNA__5632__B net248 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_101_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5929__B1 net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5807__B net630 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap109 _3199_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_6
XFILLER_7_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_input67_X net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6657__A1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6657__B2 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_105_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4605__C net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5850_ _1477_ _1478_ _1479_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4801_ net216 net394 net399 net208 VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a22oi_1
XFILLER_21_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5781_ _1352_ _1355_ _1410_ net575 VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__a211oi_4
X_4732_ _4497_ _4502_ VGND VGND VPWR VPWR _4503_ sky130_fd_sc_hd__xnor2_1
X_7520_ _3148_ _3149_ VGND VGND VPWR VPWR _3150_ sky130_fd_sc_hd__nand2_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4663_ _4428_ _4433_ VGND VGND VPWR VPWR _4434_ sky130_fd_sc_hd__and2_1
X_7451_ _3062_ _3077_ _3080_ VGND VGND VPWR VPWR _3081_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_32_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6402_ _2022_ _2024_ _2031_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_12_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7382_ _3010_ _3011_ VGND VGND VPWR VPWR _3012_ sky130_fd_sc_hd__nand2_1
X_4594_ _4362_ _4364_ VGND VGND VPWR VPWR _4365_ sky130_fd_sc_hd__and2b_1
XFILLER_128_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9121_ net538 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__inv_2
XFILLER_89_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6333_ _1864_ _1865_ _1879_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__o21ai_2
XFILLER_115_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9052_ net531 VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__inv_2
XANTENNA__8747__C net178 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6264_ net406 net332 net337 net400 VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__a22oi_2
XFILLER_130_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8003_ net485 net499 net172 net501 _3591_ VGND VGND VPWR VPWR _3592_ sky130_fd_sc_hd__a221o_1
XANTENNA__5452__B _1080_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5215_ net200 net444 VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
XFILLER_97_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6195_ _1818_ _1819_ _1824_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__nand3_1
XANTENNA_fanout299_A net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5146_ _0593_ _0762_ _0763_ _0760_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o22ai_2
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5077_ _0705_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout466_A adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7073__B2 net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7073__A1 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8905_ net513 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_88_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8836_ _3270_ _4325_ _4326_ VGND VGND VPWR VPWR multiplier_inst.man_final\[16\] sky130_fd_sc_hd__and3_1
XANTENNA_fanout254_X net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8767_ _3153_ _3167_ VGND VGND VPWR VPWR _4274_ sky130_fd_sc_hd__nor2_1
X_5979_ _1571_ _1572_ _1608_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nand3_1
X_7718_ adder_inst.exp_a_r\[7\] adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR _3341_
+ sky130_fd_sc_hd__and2b_1
XANTENNA_fanout421_X net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8698_ net188 _4250_ _4245_ _4246_ VGND VGND VPWR VPWR _4251_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_21_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7649_ adder_inst.exp_b_r\[2\] adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR _3277_
+ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_10_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9319_ clknet_leaf_9_clk net739 _0229_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_106_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7836__B1 _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__6452__A2_N net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5081__C net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input27_A i_a[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8800__A2 net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5614__A2 net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4722__A net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__8316__A1 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__7592__X _3222_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7752__B _3365_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xhold209 add_res\[21\] VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_109_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5272__B net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_124_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5000_ net244 net250 net380 net387 VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand4_1
XFILLER_98_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6951_ _2577_ _2580_ VGND VGND VPWR VPWR _2581_ sky130_fd_sc_hd__nand2_1
XFILLER_19_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6882_ _2482_ _2483_ _2484_ _2509_ VGND VGND VPWR VPWR _2512_ sky130_fd_sc_hd__nand4_1
X_5902_ _1437_ _1439_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__nand2_1
X_8621_ _4182_ _4181_ net106 VGND VGND VPWR VPWR _4183_ sky130_fd_sc_hd__mux2_4
XFILLER_61_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5833_ _1459_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__xnor2_1
XANTENNA__6831__B net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_17_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8552_ _3783_ _4091_ _4024_ VGND VGND VPWR VPWR _4123_ sky130_fd_sc_hd__a21o_1
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5728__A net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_62_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7503_ _4385_ _4386_ VGND VGND VPWR VPWR _3133_ sky130_fd_sc_hd__or2_1
X_5764_ _1391_ _1392_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__nand3_1
X_8483_ _4052_ _4053_ VGND VGND VPWR VPWR _4056_ sky130_fd_sc_hd__nand2b_1
X_4715_ _4484_ _4485_ VGND VGND VPWR VPWR _4486_ sky130_fd_sc_hd__nor2_1
XANTENNA__6318__B1 net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5695_ _1322_ _1323_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__or3_4
XFILLER_135_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4646_ net375 net239 _4415_ _4416_ VGND VGND VPWR VPWR _4417_ sky130_fd_sc_hd__nand4_1
X_7434_ _3062_ _3063_ VGND VGND VPWR VPWR _3064_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout214_A net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5629__A2_N net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4577_ adder_inst.exp_a_r\[1\] adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR _4348_
+ sky130_fd_sc_hd__nand2b_1
XFILLER_116_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7365_ _2989_ _2993_ VGND VGND VPWR VPWR _2995_ sky130_fd_sc_hd__xnor2_2
XFILLER_116_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9104_ net524 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__inv_2
X_6316_ net261 net265 net465 net472 VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__and4_1
XFILLER_115_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7296_ _2924_ _2925_ VGND VGND VPWR VPWR _2926_ sky130_fd_sc_hd__xnor2_1
X_9035_ net535 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__inv_2
XFILLER_77_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6247_ _1874_ _1875_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5613__D net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6178_ _1806_ _1807_ _1715_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__nand3b_1
X_5129_ _0509_ _0756_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nor3_4
XANTENNA_fanout371_X net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout469_X net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8819_ _3210_ _3204_ _3220_ VGND VGND VPWR VPWR _4317_ sky130_fd_sc_hd__or3_4
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_128_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5048__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7587__X _3217_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__9288__Q adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6796__B1 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5480_ net619 _1086_ net602 _1107_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__o211a_1
XANTENNA__5523__A1 _1114_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7150_ _2777_ _2778_ VGND VGND VPWR VPWR _2780_ sky130_fd_sc_hd__xnor2_2
XANTENNA__6098__B net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout519 net520 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__buf_4
XFILLER_113_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout508 net509 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7081_ _2685_ _2710_ VGND VGND VPWR VPWR _2711_ sky130_fd_sc_hd__and2b_1
X_6101_ _1727_ _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__xnor2_1
XFILLER_98_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6032_ net285 net433 net439 net278 VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__a22oi_1
XFILLER_82_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7983_ net115 _3574_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and2_1
XFILLER_82_723 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer35 net583 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__buf_1
Xrebuffer24 net379 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_54_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer46 _1657_ VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer57 _1018_ VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__buf_1
XANTENNA_fanout164_A _3665_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer68 _0532_ VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_85_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6934_ _2556_ _2563_ _2561_ VGND VGND VPWR VPWR _2564_ sky130_fd_sc_hd__o21ai_1
XFILLER_19_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8604_ _4167_ _4166_ net671 VGND VGND VPWR VPWR _4168_ sky130_fd_sc_hd__mux2_4
X_6865_ _2493_ _2494_ net324 net473 VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__and4bb_1
XANTENNA__6280__C net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6796_ net317 net459 net464 net310 VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__a22oi_1
XANTENNA_fanout331_A net333 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5816_ _1432_ _1433_ _1444_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__o21ba_2
Xrebuffer103 net651 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__buf_1
X_8535_ _4106_ _4058_ _4107_ VGND VGND VPWR VPWR _4108_ sky130_fd_sc_hd__a21o_1
X_5747_ net630 net396 net297 net302 VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__nand4_1
XANTENNA__5568__A2_N net433 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout217_X net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer114 _3279_ VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer136 _3663_ VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlymetal6s2s_1
X_8466_ _4036_ _4037_ VGND VGND VPWR VPWR _4039_ sky130_fd_sc_hd__nor2_2
XFILLER_41_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7417_ net357 net219 VGND VGND VPWR VPWR _3047_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5678_ _1305_ _1306_ _1301_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__a21o_1
XANTENNA__5905__B net383 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_135_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4629_ net361 net239 VGND VGND VPWR VPWR _4400_ sky130_fd_sc_hd__nand2_1
X_8397_ net270 net163 VGND VGND VPWR VPWR _3970_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_96_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7348_ _2971_ _2973_ VGND VGND VPWR VPWR _2978_ sky130_fd_sc_hd__nand2_1
XFILLER_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__8464__A0 net376 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_103_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7279_ _2900_ _2908_ _2899_ VGND VGND VPWR VPWR _2909_ sky130_fd_sc_hd__a21oi_1
XFILLER_1_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9018_ net511 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__inv_2
XFILLER_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6752__A net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_123_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5534__C net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput82 net82 VGND VGND VPWR VPWR o_res[22] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR o_res[12] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR o_res[3] sky130_fd_sc_hd__buf_2
XFILLER_68_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5808__A2 net297 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5550__B net286 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6365__C net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4980_ net349 net355 net280 net287 VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_67_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4795__A2 net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6650_ _2209_ _2264_ _2279_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__nand3_2
XFILLER_32_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6581_ _2129_ _2130_ _2135_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__a21o_1
XFILLER_31_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5601_ _1228_ _1229_ _1224_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__a21o_1
X_8320_ _3889_ _3891_ VGND VGND VPWR VPWR _3893_ sky130_fd_sc_hd__nand2b_1
X_5532_ _1159_ _1161_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__nor2_1
XFILLER_127_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5463_ _0728_ _0735_ _1039_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__and3_1
XFILLER_105_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8251_ _3822_ _3823_ VGND VGND VPWR VPWR _3824_ sky130_fd_sc_hd__or2_1
XFILLER_132_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5394_ _1022_ _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__or2_1
X_8182_ net133 _3755_ _3753_ net139 VGND VGND VPWR VPWR _3756_ sky130_fd_sc_hd__o211a_1
X_7202_ _2827_ _2830_ _2831_ VGND VGND VPWR VPWR _2832_ sky130_fd_sc_hd__nand3_2
X_7133_ net201 net466 VGND VGND VPWR VPWR _2763_ sky130_fd_sc_hd__nand2_1
Xfanout305 net307 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_4
XFILLER_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout316 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__buf_2
XFILLER_59_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout327 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__buf_2
Xfanout338 net340 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__buf_4
Xfanout349 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkbuf_4
X_7064_ _2692_ _2693_ VGND VGND VPWR VPWR _2694_ sky130_fd_sc_hd__or2_1
XANTENNA_fanout281_A net282 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout379_A adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6015_ _1643_ _1644_ net290 net426 VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__and4bb_1
XFILLER_82_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7966_ net483 adder_inst.sum_raw_r\[13\] adder_inst.sum_raw_r\[12\] net171 _3559_
+ VGND VGND VPWR VPWR _3560_ sky130_fd_sc_hd__a221o_1
XFILLER_82_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7897_ net114 _3500_ _3501_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__and3_1
XANTENNA__5188__A net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6917_ _2481_ _2514_ _2546_ VGND VGND VPWR VPWR _2547_ sky130_fd_sc_hd__nand3_1
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6848_ net153 _2477_ _2444_ _2448_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__o211ai_4
XFILLER_23_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout501_X net501 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_98_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8518_ _4022_ _4023_ _4020_ _4021_ VGND VGND VPWR VPWR _4091_ sky130_fd_sc_hd__a211o_4
XFILLER_10_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6779_ _2402_ _2407_ _2408_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__nand3_2
XFILLER_136_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9498_ clknet_leaf_18_clk net759 _0408_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
XFILLER_136_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8449_ _3937_ net119 _4017_ _4018_ net164 VGND VGND VPWR VPWR _4022_ sky130_fd_sc_hd__a221o_1
XFILLER_117_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5073__D net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6747__A net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_125_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5423__B1 net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5529__C net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_136_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer4 adder_inst.man_a_r\[14\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__buf_6
XANTENNA__4730__A net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5545__B net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_114_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7939__C1 net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7820_ adder_inst.sum_raw_r\[6\] adder_inst.sum_raw_r\[9\] adder_inst.sum_raw_r\[8\]
+ adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR _3426_ sky130_fd_sc_hd__or4_1
XFILLER_91_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7751_ adder_inst.i_a\[17\] adder_inst.i_a\[18\] adder_inst.i_a\[21\] adder_inst.i_a\[22\]
+ VGND VGND VPWR VPWR _3369_ sky130_fd_sc_hd__or4_1
X_4963_ _0576_ _0592_ _0558_ _0559_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a211oi_2
XFILLER_52_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7682_ net652 adder_inst.exp_a_r\[3\] _3306_ VGND VGND VPWR VPWR _3308_ sky130_fd_sc_hd__a21oi_1
X_6702_ net305 net458 VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__nand2_1
XFILLER_138_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4894_ net258 net392 _0504_ _0503_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a31o_1
X_9421_ clknet_leaf_27_clk multiplier_inst.man_final\[9\] _0331_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[9\] sky130_fd_sc_hd__dfrtp_1
X_6633_ _2212_ _2225_ _2224_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_22_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5736__A net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9352_ clknet_leaf_14_clk net199 _0262_ VGND VGND VPWR VPWR add_vld sky130_fd_sc_hd__dfrtp_1
XFILLER_138_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6564_ _2176_ _2177_ _2181_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__a21o_1
X_9283_ clknet_leaf_23_clk adder_inst.sum_raw\[20\] _0193_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_5515_ net550 _1137_ _1139_ _1143_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__o211ai_4
X_8303_ net162 _3874_ _3875_ VGND VGND VPWR VPWR _3876_ sky130_fd_sc_hd__a21oi_2
XANTENNA__4940__A2 net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6495_ net424 net329 net336 net418 VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__a22oi_2
X_5446_ _1075_ _1074_ _1067_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__nor3_4
X_8234_ _4358_ _3679_ net654 _3698_ _3769_ VGND VGND VPWR VPWR _3807_ sky130_fd_sc_hd__o41a_1
XFILLER_105_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8766__B net199 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5377_ _1005_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__nor2_1
X_8165_ _3738_ VGND VGND VPWR VPWR _3739_ sky130_fd_sc_hd__inv_2
Xfanout113 _3152_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_8
XANTENNA__6567__A net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8096_ _3667_ _3668_ _3305_ VGND VGND VPWR VPWR _3670_ sky130_fd_sc_hd__a21o_1
Xfanout135 net136 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_2
Xfanout124 _3728_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_2
XFILLER_101_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7116_ _2743_ _2744_ _2740_ VGND VGND VPWR VPWR _2746_ sky130_fd_sc_hd__a21o_1
Xfanout168 _4357_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
Xfanout157 _3666_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_2
Xfanout179 net180 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_2
XANTENNA_input1_A i_a[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout284_X net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7047_ _2641_ _2676_ VGND VGND VPWR VPWR _2677_ sky130_fd_sc_hd__xor2_2
XFILLER_47_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout549_X net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8998_ net543 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__inv_2
XFILLER_82_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout451_X net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_704 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7949_ adder_inst.sum_raw_r\[9\] net189 net169 adder_inst.sum_raw_r\[8\] net184 VGND
+ VGND VPWR VPWR _3545_ sky130_fd_sc_hd__o221a_1
XFILLER_70_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6113__A2_N net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_input57_A i_b[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_131_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_8_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5531__D net308 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7579__Y _3209_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4998__A2 net256 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5556__A net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5300_ net238 net425 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand2_1
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6280_ net296 net303 net431 net436 VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__and4_1
XFILLER_130_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5231_ _0860_ _0859_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__and2b_1
XFILLER_123_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5162_ _0781_ _0786_ _0780_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__a21bo_1
XFILLER_68_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5093_ _0719_ _0720_ _0640_ _0657_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__o211ai_2
X_8921_ net509 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
XFILLER_110_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8852_ net791 mul_res\[4\] net503 VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__mux2_1
XFILLER_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7803_ net195 _3408_ _3404_ VGND VGND VPWR VPWR _3409_ sky130_fd_sc_hd__o21a_1
X_8783_ _2538_ _4289_ VGND VGND VPWR VPWR _4290_ sky130_fd_sc_hd__or2_1
XFILLER_37_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7734_ _3353_ _3354_ VGND VGND VPWR VPWR adder_inst.man_a\[23\] sky130_fd_sc_hd__or2_1
X_5995_ net396 net326 VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout244_A net245 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4946_ _0533_ _0560_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand3_2
XFILLER_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7665_ _4354_ _3154_ _4352_ VGND VGND VPWR VPWR _3292_ sky130_fd_sc_hd__o21ai_1
X_4877_ _0500_ _0501_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__nand3_1
XFILLER_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9404_ clknet_leaf_13_clk adder_inst.sign_sum _0314_ VGND VGND VPWR VPWR adder_inst.sign_sum_r
+ sky130_fd_sc_hd__dfrtp_1
X_7596_ _1081_ _3224_ _1035_ VGND VGND VPWR VPWR _3226_ sky130_fd_sc_hd__a21bo_1
XANTENNA_fanout509_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7560__B1 _3187_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6616_ _2244_ _2245_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__and2_1
XFILLER_20_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9335_ clknet_leaf_1_clk net705 _0245_ VGND VGND VPWR VPWR adder_inst.man_b_r\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_6547_ _2101_ _2175_ _2174_ _2156_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__o211ai_1
XFILLER_134_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9266_ clknet_leaf_24_clk adder_inst.sum_raw\[3\] _0176_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
X_6478_ _2097_ _2099_ _2106_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__and3_1
X_9197_ clknet_leaf_9_clk net65 _0107_ VGND VGND VPWR VPWR adder_inst.i_vld sky130_fd_sc_hd__dfrtp_1
X_5429_ _1046_ _1047_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__or3_4
X_8217_ net127 _3788_ _3789_ _3785_ VGND VGND VPWR VPWR _3790_ sky130_fd_sc_hd__a31o_4
XANTENNA__7863__A1 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6297__A net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8148_ net333 net154 VGND VGND VPWR VPWR _3722_ sky130_fd_sc_hd__or2_1
XFILLER_0_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5632__C net461 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8079_ _4348_ _4355_ _4349_ VGND VGND VPWR VPWR _3653_ sky130_fd_sc_hd__a21oi_4
XFILLER_101_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5626__B1 net451 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5929__A1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5929__B2 net260 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5807__C net609 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6657__A2 net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_100_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4800_ net208 net216 net394 net399 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__and4_1
XANTENNA__4605__D net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5780_ _1387_ _1388_ _1407_ _1408_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__a2bb2oi_1
X_4731_ _4500_ _4501_ VGND VGND VPWR VPWR _4502_ sky130_fd_sc_hd__xnor2_1
XFILLER_14_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4662_ net222 net386 _4431_ _4429_ VGND VGND VPWR VPWR _4433_ sky130_fd_sc_hd__a31o_1
X_7450_ _3078_ _3079_ VGND VGND VPWR VPWR _3080_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_32_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6401_ _1954_ _2030_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9120_ net524 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__inv_2
X_7381_ _3007_ _3008_ VGND VGND VPWR VPWR _3011_ sky130_fd_sc_hd__xor2_2
X_4593_ net351 net209 net214 net346 VGND VGND VPWR VPWR _4364_ sky130_fd_sc_hd__a22o_1
XFILLER_127_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6332_ _1943_ _1945_ _1961_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__and3_2
XFILLER_89_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9051_ net532 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__inv_2
X_6263_ net412 net326 VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__nand2_1
XFILLER_115_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8002_ adder_inst.sum_raw_r\[14\] _3504_ _3589_ _3590_ VGND VGND VPWR VPWR _3591_
+ sky130_fd_sc_hd__o211a_1
XFILLER_103_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5214_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__nor2_1
X_6194_ _1820_ _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__xnor2_1
XFILLER_111_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5145_ _0765_ _0768_ _0767_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5076_ net223 net403 VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__nand2_1
XFILLER_84_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7073__A2 net295 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8904_ net515 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout361_A net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8022__A1 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_88_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout459_A net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8835_ _3244_ _3257_ VGND VGND VPWR VPWR _4326_ sky130_fd_sc_hd__nand2_1
X_8766_ multiplier_inst.is_nan_r net199 net842 VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__and3b_1
XFILLER_52_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5978_ _1573_ _1607_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout247_X net247 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6584__A1 net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7717_ _3329_ _3332_ _3330_ VGND VGND VPWR VPWR _3340_ sky130_fd_sc_hd__o21ba_1
X_8697_ _4033_ _4042_ _4224_ _4051_ _4249_ VGND VGND VPWR VPWR _4250_ sky130_fd_sc_hd__a41o_1
X_4929_ _0556_ _0557_ _0491_ _0509_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a211oi_4
XFILLER_138_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7648_ _3274_ _3275_ VGND VGND VPWR VPWR _3276_ sky130_fd_sc_hd__nand2b_1
XANTENNA__5196__A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout414_X net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5627__C net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_100_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5483__X _1113_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7579_ _1151_ _3208_ VGND VGND VPWR VPWR _3209_ sky130_fd_sc_hd__xnor2_2
X_9318_ clknet_leaf_9_clk net731 _0228_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_118_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9249_ clknet_leaf_5_clk net43 _0159_ VGND VGND VPWR VPWR adder_inst.i_b\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5081__D net417 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__6755__A net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8970__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8013__B2 adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__4722__B net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4889__A1 net240 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5272__C net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6950_ _2578_ _2579_ VGND VGND VPWR VPWR _2580_ sky130_fd_sc_hd__nand2b_1
XFILLER_38_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5901_ _1528_ _1529_ _1514_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__a21o_1
XANTENNA__7774__A_N _3363_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6881_ _2482_ _2483_ _2484_ _2509_ VGND VGND VPWR VPWR _2511_ sky130_fd_sc_hd__and4_1
X_8620_ _4004_ _4102_ _4006_ VGND VGND VPWR VPWR _4182_ sky130_fd_sc_hd__o21a_1
XANTENNA__4913__A net229 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5832_ _1460_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__and2b_1
XFILLER_50_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8551_ _4095_ net671 VGND VGND VPWR VPWR _4122_ sky130_fd_sc_hd__or2_1
XFILLER_61_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5763_ net408 net286 net414 net279 VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__a22o_1
XANTENNA__5728__B net326 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4714_ _4480_ _4483_ VGND VGND VPWR VPWR _4485_ sky130_fd_sc_hd__nor2_1
X_7502_ _4390_ _3131_ VGND VGND VPWR VPWR _3132_ sky130_fd_sc_hd__nor2_1
X_8482_ _4052_ _4053_ VGND VGND VPWR VPWR _4055_ sky130_fd_sc_hd__and2b_1
XANTENNA__6318__B2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6318__A1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5694_ net365 net333 net339 net362 VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a22oi_2
XFILLER_135_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4645_ net368 net246 net252 net361 VGND VGND VPWR VPWR _4416_ sky130_fd_sc_hd__a22o_1
XANTENNA__7943__B adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7433_ _3043_ _3061_ VGND VGND VPWR VPWR _3063_ sky130_fd_sc_hd__nand2_1
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4576_ net537 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__inv_2
XANTENNA_fanout207_A net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7364_ _2989_ _2993_ VGND VGND VPWR VPWR _2994_ sky130_fd_sc_hd__nand2b_1
X_9103_ net524 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__inv_2
X_6315_ _1862_ _1942_ _1941_ _1924_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__o211ai_1
X_9034_ net536 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__inv_2
XFILLER_131_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7295_ net200 net460 VGND VGND VPWR VPWR _2925_ sky130_fd_sc_hd__nand2_1
X_6246_ _1874_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__nand2b_1
XFILLER_131_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6177_ _1713_ _1714_ _1708_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__a21bo_1
XFILLER_29_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5128_ _0606_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__or2_1
XFILLER_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5059_ _0630_ _0632_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout364_X net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_72_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8818_ _4315_ _4316_ VGND VGND VPWR VPWR multiplier_inst.man_final\[8\] sky130_fd_sc_hd__and2b_1
XFILLER_53_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5919__A net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_rebuffer2_X net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8749_ net855 net179 net177 VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_rebuffer12_A net560 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6037__A1_N net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5296__A1 net255 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_95_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__8234__A1 _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_54_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5048__A1 net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5048__B2 net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6796__A1 net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6796__B2 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5829__A net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5564__A net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6100_ _1728_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__nor2_1
XANTENNA__6098__C net315 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8473__A1 net382 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout509 net523 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_70_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7080_ _2698_ _2709_ VGND VGND VPWR VPWR _2710_ sky130_fd_sc_hd__xnor2_2
XFILLER_100_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6031_ net271 net445 VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__nand2_1
XFILLER_39_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4627__B net343 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_67_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer14 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__clkbuf_2
X_7982_ net484 adder_inst.sum_raw_r\[15\] adder_inst.sum_raw_r\[14\] net171 _3573_
+ VGND VGND VPWR VPWR _3574_ sky130_fd_sc_hd__a221o_1
XFILLER_82_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer36 _1819_ VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer25 net573 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_85_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6933_ _2370_ _2411_ _2555_ VGND VGND VPWR VPWR _2563_ sky130_fd_sc_hd__nor3_1
Xrebuffer47 _2117_ VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__buf_6
Xrebuffer58 _1768_ VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlymetal6s2s_1
X_6864_ net335 net460 net466 net330 VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__a22oi_1
XFILLER_35_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout157_A _3666_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8603_ _3934_ _4100_ _3933_ VGND VGND VPWR VPWR _4167_ sky130_fd_sc_hd__o21ba_1
X_5815_ _1432_ _1433_ _1444_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__nor3b_4
XANTENNA__6280__D net436 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6795_ net310 net317 net458 net465 VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__and4_1
Xrebuffer104 net652 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd1_1
X_8534_ _4049_ _4054_ _4048_ VGND VGND VPWR VPWR _4107_ sky130_fd_sc_hd__o21ai_1
XANTENNA_fanout324_A adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5746_ net401 net291 VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__nand2_1
XFILLER_136_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer115 _3661_ VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__buf_6
X_8465_ _4036_ _4037_ VGND VGND VPWR VPWR _4038_ sky130_fd_sc_hd__nand2b_1
X_5677_ _1301_ _1305_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__nand3_1
XFILLER_135_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4628_ net257 _4398_ VGND VGND VPWR VPWR _4399_ sky130_fd_sc_hd__and2_1
X_7416_ _3044_ _3045_ VGND VGND VPWR VPWR _3046_ sky130_fd_sc_hd__nor2_1
XANTENNA__5905__C net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8396_ net123 _3886_ _3968_ net120 VGND VGND VPWR VPWR _3969_ sky130_fd_sc_hd__o211a_1
XFILLER_116_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7347_ _2975_ _2976_ VGND VGND VPWR VPWR _2977_ sky130_fd_sc_hd__nand2_1
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7278_ _2906_ _2907_ VGND VGND VPWR VPWR _2908_ sky130_fd_sc_hd__nor2_1
XFILLER_104_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9017_ net512 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
XFILLER_77_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout481_X net481 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6229_ _1764_ _1857_ _1856_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__o21a_1
XFILLER_57_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8724__S net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_85_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6752__B net317 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_123_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5534__D net304 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput83 net83 VGND VGND VPWR VPWR o_res[23] sky130_fd_sc_hd__buf_2
XFILLER_122_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput72 net72 VGND VGND VPWR VPWR o_res[13] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR o_res[4] sky130_fd_sc_hd__buf_2
XFILLER_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5550__C net414 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__7966__B1 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6580_ _2207_ _2208_ _2202_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__a21bo_1
X_5600_ _1224_ _1228_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__nand3_1
X_5531_ _1159_ _1160_ net401 net308 VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__and4bb_1
XFILLER_117_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8250_ _3819_ _3806_ net164 _3792_ VGND VGND VPWR VPWR _3823_ sky130_fd_sc_hd__o211a_1
X_5462_ _1089_ _1090_ _0701_ _0717_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__o211ai_2
XFILLER_117_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__8694__A1 net370 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7201_ _0910_ _2829_ _2828_ VGND VGND VPWR VPWR _2831_ sky130_fd_sc_hd__a21o_1
X_5393_ _0431_ _0433_ _0430_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__o21ba_1
X_8181_ net435 net155 _3754_ VGND VGND VPWR VPWR _3755_ sky130_fd_sc_hd__a21oi_1
X_7132_ _2760_ _2761_ VGND VGND VPWR VPWR _2762_ sky130_fd_sc_hd__nor2_1
XFILLER_113_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout328 net330 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__buf_2
Xfanout317 net318 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__buf_2
X_7063_ _2690_ _2691_ _2686_ VGND VGND VPWR VPWR _2693_ sky130_fd_sc_hd__a21oi_1
Xfanout339 net340 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_2
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_2
XANTENNA__4638__A net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_86_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6014_ net420 net296 net302 net414 VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_129_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout274_A net275 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7965_ adder_inst.sum_raw_r\[9\] _3504_ _3557_ _3558_ VGND VGND VPWR VPWR _3559_
+ sky130_fd_sc_hd__o211a_1
XFILLER_82_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout539_A net549 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7896_ net194 adder_inst.sum_raw_r\[2\] _3383_ adder_inst.sum_raw_r\[1\] VGND VGND
+ VPWR VPWR _3501_ sky130_fd_sc_hd__o22a_1
XANTENNA_fanout441_A adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6916_ _2484_ net118 _2537_ _2545_ VGND VGND VPWR VPWR _2546_ sky130_fd_sc_hd__a22o_1
XANTENNA__5188__B net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6847_ _2468_ _2475_ _2476_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__and3_4
X_6778_ _2360_ _2372_ _2401_ _2406_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__a211o_1
XANTENNA_fanout327_X net327 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_138_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8517_ _4058_ _4089_ VGND VGND VPWR VPWR _4090_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_98_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5729_ net354 net362 net331 net338 VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__nand4_1
XFILLER_136_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9497_ clknet_leaf_18_clk net783 _0407_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
XFILLER_6_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8448_ net333 net164 VGND VGND VPWR VPWR _4021_ sky130_fd_sc_hd__nor2_1
XFILLER_136_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8379_ net394 net159 VGND VGND VPWR VPWR _3952_ sky130_fd_sc_hd__nor2_1
XFILLER_104_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6747__B net453 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5370__C net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_125_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5423__A1 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5423__B2 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_107_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5529__D net322 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer5 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__buf_6
XANTENNA__4730__B net384 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_61_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6003__A net395 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5545__C net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7884__C1 net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5662__A1 net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5662__B2 net371 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7750_ adder_inst.i_a\[8\] adder_inst.i_a\[11\] adder_inst.i_a\[13\] adder_inst.i_a\[14\]
+ VGND VGND VPWR VPWR _3368_ sky130_fd_sc_hd__or4_1
X_4962_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__inv_2
XFILLER_52_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7681_ net651 adder_inst.exp_a_r\[3\] _3306_ VGND VGND VPWR VPWR _3307_ sky130_fd_sc_hd__and3_1
X_4893_ _0520_ _0521_ _0514_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
XFILLER_51_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6701_ _2329_ _2330_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__nor2_1
X_9420_ clknet_leaf_27_clk multiplier_inst.man_final\[8\] _0330_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[8\] sky130_fd_sc_hd__dfrtp_1
X_6632_ _2229_ _2239_ _2238_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_22_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5736__B net377 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9351_ clknet_leaf_13_clk net691 _0261_ VGND VGND VPWR VPWR adder_inst.sign_b_r sky130_fd_sc_hd__dfrtp_2
XFILLER_118_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6563_ _2180_ _2186_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__xnor2_4
X_9282_ clknet_leaf_19_clk adder_inst.sum_raw\[19\] _0192_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_5514_ _1139_ _1143_ net550 _1137_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__a211oi_2
X_8302_ net309 net162 VGND VGND VPWR VPWR _3875_ sky130_fd_sc_hd__nor2_1
X_6494_ net430 net324 VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__nand2_1
XFILLER_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5445_ _1018_ _1066_ _1065_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__o21ba_1
X_8233_ _3678_ _3805_ _3799_ VGND VGND VPWR VPWR _3806_ sky130_fd_sc_hd__and3_1
X_8164_ net263 net404 net158 VGND VGND VPWR VPWR _3738_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_93_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5376_ net217 net398 net403 net207 VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__a22oi_1
Xfanout103 net104 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_8
XFILLER_120_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7115_ _2740_ _2743_ _2744_ VGND VGND VPWR VPWR _2745_ sky130_fd_sc_hd__nand3_1
XANTENNA__6567__B net324 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8095_ _3305_ _3667_ _3668_ VGND VGND VPWR VPWR _3669_ sky130_fd_sc_hd__nand3_1
XFILLER_114_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout136 _3710_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_2
XFILLER_101_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout125 net128 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_4
Xfanout114 net115 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_2
XANTENNA_fanout391_A net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5102__B1 net268 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout158 net161 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
Xfanout169 _3463_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
X_7046_ _2642_ _2674_ VGND VGND VPWR VPWR _2676_ sky130_fd_sc_hd__xnor2_2
XFILLER_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5653__A1 net215 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout277_X net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8997_ net549 VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
XFILLER_43_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7948_ adder_inst.sum_raw_r\[6\] net495 _3542_ _3543_ _3473_ VGND VGND VPWR VPWR
+ _3544_ sky130_fd_sc_hd__a221o_1
XFILLER_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_fanout444_X net444 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_120_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7879_ net197 _3415_ _3407_ VGND VGND VPWR VPWR _3485_ sky130_fd_sc_hd__o21ai_1
XANTENNA__4831__A net359 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5169__B1 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5927__A net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_128_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold190 adder_inst.exp_a\[6\] VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA__8973__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_78_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7094__B1 net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6493__A net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5556__B net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__8359__S net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5230_ _0586_ _0588_ _0585_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__o21ba_1
XANTENNA__5572__A net253 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5161_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_75_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5092_ _0640_ _0657_ _0719_ _0720_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a211o_1
XFILLER_84_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7624__A2 _0456_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_110_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8920_ net510 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
XFILLER_68_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4916__A net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_83_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8851_ net826 mul_res\[3\] net503 VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__mux2_1
X_7802_ _4346_ _3407_ VGND VGND VPWR VPWR _3408_ sky130_fd_sc_hd__nand2_1
XFILLER_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5994_ net384 net389 net331 net338 VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__and4_1
X_8782_ net334 net470 net478 net328 _2540_ VGND VGND VPWR VPWR _4289_ sky130_fd_sc_hd__a221o_1
XFILLER_37_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7733_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] adder_inst.exp_a\[2\]
+ VGND VGND VPWR VPWR _3354_ sky130_fd_sc_hd__or4_1
X_4945_ _0572_ _0573_ _0567_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a21bo_1
XFILLER_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5747__A net630 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7664_ _3288_ _3289_ _3291_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[3\] sky130_fd_sc_hd__o21a_1
X_4876_ _0502_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__xnor2_1
XANTENNA_fanout237_A net238 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9403_ clknet_leaf_8_clk adder_inst.is_inf_b _0313_ VGND VGND VPWR VPWR adder_inst.is_inf_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_7595_ _3223_ _1035_ _1081_ VGND VGND VPWR VPWR _3225_ sky130_fd_sc_hd__or3b_1
XANTENNA__7560__A1 _4370_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6615_ _2241_ _2242_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__xor2_2
XANTENNA_fanout404_A net405 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9334_ clknet_leaf_3_clk net696 _0244_ VGND VGND VPWR VPWR adder_inst.man_b_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
X_6546_ _2174_ _2156_ _2175_ _2101_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__a211o_4
XFILLER_134_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9265_ clknet_leaf_24_clk adder_inst.sum_raw\[2\] _0175_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
X_6477_ _2097_ _2099_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__a21oi_2
X_5428_ _1051_ _1056_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__xnor2_1
X_9196_ clknet_leaf_18_clk net777 _0106_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
X_8216_ net136 _3764_ _3786_ net140 VGND VGND VPWR VPWR _3789_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_7_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6297__B net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5359_ net368 net256 _0732_ _0731_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a31o_1
XFILLER_102_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout394_X net394 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8147_ _3719_ _3720_ net134 VGND VGND VPWR VPWR _3721_ sky130_fd_sc_hd__mux2_1
XFILLER_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5632__D net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8078_ adder_inst.is_nan_r net199 net845 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__and3b_1
XFILLER_102_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7029_ net231 net446 net451 net225 VGND VGND VPWR VPWR _2659_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__5626__B2 net259 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5626__A1 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__7856__B net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5929__A2 net415 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4561__A net288 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__5807__D net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_133_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7854__A2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4730_ net201 net384 VGND VGND VPWR VPWR _4501_ sky130_fd_sc_hd__nand2_1
XFILLER_14_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4661_ _4429_ _4431_ VGND VGND VPWR VPWR _4432_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_32_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7380_ _2779_ _2781_ VGND VGND VPWR VPWR _3010_ sky130_fd_sc_hd__nand2_1
X_6400_ _1951_ _1953_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_12_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4592_ net203 net358 VGND VGND VPWR VPWR _4363_ sky130_fd_sc_hd__nand2_1
X_6331_ _1954_ _1959_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_12_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9050_ net531 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__inv_2
X_6262_ net400 net406 net332 net337 VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__and4_1
X_8001_ adder_inst.sum_raw_r\[16\] net190 net169 adder_inst.sum_raw_r\[15\] net186
+ VGND VGND VPWR VPWR _3590_ sky130_fd_sc_hd__o221a_1
X_5213_ net212 net432 net437 net205 VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__a22oi_1
XFILLER_69_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6193_ _1821_ _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__nor2_1
X_5144_ _0600_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__xnor2_1
XFILLER_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6805__B1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5075_ _0703_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__nor2_1
XANTENNA__4646__A net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout187_A _3355_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8903_ net515 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__inv_2
XFILLER_84_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8834_ _3244_ _3257_ VGND VGND VPWR VPWR _4325_ sky130_fd_sc_hd__or2_1
XANTENNA_fanout354_A net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_64_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8765_ net757 _4272_ _0104_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a21o_1
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5977_ _1605_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__nor2_1
XANTENNA__6584__A2 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout521_A net523 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7716_ net104 _3339_ _3338_ _3324_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[6\]
+ sky130_fd_sc_hd__o2bb2a_1
X_8696_ _4033_ _4248_ _4247_ VGND VGND VPWR VPWR _4249_ sky130_fd_sc_hd__a21o_1
XANTENNA_fanout142_X net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4928_ _0491_ _0509_ _0556_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__o211a_4
XFILLER_52_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4595__A1 net203 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7647_ net657 adder_inst.exp_a_r\[2\] _3273_ VGND VGND VPWR VPWR _3275_ sky130_fd_sc_hd__a21o_1
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_leaf_7_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4859_ _0482_ _0483_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand3_1
XANTENNA__5627__D net455 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7578_ _0977_ _3207_ VGND VGND VPWR VPWR _3208_ sky130_fd_sc_hd__and2_1
XANTENNA_fanout407_X net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_9317_ clknet_leaf_9_clk net742 _0227_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_119_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6529_ net273 net472 _2084_ _2085_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_4_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9248_ clknet_leaf_4_clk net42 _0158_ VGND VGND VPWR VPWR adder_inst.i_b\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_134_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__8727__S net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9179_ net541 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__inv_2
XFILLER_0_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6755__B net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_110_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6272__B2 net413 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6272__A1 net418 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7867__A net191 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_48_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7221__B1 net438 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__4889__A2 net398 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5535__B1 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_59_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5272__D net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_79_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5900_ _1514_ _1528_ _1529_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__nand3_1
XFILLER_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6880_ _2478_ _2485_ _2487_ _2508_ VGND VGND VPWR VPWR _2510_ sky130_fd_sc_hd__nand4_1
XFILLER_34_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4913__B net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5831_ net267 net421 net427 net260 VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__a22o_1
XFILLER_50_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8550_ _4020_ _4021_ net678 _4023_ VGND VGND VPWR VPWR _4121_ sky130_fd_sc_hd__or4bb_1
X_5762_ net279 net408 net286 net414 VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__nand4_1
X_4713_ _4480_ _4483_ VGND VGND VPWR VPWR _4484_ sky130_fd_sc_hd__and2_1
X_7501_ _4388_ _4389_ _4383_ VGND VGND VPWR VPWR _3131_ sky130_fd_sc_hd__o21a_1
X_8481_ _4053_ _4052_ VGND VGND VPWR VPWR _4054_ sky130_fd_sc_hd__nand2b_1
XANTENNA__6318__A2 net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5693_ net362 net365 net331 net339 VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__and4_1
X_4644_ net361 net368 net244 net250 VGND VGND VPWR VPWR _4415_ sky130_fd_sc_hd__nand4_1
XANTENNA__7943__C adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7432_ _3043_ _3061_ VGND VGND VPWR VPWR _3062_ sky130_fd_sc_hd__or2_1
XFILLER_30_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4575_ net195 VGND VGND VPWR VPWR _4347_ sky130_fd_sc_hd__inv_2
X_7363_ _2990_ _2991_ VGND VGND VPWR VPWR _2993_ sky130_fd_sc_hd__xnor2_2
XFILLER_116_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7294_ _2922_ _2923_ VGND VGND VPWR VPWR _2924_ sky130_fd_sc_hd__nand2b_1
X_9102_ net525 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__inv_2
X_6314_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__inv_2
X_9033_ net535 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__inv_2
XFILLER_103_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6245_ _1271_ _1794_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__xor2_1
XFILLER_131_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6176_ _1800_ _1803_ _1805_ _1711_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__o211ai_2
X_5127_ _0601_ _0605_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__nor2_1
XFILLER_84_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout471_A net472 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5058_ _0685_ _0686_ _0684_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout357_X net357 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8817_ _3204_ _3220_ VGND VGND VPWR VPWR _4316_ sky130_fd_sc_hd__nand2_1
XANTENNA__5919__B net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8748_ multiplier_inst.man_final_r\[17\] net179 net178 VGND VGND VPWR VPWR _0080_
+ sky130_fd_sc_hd__and3_1
XFILLER_139_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5000__A net244 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8679_ _4051_ _4224_ VGND VGND VPWR VPWR _4234_ sky130_fd_sc_hd__nand2_1
XFILLER_138_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_698 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__5296__A2 net406 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_input32_A i_a[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5048__A2 net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7993__A1 adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7597__A _1035_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6796__A2 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5829__B net434 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_45_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5564__B net285 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__6098__D net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_98_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6030_ net279 net439 net433 net285 VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__and4_1
XFILLER_121_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4627__C net262 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7981_ _3414_ _3571_ _3572_ VGND VGND VPWR VPWR _3573_ sky130_fd_sc_hd__o21a_1
XFILLER_66_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer15 _1909_ VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__buf_2
XFILLER_26_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer26 net631 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_85_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6932_ _2561_ VGND VGND VPWR VPWR _2562_ sky130_fd_sc_hd__inv_2
Xrebuffer48 net596 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer59 _1741_ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__buf_2
XFILLER_26_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6863_ net330 net335 net460 net466 VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__and4_1
XFILLER_34_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_791 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8602_ _3935_ _4163_ _3933_ VGND VGND VPWR VPWR _4166_ sky130_fd_sc_hd__a21o_1
X_5814_ _1434_ _1443_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__xor2_1
XFILLER_23_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6794_ _2379_ _2418_ _2423_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__nand3_1
X_8533_ _3967_ _4103_ _3989_ _4105_ VGND VGND VPWR VPWR _4106_ sky130_fd_sc_hd__a31o_1
XFILLER_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5745_ _1329_ _1331_ _1330_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__o21bai_1
XFILLER_41_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8464_ net376 _4034_ net160 VGND VGND VPWR VPWR _4037_ sky130_fd_sc_hd__mux2_1
XANTENNA__8131__A _4358_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer105 _3694_ VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA__8161__A1 net168 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xrebuffer116 _3799_ VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlymetal6s4s_1
XANTENNA_fanout317_A net318 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5676_ _1303_ _1304_ _1302_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a21o_1
XFILLER_135_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4627_ net350 net343 net262 VGND VGND VPWR VPWR _4398_ sky130_fd_sc_hd__and3_1
X_7415_ net345 net232 _4374_ VGND VGND VPWR VPWR _3045_ sky130_fd_sc_hd__and3_1
X_8395_ net145 _3774_ _3884_ net124 VGND VGND VPWR VPWR _3968_ sky130_fd_sc_hd__a211o_1
XANTENNA__8449__C1 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5905__D net300 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_104_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7346_ _2938_ _2945_ VGND VGND VPWR VPWR _2976_ sky130_fd_sc_hd__xor2_1
XFILLER_116_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7277_ _2904_ _2905_ _2901_ VGND VGND VPWR VPWR _2907_ sky130_fd_sc_hd__a21oi_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9016_ net511 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__inv_2
XANTENNA__6475__A1 net249 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6228_ _1764_ _1856_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__nor3_1
XFILLER_58_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6159_ net241 net248 net475 net481 VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__and4_1
XFILLER_58_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_fanout474_X net474 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_123_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7864__B net494 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_738 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__8187__S net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput84 net84 VGND VGND VPWR VPWR o_res[24] sky130_fd_sc_hd__buf_2
XFILLER_122_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput73 net73 VGND VGND VPWR VPWR o_res[14] sky130_fd_sc_hd__buf_2
XFILLER_110_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput95 net95 VGND VGND VPWR VPWR o_res[5] sky130_fd_sc_hd__buf_2
XFILLER_49_711 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5550__D net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_91_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7966__B2 net171 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4744__A net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_28_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_36_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5530_ net395 net315 net322 net555 VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__a22oi_1
X_5461_ _0701_ _0717_ _1089_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a211o_4
XFILLER_117_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7200_ _0910_ _2828_ _2829_ VGND VGND VPWR VPWR _2830_ sky130_fd_sc_hd__nand3_2
X_5392_ _1020_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__xnor2_1
XFILLER_99_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8180_ adder_inst.man_b_r\[8\] _3342_ net648 VGND VGND VPWR VPWR _3754_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7131_ net213 net454 net460 net206 VGND VGND VPWR VPWR _2761_ sky130_fd_sc_hd__a22oi_1
XFILLER_98_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout307 net309 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_4
Xfanout318 net323 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_4
X_7062_ _2686_ _2690_ _2691_ VGND VGND VPWR VPWR _2692_ sky130_fd_sc_hd__and3_1
Xfanout329 net330 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6013_ net414 net420 net296 net302 VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__and4_1
XFILLER_100_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__7957__A1 adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_19_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
X_7964_ adder_inst.sum_raw_r\[11\] net189 net169 adder_inst.sum_raw_r\[10\] net184
+ VGND VGND VPWR VPWR _3558_ sky130_fd_sc_hd__o221a_1
XANTENNA__7957__B2 adder_inst.sum_raw_r\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout267_A net270 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6915_ _2488_ _2516_ _2534_ _2544_ VGND VGND VPWR VPWR _2545_ sky130_fd_sc_hd__nor4_1
X_7895_ adder_inst.sum_raw_r\[0\] net487 _3394_ VGND VGND VPWR VPWR _3500_ sky130_fd_sc_hd__a21o_1
XANTENNA__5188__C net269 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_fanout434_A net435 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_50_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6846_ _2440_ _2449_ _2473_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__o21ai_1
XFILLER_50_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6777_ _2401_ _2406_ _2360_ _2372_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__o211ai_2
XFILLER_22_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout222_X net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8516_ _4044_ _4075_ _4088_ VGND VGND VPWR VPWR _4089_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_98_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5728_ net365 net326 VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__and2_1
X_9496_ clknet_leaf_18_clk net781 _0406_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
XFILLER_109_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8447_ net119 _3937_ _4017_ _4018_ net157 VGND VGND VPWR VPWR _4020_ sky130_fd_sc_hd__a221oi_2
X_5659_ _1286_ _1287_ _1285_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__a21bo_1
XFILLER_117_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8378_ net165 _3950_ _3949_ VGND VGND VPWR VPWR _3951_ sky130_fd_sc_hd__a21o_1
XFILLER_123_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA__4829__A net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7329_ _2914_ _2915_ _2928_ VGND VGND VPWR VPWR _2959_ sky130_fd_sc_hd__o21a_1
XANTENNA__6604__A1_N net273 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_125_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_125_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5423__A2 net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_107_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7875__A _3435_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_54_791 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6384__B1 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_24_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_136_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer6 net554 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA__5545__D net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_647 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__8600__A2 net173 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4961_ _0576_ _0577_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__and3_1
X_7680_ _3303_ _3304_ VGND VGND VPWR VPWR _3306_ sky130_fd_sc_hd__or2_1
X_4892_ _0514_ _0520_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nand3_1
XANTENNA__7167__A2 _1622_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6700_ net317 net447 net452 net310 VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__a22oi_1
XFILLER_32_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6631_ _2244_ _2245_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__xnor2_2
XFILLER_32_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9350_ clknet_leaf_17_clk _0068_ _0260_ VGND VGND VPWR VPWR add_ovf sky130_fd_sc_hd__dfrtp_1
X_8301_ net121 _3861_ _3869_ _3873_ VGND VGND VPWR VPWR _3874_ sky130_fd_sc_hd__a31oi_2
X_6562_ _2117_ net601 _2190_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__nor3_1
X_9281_ clknet_leaf_22_clk adder_inst.sum_raw\[18\] _0191_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_5513_ _1140_ _1142_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__or2_1
XANTENNA__6127__B1 net445 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6493_ net418 net424 net329 net336 VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__and4_1
Xclkbuf_leaf_8_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_5444_ _1071_ _1072_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__xor2_1
X_8232_ _3803_ _3804_ net125 VGND VGND VPWR VPWR _3805_ sky130_fd_sc_hd__a21o_1
X_8163_ _3736_ VGND VGND VPWR VPWR _3737_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_93_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5375_ net207 net217 net399 net404 VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__and4_1
XFILLER_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout104 _3269_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_6
X_7114_ net238 net430 _2741_ _2742_ VGND VGND VPWR VPWR _2744_ sky130_fd_sc_hd__a22o_1
X_8094_ _3342_ net645 _3660_ VGND VGND VPWR VPWR _3668_ sky130_fd_sc_hd__a21o_1
Xfanout115 net116 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_2
XFILLER_99_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout137 _3709_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_6
Xfanout126 net128 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_86_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout148 _3698_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
XANTENNA__5102__A1 net360 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5102__B2 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xfanout159 net161 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__clkbuf_4
XANTENNA_fanout384_A net385 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7045_ _2674_ _2642_ VGND VGND VPWR VPWR _2675_ sky130_fd_sc_hd__nand2b_1
XFILLER_101_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5653__A2 net480 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_2_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8996_ net513 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__inv_2
XFILLER_28_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7947_ adder_inst.sum_raw_r\[5\] _4341_ net182 adder_inst.sum_raw_r\[3\] net192 VGND
+ VGND VPWR VPWR _3543_ sky130_fd_sc_hd__o221a_1
XFILLER_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7878_ _3386_ _3415_ net170 VGND VGND VPWR VPWR _3484_ sky130_fd_sc_hd__a21oi_1
XANTENNA_fanout437_X net437 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__5169__A1 net573 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__5169__B2 net373 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_51_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5927__B net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6829_ net317 net464 net471 net310 VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_102_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__4831__B net292 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9479_ clknet_leaf_28_clk net790 _0389_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
XFILLER_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold180 adder_inst.i_b\[11\] VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clone92_A net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold191 adder_inst.exp_a\[2\] VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7094__A1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7094__B2 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__9150__A net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6493__B net424 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6109__B1 net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5572__B net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5160_ _0464_ _0470_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_75_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5091_ _0640_ _0657_ _0719_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a211oi_2
XFILLER_110_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA__4916__B net422 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8850_ net789 mul_res\[2\] net503 VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__mux2_1
XFILLER_37_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7801_ net196 _3406_ VGND VGND VPWR VPWR _3407_ sky130_fd_sc_hd__nand2_1
X_8781_ _2481_ _2514_ _2546_ VGND VGND VPWR VPWR _4288_ sky130_fd_sc_hd__a21o_1
X_5993_ _1620_ _1621_ _1284_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__o21a_1
X_7732_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _3353_ sky130_fd_sc_hd__or4_1
X_4944_ _0567_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand3_1
XANTENNA__4932__A net258 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_52_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA__5747__B net396 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9402_ clknet_leaf_8_clk net743 _0312_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_7663_ net103 _3290_ VGND VGND VPWR VPWR _3291_ sky130_fd_sc_hd__nand2_1
X_4875_ _0503_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and2b_1
XFILLER_20_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7594_ _1153_ _3222_ _1082_ VGND VGND VPWR VPWR _3224_ sky130_fd_sc_hd__a21o_1
X_6614_ _2233_ _2235_ _2236_ _2232_ _2231_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__a32o_1
X_9333_ clknet_leaf_1_clk net729 _0243_ VGND VGND VPWR VPWR adder_inst.man_b_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
X_6545_ _2080_ _2081_ _2099_ _2100_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9264_ clknet_leaf_24_clk adder_inst.sum_raw\[1\] _0174_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[1\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_133_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8215_ net135 _3768_ _3787_ net138 VGND VGND VPWR VPWR _3788_ sky130_fd_sc_hd__a211o_1
X_6476_ _1951_ _2105_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__or2_1
X_9195_ clknet_leaf_14_clk net688 _0105_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
X_5427_ _1051_ _1056_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__nand2_1
XANTENNA__6297__C net450 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_7_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5358_ _4553_ _4559_ _4558_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21o_1
X_8146_ net327 net469 net154 VGND VGND VPWR VPWR _3720_ sky130_fd_sc_hd__mux2_1
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8077_ _3628_ _3652_ net198 VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__o21a_1
XFILLER_102_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout387_X net387 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5289_ _0899_ _0912_ _0918_ _0849_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a211o_1
X_7028_ net225 net232 net446 net451 VGND VGND VPWR VPWR _2658_ sky130_fd_sc_hd__and4_1
XANTENNA__5626__A2 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_74_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_104_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8979_ net508 VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__inv_2
XFILLER_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4842__A net368 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_rebuffer35_A net583 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__5673__A net365 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_input62_A i_b[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_115_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout490 net491 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__buf_2
XFILLER_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5848__A net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4660_ net235 net374 net380 net229 VGND VGND VPWR VPWR _4431_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_32_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4591_ net352 net346 net209 net214 VGND VGND VPWR VPWR _4362_ sky130_fd_sc_hd__and4_1
X_6330_ _1954_ _1959_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__nor2_1
XFILLER_6_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6261_ _1806_ _1888_ _1887_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_23_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8000_ adder_inst.sum_raw_r\[13\] net496 _3587_ _3588_ _3473_ VGND VGND VPWR VPWR
+ _3589_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_90_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5212_ net205 net212 net432 net437 VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__and4_1
X_6192_ net412 net314 net321 net407 VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__a22oi_1
XFILLER_97_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5143_ _0770_ _0771_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or2_1
XFILLER_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__6805__A1 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5074_ net234 net393 net399 net228 VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a22oi_1
XANTENNA__4646__B net239 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__6805__B2 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8902_ net515 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__inv_2
XFILLER_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8833_ _4324_ _3232_ _3244_ VGND VGND VPWR VPWR multiplier_inst.man_final\[15\] sky130_fd_sc_hd__a21oi_2
XANTENNA__5644__A1_N net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8764_ net834 _4272_ _0104_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__a21o_1
XFILLER_80_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_fanout347_A net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5976_ _1603_ _1604_ _1466_ _1468_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__o211a_1
XFILLER_12_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7715_ _3322_ _3338_ VGND VGND VPWR VPWR _3339_ sky130_fd_sc_hd__and2_1
X_8695_ _4043_ _4235_ _4038_ VGND VGND VPWR VPWR _4248_ sky130_fd_sc_hd__o21ai_1
X_4927_ _0535_ _0537_ _0555_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o21ai_1
XANTENNA__4595__A2 net358 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7646_ net657 adder_inst.exp_a_r\[2\] _3273_ VGND VGND VPWR VPWR _3274_ sky130_fd_sc_hd__and3_1
XANTENNA_fanout514_A net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4858_ _0484_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9316_ clknet_leaf_9_clk net745 _0226_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_2
X_4789_ _4553_ _4558_ _4559_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand3_1
X_7577_ _3029_ _3030_ _3031_ _3033_ VGND VGND VPWR VPWR _3207_ sky130_fd_sc_hd__a211o_1
XANTENNA__6589__A net289 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout302_X net302 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6528_ _2155_ _2157_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_41_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9247_ clknet_leaf_4_clk net41 _0157_ VGND VGND VPWR VPWR adder_inst.i_b\[17\] sky130_fd_sc_hd__dfrtp_1
X_6459_ net265 net472 net479 net261 VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__a22o_1
XFILLER_134_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9178_ net541 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__inv_2
XFILLER_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8129_ _3700_ _3702_ VGND VGND VPWR VPWR _3703_ sky130_fd_sc_hd__nor2_1
XFILLER_85_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA__4837__A net342 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_50_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7221__A1 net233 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7221__B2 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire132 _3796_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5535__A1 net407 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7288__A1 net220 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7123__A net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7777__B adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4913__C net410 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5830_ net260 net267 net421 net427 VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_17_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5761_ net272 net421 VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__and2_1
XFILLER_34_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8480_ net388 net165 _3776_ _3979_ VGND VGND VPWR VPWR _4053_ sky130_fd_sc_hd__a22o_1
X_7500_ _3126_ _3129_ VGND VGND VPWR VPWR _3130_ sky130_fd_sc_hd__and2_1
X_4712_ _4481_ _4482_ VGND VGND VPWR VPWR _4483_ sky130_fd_sc_hd__nor2_1
X_7431_ _3059_ _3060_ VGND VGND VPWR VPWR _3061_ sky130_fd_sc_hd__or2_1
X_5692_ net371 net326 VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__nand2_1
X_4643_ _4396_ _4412_ _4413_ VGND VGND VPWR VPWR _4414_ sky130_fd_sc_hd__nand3_1
XANTENNA__6723__B1 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4574_ adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _4346_ sky130_fd_sc_hd__inv_2
X_7362_ _2758_ _2765_ _2990_ VGND VGND VPWR VPWR _2992_ sky130_fd_sc_hd__o21ai_1
XANTENNA__6202__A net290 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_115_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7293_ net212 net449 net454 net206 VGND VGND VPWR VPWR _2923_ sky130_fd_sc_hd__a22o_1
X_9101_ net524 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__inv_2
X_6313_ _1924_ _1941_ _1942_ _1862_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__a211o_1
X_9032_ net535 VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__inv_2
XFILLER_131_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6244_ _1858_ _1860_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__nor2_1
XFILLER_131_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout297_A net298 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6175_ _1706_ _1707_ _1710_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__a21o_1
X_5126_ _0492_ _0493_ _0508_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a21oi_1
XFILLER_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5057_ _0684_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__or2_1
XFILLER_84_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_fanout464_A net465 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__8400__A0 net411 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_fanout252_X net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8816_ _3204_ _3220_ VGND VGND VPWR VPWR _4315_ sky130_fd_sc_hd__nor2_1
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8747_ net853 net181 net178 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__and3_1
X_5959_ net226 net232 net451 net457 VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__and4_1
XFILLER_53_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5000__B net250 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_fanout517_X net517 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8678_ _4108_ net661 _4232_ net175 VGND VGND VPWR VPWR _4233_ sky130_fd_sc_hd__o211a_1
XFILLER_21_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7629_ net592 _3255_ _3258_ VGND VGND VPWR VPWR _3259_ sky130_fd_sc_hd__o21ai_2
XANTENNA__6714__B1 net470 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_126_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__4567__A adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_76_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_input25_A i_a[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__7597__B _1081_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__5564__C net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6957__A net347 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA__4908__C net403 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_clkbuf_leaf_6_clk_A clknet_2_1__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7788__A net484 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer16 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__clkbuf_2
X_7980_ adder_inst.sum_raw_r\[13\] net189 net169 adder_inst.sum_raw_r\[12\] net186
+ VGND VGND VPWR VPWR _3572_ sky130_fd_sc_hd__o221a_1
XFILLER_94_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer27 net603 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_85_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer49 adder_inst.man_a_r\[5\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_47_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6931_ _2411_ _2555_ _2370_ VGND VGND VPWR VPWR _2561_ sky130_fd_sc_hd__o21ai_1
Xrebuffer38 _1694_ VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_19_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6862_ _2453_ _2455_ VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__xnor2_1
XANTENNA__5101__A net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_8601_ _3936_ _4165_ VGND VGND VPWR VPWR adder_inst.sum_raw\[8\] sky130_fd_sc_hd__xnor2_1
XFILLER_62_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5813_ _1441_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__and2b_1
XFILLER_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8532_ _3955_ _3964_ _3967_ _4094_ _3954_ VGND VGND VPWR VPWR _4105_ sky130_fd_sc_hd__a221o_1
XFILLER_50_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6793_ _2420_ _2421_ _2419_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__o21bai_1
X_5744_ _1342_ _1344_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nand2_1
X_8463_ net160 _4034_ _4035_ VGND VGND VPWR VPWR _4036_ sky130_fd_sc_hd__o21ai_1
XANTENNA__8131__B net161 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_5675_ _1302_ _1303_ _1304_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nand3_1
XFILLER_136_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8394_ _3956_ _3966_ VGND VGND VPWR VPWR _3967_ sky130_fd_sc_hd__nor2_1
X_4626_ _4394_ _4396_ VGND VGND VPWR VPWR _4397_ sky130_fd_sc_hd__nand2_1
XANTENNA_fanout212_A net213 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__7028__A net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7414_ net345 net232 _4374_ VGND VGND VPWR VPWR _3044_ sky130_fd_sc_hd__a21oi_1
X_7345_ _2967_ _2974_ _2966_ VGND VGND VPWR VPWR _2975_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_96_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7276_ _2901_ _2904_ _2905_ VGND VGND VPWR VPWR _2906_ sky130_fd_sc_hd__and3_1
XFILLER_106_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9015_ net510 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__inv_2
XANTENNA__6475__A2 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6227_ _1760_ _1761_ _1763_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__a21oi_1
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6158_ _1785_ _1787_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__and2_1
X_5109_ _0737_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__nor2_1
XFILLER_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_fanout467_X net467 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6089_ net389 net395 net332 net338 VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_123_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__6107__A net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__6752__D net458 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA__5946__A net237 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__7112__B1 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput85 net85 VGND VGND VPWR VPWR o_res[25] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR o_res[15] sky130_fd_sc_hd__buf_2
XFILLER_1_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput96 net96 VGND VGND VPWR VPWR o_res[6] sky130_fd_sc_hd__buf_2
XFILLER_49_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA__7966__A2 adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA__4744__B adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_63_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5460_ _1059_ _1088_ _0737_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21oi_1
XFILLER_117_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5391_ _0429_ _0434_ _0428_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__a21oi_1
XFILLER_99_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7130_ net206 net213 net454 net460 VGND VGND VPWR VPWR _2760_ sky130_fd_sc_hd__and4_1
XFILLER_99_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7061_ _2688_ _2689_ _2687_ VGND VGND VPWR VPWR _2691_ sky130_fd_sc_hd__o21ai_1
Xfanout319 net323 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout308 net309 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6012_ _1299_ _1639_ _1638_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21o_1
.ends
