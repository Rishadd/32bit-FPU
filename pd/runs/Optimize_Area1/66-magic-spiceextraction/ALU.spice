* NGSPICE file created from ALU.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_16 abstract view
.subckt sky130_fd_sc_hd__clkinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_1 abstract view
.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_2 abstract view
.subckt sky130_fd_sc_hd__o311ai_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

.subckt ALU VGND VPWR clk i_a[0] i_a[10] i_a[11] i_a[12] i_a[13] i_a[14] i_a[15] i_a[16]
+ i_a[17] i_a[18] i_a[19] i_a[1] i_a[20] i_a[21] i_a[22] i_a[23] i_a[24] i_a[25] i_a[26]
+ i_a[27] i_a[28] i_a[29] i_a[2] i_a[30] i_a[31] i_a[3] i_a[4] i_a[5] i_a[6] i_a[7]
+ i_a[8] i_a[9] i_b[0] i_b[10] i_b[11] i_b[12] i_b[13] i_b[14] i_b[15] i_b[16] i_b[17]
+ i_b[18] i_b[19] i_b[1] i_b[20] i_b[21] i_b[22] i_b[23] i_b[24] i_b[25] i_b[26] i_b[27]
+ i_b[28] i_b[29] i_b[2] i_b[30] i_b[31] i_b[3] i_b[4] i_b[5] i_b[6] i_b[7] i_b[8]
+ i_b[9] i_vld o_res[0] o_res[10] o_res[11] o_res[12] o_res[13] o_res[14] o_res[15]
+ o_res[16] o_res[17] o_res[18] o_res[19] o_res[1] o_res[20] o_res[21] o_res[22] o_res[23]
+ o_res[24] o_res[25] o_res[26] o_res[27] o_res[28] o_res[29] o_res[2] o_res[30] o_res[31]
+ o_res[3] o_res[4] o_res[5] o_res[6] o_res[7] o_res[8] o_res[9] o_res_vld opcode
+ overflow rst
XFILLER_67_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09671_ _01966_ _01795_ _01969_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__nand3_1
XFILLER_67_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08622_ _00918_ _00920_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08553_ _00846_ _00849_ _00717_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__nand3_1
XFILLER_23_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08484_ _00758_ _00761_ _00756_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_689 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09105_ _01397_ _01394_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__nand2_1
X_09036_ _01327_ _01315_ _01317_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__nand3_1
XFILLER_104_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09938_ _02220_ _02234_ _02236_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__nand3_1
XFILLER_89_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09869_ _02167_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__inv_2
X_12880_ _05151_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__nand2_1
X_11900_ _04197_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__inv_2
X_11831_ _04129_ _03899_ _03901_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__nand3_1
X_14550_ _06788_ _06789_ VGND VGND VPWR VPWR _06790_ sky130_fd_sc_hd__nand2_2
XFILLER_60_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13501_ _05795_ _05799_ VGND VGND VPWR VPWR _05800_ sky130_fd_sc_hd__nand2_1
X_11762_ net184 net147 VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__nand2_1
XFILLER_14_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14481_ net217 _06558_ _06720_ VGND VGND VPWR VPWR _06721_ sky130_fd_sc_hd__o21ai_1
X_11693_ _03990_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__nand2_1
X_10713_ net195 net147 VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__nand2_1
XFILLER_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10644_ _02942_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__inv_2
X_13432_ _05646_ _05647_ _05730_ VGND VGND VPWR VPWR _05731_ sky130_fd_sc_hd__nand3_1
XFILLER_13_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10575_ _02870_ _02873_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__nand2_1
X_16151_ clknet_leaf_16_clk _00003_ _00399_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
X_13363_ _05646_ _05647_ VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__nand2_1
X_15102_ _07344_ _07351_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07352_ sky130_fd_sc_hd__o21ai_1
X_12314_ _04594_ _04612_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__nand2_1
X_16082_ clknet_leaf_20_clk multiplier_inst.man_final\[8\] _00330_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_54_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13294_ _05489_ _05449_ VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__nand2_1
X_15033_ _07244_ _07248_ VGND VGND VPWR VPWR _07279_ sky130_fd_sc_hd__nand2_1
X_12245_ _04542_ _03879_ _04543_ VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__a21oi_1
X_12176_ _04437_ _04474_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__nand2_1
XFILLER_68_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11127_ _03423_ _03421_ _03077_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__nand3_2
XFILLER_49_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15935_ clknet_leaf_17_clk adder_inst.sum_raw\[10\] _00183_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[10\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_76_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11058_ _03355_ _03356_ VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__nand2_1
X_10009_ _02100_ _02090_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__nand2_1
X_15866_ clknet_leaf_3_clk net29 _00114_ VGND VGND VPWR VPWR adder_inst.i_a\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_76_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14817_ _07053_ _07042_ VGND VGND VPWR VPWR _07054_ sky130_fd_sc_hd__nand2_1
XFILLER_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15797_ net284 VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__inv_2
XFILLER_51_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14748_ _06987_ _06979_ VGND VGND VPWR VPWR _06988_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_67_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14679_ _06915_ _06918_ _06714_ VGND VGND VPWR VPWR _06919_ sky130_fd_sc_hd__nand3_1
XFILLER_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout105 adder_inst.i_vld_r2 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_2
Xfanout127 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_2
XFILLER_59_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout116 adder_inst.man_b_r\[20\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_4
Xfanout138 net139 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_4
XFILLER_113_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07984_ net200 net155 VGND VGND VPWR VPWR _07755_ sky130_fd_sc_hd__nand2_1
Xfanout149 net150 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_4
X_09723_ _02010_ _02021_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__nand2_1
XFILLER_67_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09654_ _01886_ _01739_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__nand2_1
XFILLER_67_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08605_ _00843_ _00899_ _00903_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_38_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09585_ _01578_ _01563_ _01708_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__nand3_1
XFILLER_55_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08536_ _07816_ _07819_ _00456_ VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__nand3_1
X_08467_ _00745_ _00753_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__nand2_1
X_08398_ _00637_ _00631_ VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__nand2_1
XFILLER_50_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10360_ _02646_ _02647_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_94_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10291_ _02588_ _02589_ VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__nand2_1
X_09019_ _01315_ _01317_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__nand2_1
XFILLER_2_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12030_ _04328_ _04269_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__nand2_1
XFILLER_78_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13981_ _06192_ _06193_ _06248_ VGND VGND VPWR VPWR _06249_ sky130_fd_sc_hd__and3_1
X_15720_ net298 VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__inv_2
XFILLER_58_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12932_ _05229_ _05225_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__nand2_1
XFILLER_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15651_ net265 VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__inv_2
XFILLER_61_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14602_ _06840_ _06841_ _06512_ VGND VGND VPWR VPWR _06842_ sky130_fd_sc_hd__o21ai_1
X_12863_ _05160_ _05161_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__nor2_1
X_15582_ net273 VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__inv_2
XFILLER_61_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11814_ net128 net202 VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__nand2_1
X_12794_ _04996_ _04992_ _04994_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_103_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14533_ _06761_ _06551_ _06762_ VGND VGND VPWR VPWR _06773_ sky130_fd_sc_hd__nand3_1
X_11745_ _03855_ _03851_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_16_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14464_ _06453_ _06492_ _06703_ VGND VGND VPWR VPWR _06704_ sky130_fd_sc_hd__o21a_1
XFILLER_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13415_ _05713_ _02989_ VGND VGND VPWR VPWR _05714_ sky130_fd_sc_hd__or2_1
X_11676_ _03809_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__inv_2
X_10627_ _02925_ _02922_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__nand2_1
X_14395_ _06634_ _04881_ _06551_ VGND VGND VPWR VPWR _06635_ sky130_fd_sc_hd__mux2_1
XFILLER_10_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16134_ clknet_leaf_13_clk _00091_ _00382_ VGND VGND VPWR VPWR mul_res\[27\] sky130_fd_sc_hd__dfrtp_1
X_10558_ _02826_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__inv_2
X_13346_ _05644_ VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__clkinvlp_2
X_16065_ clknet_leaf_11_clk adder_inst.is_inf_b _00313_ VGND VGND VPWR VPWR adder_inst.is_inf_b_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13277_ _05575_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__inv_2
XFILLER_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10489_ _02633_ _02787_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__nand2_1
X_15016_ _07220_ _07260_ VGND VGND VPWR VPWR _07261_ sky130_fd_sc_hd__nand2_1
X_12228_ _04521_ _04524_ VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_114_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12159_ _01450_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__inv_2
XFILLER_96_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15918_ clknet_leaf_7_clk net51 _00166_ VGND VGND VPWR VPWR adder_inst.exp_b\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_77_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15849_ net302 VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__inv_2
XFILLER_64_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09370_ _01668_ _01176_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__or2_1
XFILLER_52_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08321_ net117 net235 VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__nand2_1
XFILLER_20_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08252_ _00531_ _00533_ _00541_ VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_43_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08183_ net201 net161 VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__nand2_1
XFILLER_106_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07967_ _07726_ _07735_ _07737_ VGND VGND VPWR VPWR _07738_ sky130_fd_sc_hd__o21ai_1
X_09706_ _01957_ _01998_ _01963_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__a21boi_1
XFILLER_68_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07898_ _07076_ _07128_ VGND VGND VPWR VPWR _07138_ sky130_fd_sc_hd__or2_1
XFILLER_74_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09637_ net156 net228 VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__nand2_1
XFILLER_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09568_ _01704_ _01866_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__nand2_1
XFILLER_90_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08519_ _00543_ _00551_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__nand2_1
X_09499_ _01777_ _01797_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__nand2_1
X_11530_ _03825_ _03828_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_13_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11461_ _03701_ _03756_ _03759_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__nand3_1
XFILLER_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14180_ _06417_ _05912_ _05911_ VGND VGND VPWR VPWR _06422_ sky130_fd_sc_hd__a21oi_1
X_10412_ _02624_ _02615_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__nand2_1
X_13200_ _05448_ _05447_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__nand2_1
X_11392_ _03689_ _03690_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__nand2_1
X_10343_ net159 net242 VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__nand2_1
XFILLER_99_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13131_ _04881_ _04582_ _05398_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__o21ai_1
XFILLER_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10274_ _02571_ _02572_ VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__nor2_1
X_13062_ _05331_ _05360_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__nand2_1
XFILLER_105_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12013_ _04311_ VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__inv_2
XFILLER_93_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13964_ _06232_ adder_inst.sum_raw_r\[0\] VGND VGND VPWR VPWR _06233_ sky130_fd_sc_hd__nand2_1
XFILLER_93_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15703_ net296 VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__inv_2
X_13895_ _06122_ _06121_ VGND VGND VPWR VPWR _06170_ sky130_fd_sc_hd__nor2_1
XFILLER_61_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12915_ _05212_ _05027_ _05213_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__nand3_1
X_15634_ net305 VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__inv_2
XFILLER_73_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12846_ _05141_ _05056_ _04095_ VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__nand3_1
X_15565_ net263 VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__inv_2
X_14516_ _06750_ _06753_ VGND VGND VPWR VPWR _06756_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12777_ _04964_ _05074_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__nand2_1
X_15496_ _07705_ VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__clkbuf_1
X_11728_ _04024_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14447_ _06683_ _06474_ _06686_ VGND VGND VPWR VPWR _06687_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_40_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11659_ _03951_ _03957_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_116_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14378_ _06617_ _06474_ VGND VGND VPWR VPWR _06618_ sky130_fd_sc_hd__nand2_1
X_16117_ clknet_leaf_19_clk _00073_ _00365_ VGND VGND VPWR VPWR mul_res\[10\] sky130_fd_sc_hd__dfrtp_1
X_13329_ _05626_ _05625_ VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__nand2_1
X_16048_ clknet_leaf_9_clk adder_inst.exp_larger\[0\] _00296_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_111_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08870_ _01168_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__inv_2
XFILLER_57_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09422_ _01559_ _01223_ _01556_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__o21ai_1
XFILLER_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09353_ _01192_ _01193_ VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__nand2_1
X_08304_ _00599_ _00602_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__nand2_1
X_09284_ _01582_ _01132_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__nand2_1
XFILLER_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08235_ _00531_ _00533_ VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__nand2_1
XFILLER_118_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08166_ _07790_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__inv_2
XFILLER_119_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08097_ net146 net218 VGND VGND VPWR VPWR _07868_ sky130_fd_sc_hd__nand2_1
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08999_ _01297_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__inv_2
XFILLER_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10961_ _03258_ _03259_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__or2_1
X_13680_ adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR _05972_ sky130_fd_sc_hd__inv_2
XFILLER_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12700_ _04989_ _04990_ _04998_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__nand3_1
XFILLER_70_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10892_ _03189_ _03186_ _03187_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__nand3b_1
XFILLER_16_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12631_ _04929_ _04726_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_100_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15350_ _07560_ _07576_ VGND VGND VPWR VPWR _07578_ sky130_fd_sc_hd__nor2_1
X_12562_ _04781_ _04846_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__or2_1
XFILLER_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15281_ _07507_ multiplier_inst.man_final_r\[17\] _07508_ VGND VGND VPWR VPWR _07518_
+ sky130_fd_sc_hd__and3_1
X_14301_ _06538_ _06539_ _06541_ VGND VGND VPWR VPWR _06542_ sky130_fd_sc_hd__o21ai_1
X_12493_ _04778_ _04791_ VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__nand2b_1
XFILLER_7_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11513_ _03182_ _03811_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__nand2_1
XFILLER_11_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14232_ _06472_ VGND VGND VPWR VPWR _06473_ sky130_fd_sc_hd__buf_2
XFILLER_11_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11444_ _03741_ _03742_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__nand2_1
XFILLER_50_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14163_ _06403_ _06404_ VGND VGND VPWR VPWR _06405_ sky130_fd_sc_hd__nor2_1
XFILLER_109_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11375_ _03673_ VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__inv_2
XFILLER_98_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10326_ _02615_ _02624_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__nor2_1
X_14094_ _06348_ _06349_ _06350_ VGND VGND VPWR VPWR _06351_ sky130_fd_sc_hd__a21oi_1
X_13114_ _05411_ _05412_ VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__nand2_1
X_10257_ _02543_ _02554_ _02555_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_111_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13045_ _05325_ _05320_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__nand2_1
X_10188_ _02474_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__inv_2
XFILLER_78_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14996_ _07238_ _07226_ VGND VGND VPWR VPWR _07240_ sky130_fd_sc_hd__nand2_1
X_13947_ adder_inst.sum_raw_r\[2\] _06083_ _06215_ _06155_ _06217_ VGND VGND VPWR
+ VPWR _06218_ sky130_fd_sc_hd__a221o_1
XFILLER_93_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_695 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13878_ _06152_ adder_inst.sum_raw_r\[19\] net253 VGND VGND VPWR VPWR _06153_ sky130_fd_sc_hd__a21oi_1
X_15617_ net289 VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__inv_2
XFILLER_22_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12829_ _05126_ _05127_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__nand2_1
X_15548_ net272 VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__inv_2
X_15479_ add_res\[0\] mul_res\[0\] net258 VGND VGND VPWR VPWR _07695_ sky130_fd_sc_hd__mux2_1
X_08020_ _07790_ _07681_ VGND VGND VPWR VPWR _07791_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09971_ net223 net174 VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__nand2_1
XFILLER_115_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08922_ _01220_ _00944_ VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__nand2_1
XFILLER_39_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08853_ net142 net232 VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__nand2_1
XFILLER_69_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08784_ _01040_ _01036_ _00894_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_88_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09405_ _01702_ _01703_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__nand2_1
XFILLER_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09336_ _01634_ _01631_ VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__nand2_1
XFILLER_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09267_ net215 net163 VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08218_ _00479_ _00491_ _00490_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__nand3_1
XFILLER_119_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09198_ _01493_ _01496_ VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__nand2_1
XFILLER_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08149_ _07886_ _00443_ _00444_ VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__nand3b_1
XFILLER_106_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11160_ _01460_ _03310_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__nand2_1
XFILLER_96_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10111_ _02408_ _02409_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__nand2_1
X_11091_ _03358_ _03387_ _03361_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__nand3_1
XFILLER_96_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10042_ _02340_ _02336_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__nand2_1
Xhold41 adder_inst.exp_a\[6\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold30 adder_inst.i_a\[0\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_88_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold74 adder_inst.is_zero_b_r VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 adder_inst.exp_a\[5\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
X_14850_ _07072_ _06947_ VGND VGND VPWR VPWR _07087_ sky130_fd_sc_hd__nand2_1
Xhold63 adder_inst.i_b\[21\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 _07722_ VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
X_13801_ net249 _06075_ VGND VGND VPWR VPWR _06076_ sky130_fd_sc_hd__nor2_4
X_14781_ _07020_ VGND VGND VPWR VPWR _07021_ sky130_fd_sc_hd__buf_6
XFILLER_75_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold96 mul_res\[8\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13732_ net382 VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__inv_2
XFILLER_44_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11993_ _04290_ _04291_ VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10944_ _03215_ _03239_ _03242_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__nand3_1
XFILLER_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13663_ _05920_ _05905_ _05955_ VGND VGND VPWR VPWR _05956_ sky130_fd_sc_hd__a21o_1
XFILLER_71_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10875_ _03152_ _03172_ _03173_ VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__nand3_1
X_13594_ _05885_ _05890_ VGND VGND VPWR VPWR _05891_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15402_ _05778_ VGND VGND VPWR VPWR _07628_ sky130_fd_sc_hd__inv_2
X_12614_ _04911_ _04912_ VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__nand2_1
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15333_ _02972_ _07552_ _02785_ VGND VGND VPWR VPWR _07559_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12545_ _04801_ _04843_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__nor2_1
XFILLER_61_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15264_ _07506_ VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__clkbuf_1
X_12476_ _04645_ _04614_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__nand2_1
X_14215_ _06415_ _06440_ VGND VGND VPWR VPWR _06456_ sky130_fd_sc_hd__or2_1
X_15195_ _07447_ _07449_ VGND VGND VPWR VPWR _07450_ sky130_fd_sc_hd__nand2_1
XANTENNA_5 net114 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11427_ _03723_ _03720_ VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__nand2_1
X_14146_ adder_inst.is_zero_r _06174_ VGND VGND VPWR VPWR _06393_ sky130_fd_sc_hd__or2_1
X_11358_ _03656_ _03608_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__nand2_1
X_10309_ _02340_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__nand2_1
X_14077_ _06183_ _06190_ _06335_ VGND VGND VPWR VPWR _06336_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_72_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11289_ _03587_ _03420_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__nand2_1
XFILLER_79_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13028_ _05294_ _05326_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__nor2_1
XFILLER_94_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14979_ _07220_ _07207_ VGND VGND VPWR VPWR _07222_ sky130_fd_sc_hd__nand2_1
XFILLER_35_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09121_ _00583_ _00593_ _01419_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09052_ _01340_ _01350_ VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__nor2_1
X_08003_ _07760_ _07763_ VGND VGND VPWR VPWR _07774_ sky130_fd_sc_hd__nand2_1
XFILLER_2_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09954_ _02209_ _02210_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__nand2_1
XFILLER_106_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09885_ _02181_ _02183_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__nand2_1
X_08905_ _00768_ _00754_ _00936_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__nand3_1
XFILLER_85_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08836_ _01134_ _00976_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__nand2_1
XFILLER_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08767_ net130 net244 VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_56_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08698_ _00808_ _00535_ _00805_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_0_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10660_ _02958_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__inv_2
XFILLER_13_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09319_ _01614_ _01617_ VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__nand2_1
X_10591_ _02844_ _02769_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__nand2_1
XFILLER_21_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12330_ net198 VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__inv_2
XFILLER_31_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12261_ net184 VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__inv_2
X_14000_ net249 adder_inst.sum_raw_r\[10\] adder_inst.sum_raw_r\[9\] _06076_ _06265_
+ VGND VGND VPWR VPWR _06266_ sky130_fd_sc_hd__a221o_1
X_11212_ _03509_ _03510_ _03415_ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__nand3_1
XFILLER_31_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12192_ _04489_ _04490_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__nand2_1
XFILLER_110_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput75 net75 VGND VGND VPWR VPWR o_res[16] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11143_ _03273_ _03274_ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__nand2_1
X_15951_ clknet_leaf_5_clk net323 _00199_ VGND VGND VPWR VPWR adder_inst.man_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_2
Xoutput86 net86 VGND VGND VPWR VPWR o_res[26] sky130_fd_sc_hd__buf_2
Xoutput97 net97 VGND VGND VPWR VPWR o_res[7] sky130_fd_sc_hd__buf_2
X_11074_ _03372_ _03368_ _03369_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__nand3_1
X_10025_ _02260_ _02259_ _02323_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__a21oi_1
X_14902_ _06000_ VGND VGND VPWR VPWR _07141_ sky130_fd_sc_hd__clkbuf_4
X_15882_ clknet_leaf_24_clk net15 _00130_ VGND VGND VPWR VPWR adder_inst.i_a\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14833_ _07061_ _07069_ VGND VGND VPWR VPWR adder_inst.sum_raw\[4\] sky130_fd_sc_hd__nand2_1
XFILLER_56_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14764_ _06818_ _07003_ VGND VGND VPWR VPWR _07004_ sky130_fd_sc_hd__nor2_1
X_11976_ _04273_ _04274_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__nand2_1
XFILLER_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13715_ adder_inst.i_b\[0\] adder_inst.i_b\[3\] adder_inst.i_b\[5\] adder_inst.i_b\[6\]
+ VGND VGND VPWR VPWR _06003_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_106_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14695_ _06806_ _06488_ _06807_ VGND VGND VPWR VPWR _06935_ sky130_fd_sc_hd__nand3_1
X_10927_ _03217_ _03223_ _03225_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__nand3_1
XFILLER_72_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13646_ _05670_ _05939_ _05836_ VGND VGND VPWR VPWR _05940_ sky130_fd_sc_hd__nor3_4
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10858_ _03154_ _03156_ VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__nand2_1
X_13577_ _05872_ _05873_ VGND VGND VPWR VPWR _05874_ sky130_fd_sc_hd__nand2_1
X_10789_ _03086_ _03087_ _03083_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__nand3_1
X_15316_ _07539_ _01871_ VGND VGND VPWR VPWR _07540_ sky130_fd_sc_hd__nand2_1
X_12528_ _04825_ _04826_ VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__nand2_1
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15247_ _07492_ multiplier_inst.man_final_r\[1\] _07494_ VGND VGND VPWR VPWR _07496_
+ sky130_fd_sc_hd__and3_1
X_12459_ _04756_ _04757_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__nand2_1
X_15178_ _06650_ _07431_ VGND VGND VPWR VPWR _07432_ sky130_fd_sc_hd__xor2_1
X_14129_ _06108_ _06052_ VGND VGND VPWR VPWR _06382_ sky130_fd_sc_hd__nand2_1
XFILLER_98_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09670_ _01967_ _01968_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__nand2_1
X_08621_ _00906_ _00907_ _00919_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__nand3_1
XFILLER_54_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08552_ _00847_ _00850_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08483_ _00781_ _00505_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__nand2_1
XFILLER_50_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09104_ _01395_ _01396_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__nand2_1
X_09035_ _01318_ _01329_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__nand2_1
XFILLER_116_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09937_ _02235_ _02221_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__nand2_1
XFILLER_77_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09868_ _02146_ _02166_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__nand2_1
X_09799_ _02097_ _02085_ _02083_ VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__nand3_1
XFILLER_100_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08819_ _01075_ _01077_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__nand2_1
X_11830_ _04127_ _04128_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__nand2_1
X_11761_ _03968_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__inv_2
XFILLER_26_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13500_ _05646_ _05798_ _05647_ VGND VGND VPWR VPWR _05799_ sky130_fd_sc_hd__nand3_1
X_10712_ net199 net144 VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__nand2_1
X_14480_ _06716_ _06551_ VGND VGND VPWR VPWR _06720_ sky130_fd_sc_hd__nand2_1
X_11692_ _03989_ _03978_ _03979_ VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__nand3b_1
X_10643_ _02925_ _02941_ VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__nand2_1
X_13431_ _04517_ _05729_ VGND VGND VPWR VPWR _05730_ sky130_fd_sc_hd__xor2_2
XFILLER_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10574_ _02871_ net167 net245 _02872_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__a31oi_1
X_16150_ clknet_leaf_15_clk _00002_ _00398_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
X_13362_ _05660_ _05656_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__nand2_1
XFILLER_42_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_16081_ clknet_leaf_20_clk multiplier_inst.man_final\[7\] _00329_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
X_15101_ _07348_ _07350_ _07173_ VGND VGND VPWR VPWR _07351_ sky130_fd_sc_hd__a21oi_1
X_12313_ _04611_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__inv_2
X_15032_ _07277_ _07173_ VGND VGND VPWR VPWR _07278_ sky130_fd_sc_hd__nand2_1
X_13293_ _05585_ _05591_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__nand2_1
XFILLER_107_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12244_ _04047_ _04049_ _04051_ VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12175_ _04471_ _04473_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__nand2_1
XFILLER_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11126_ _03422_ _03424_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__nand2_1
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15934_ clknet_leaf_9_clk adder_inst.sum_raw\[9\] _00182_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[9\]
+ sky130_fd_sc_hd__dfrtp_4
X_11057_ _03353_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_108_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10008_ _02306_ _02305_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__nand2_1
X_15865_ clknet_leaf_3_clk net28 _00113_ VGND VGND VPWR VPWR adder_inst.i_a\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_76_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14816_ _06881_ _07052_ VGND VGND VPWR VPWR _07053_ sky130_fd_sc_hd__xnor2_1
XFILLER_64_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15796_ net282 VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__inv_2
X_14747_ _06985_ _06986_ VGND VGND VPWR VPWR _06987_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_67_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11959_ _04257_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__inv_2
X_14678_ _06916_ _06700_ _06917_ VGND VGND VPWR VPWR _06918_ sky130_fd_sc_hd__nand3_1
X_13629_ _05923_ _05917_ VGND VGND VPWR VPWR _05924_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_80_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout117 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_4
Xfanout106 net108 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_4
Xfanout128 net129 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout139 adder_inst.man_b_r\[12\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_2
X_09722_ _01995_ _01996_ _01993_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__nand3_1
X_07983_ net201 net152 VGND VGND VPWR VPWR _07754_ sky130_fd_sc_hd__nand2_1
XFILLER_101_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09653_ _01923_ _01948_ _01951_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__a21boi_1
XFILLER_67_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09584_ _01705_ _01574_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__nand2_1
XFILLER_55_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08604_ _00833_ _00902_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08535_ _00453_ _07842_ VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__nand2_1
XFILLER_63_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08466_ _00762_ _00764_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__nand2_1
X_08397_ _00669_ _00695_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__nand2_1
XFILLER_50_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10290_ _02586_ _02585_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__nand2_1
X_09018_ _01316_ _01310_ _01312_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__nand3_2
XFILLER_104_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13980_ net249 adder_inst.sum_raw_r\[8\] adder_inst.sum_raw_r\[7\] _06076_ _06247_
+ VGND VGND VPWR VPWR _06248_ sky130_fd_sc_hd__a221o_1
XFILLER_92_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12931_ _05225_ _05229_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__nor2_1
XFILLER_18_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15650_ net263 VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__inv_2
XFILLER_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12862_ _05081_ net109 net220 VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__and3_1
X_14601_ _06449_ _06539_ _06447_ VGND VGND VPWR VPWR _06841_ sky130_fd_sc_hd__o21ai_1
X_11813_ net125 net202 VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__nand2_1
X_15581_ net271 VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__inv_2
XFILLER_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12793_ _05091_ _04991_ VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_103_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14532_ _06770_ _06771_ VGND VGND VPWR VPWR _06772_ sky130_fd_sc_hd__nand2_1
XFILLER_14_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11744_ _04041_ _04042_ VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__nand2_1
XFILLER_53_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14463_ _06453_ _06498_ VGND VGND VPWR VPWR _06703_ sky130_fd_sc_hd__nand2_1
X_11675_ _03972_ _03973_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__nand2_1
X_10626_ _02918_ _02924_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__or2_1
X_13414_ _04435_ VGND VGND VPWR VPWR _05713_ sky130_fd_sc_hd__inv_2
X_16133_ clknet_leaf_14_clk _00090_ _00381_ VGND VGND VPWR VPWR mul_res\[26\] sky130_fd_sc_hd__dfrtp_1
X_14394_ _06633_ VGND VGND VPWR VPWR _06634_ sky130_fd_sc_hd__inv_2
X_10557_ _02855_ _02830_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__nand2_1
X_13345_ _05643_ _05604_ _05634_ VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__o21ai_2
XFILLER_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16064_ clknet_leaf_7_clk net347 _00312_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_10488_ _02786_ _02713_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__nand2_1
X_13276_ _05573_ _05571_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__nand2_1
X_15015_ _07259_ VGND VGND VPWR VPWR _07260_ sky130_fd_sc_hd__inv_2
X_12227_ _04522_ _04525_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_114_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12158_ _04454_ _04456_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__nand2_1
XFILLER_110_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11109_ _03080_ _03081_ VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__nand2_1
X_12089_ _01401_ _01399_ _04385_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__a21oi_1
X_15917_ clknet_leaf_6_clk net50 _00165_ VGND VGND VPWR VPWR adder_inst.exp_b\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_37_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15848_ net302 VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__inv_2
X_15779_ net282 VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__inv_2
XFILLER_64_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08320_ net121 net238 VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__nand2_1
XFILLER_17_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08251_ _00544_ _00549_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_43_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08182_ _00480_ _07802_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07966_ _07736_ VGND VGND VPWR VPWR _07737_ sky130_fd_sc_hd__inv_2
X_09705_ _02002_ _02003_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__nand2_1
XFILLER_28_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07897_ _07097_ _07117_ VGND VGND VPWR VPWR _07128_ sky130_fd_sc_hd__nand2_1
X_09636_ net154 net231 VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__nand2_1
XFILLER_67_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09567_ _01865_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__inv_2
X_09498_ _01796_ VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__inv_2
XFILLER_70_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08518_ _00816_ _00812_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__nand2_1
X_08449_ adder_inst.man_a_r\[15\] net169 VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__nand2_1
XFILLER_11_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11460_ _03757_ _03758_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__nand2_1
XFILLER_109_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10411_ _02709_ VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__inv_2
X_11391_ _03669_ _03683_ _03664_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10342_ _02524_ _02640_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__nand2_1
X_13130_ _04886_ _04883_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__nand2_1
X_13061_ _05348_ _05359_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__nor2_1
X_10273_ _02538_ _02528_ VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__and2_1
X_12012_ _04306_ _04310_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__xor2_2
XFILLER_78_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13963_ _06055_ VGND VGND VPWR VPWR _06232_ sky130_fd_sc_hd__buf_2
X_15702_ net281 VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__inv_2
XFILLER_46_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13894_ _06168_ VGND VGND VPWR VPWR _06169_ sky130_fd_sc_hd__inv_2
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12914_ _05015_ _05025_ VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__nand2_1
X_15633_ net280 VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__inv_2
XFILLER_73_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12845_ _04252_ _04237_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__nand2_1
X_15564_ net263 VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_14_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12776_ _05073_ _04964_ _05074_ VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__nand3_1
X_14515_ _06751_ _06754_ VGND VGND VPWR VPWR _06755_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11727_ _04024_ _03742_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__nand3_1
X_15495_ add_res\[8\] net403 net258 VGND VGND VPWR VPWR _07705_ sky130_fd_sc_hd__mux2_1
XFILLER_9_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14446_ _06684_ _06685_ _06462_ VGND VGND VPWR VPWR _06686_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_40_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11658_ _03953_ _03956_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_116_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10609_ _02854_ _02895_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__nand2_1
X_14377_ _06512_ _06612_ _06616_ VGND VGND VPWR VPWR _06617_ sky130_fd_sc_hd__o21ai_2
X_11589_ net123 net212 VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__nand2_1
X_16116_ clknet_leaf_18_clk _00103_ _00364_ VGND VGND VPWR VPWR mul_res\[9\] sky130_fd_sc_hd__dfrtp_1
X_13328_ _05625_ _05626_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_23_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16047_ clknet_leaf_11_clk _00060_ _00295_ VGND VGND VPWR VPWR add_res\[31\] sky130_fd_sc_hd__dfrtp_1
X_13259_ _05557_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__inv_2
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09421_ _01719_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__inv_2
XFILLER_64_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09352_ _01641_ _01648_ _01650_ VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__nand3_2
XFILLER_52_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08303_ _00601_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__inv_2
XFILLER_100_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09283_ _01581_ _01125_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__nand2_1
XFILLER_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08234_ _00532_ _07867_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__nand2_1
XFILLER_119_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08165_ _00463_ _07811_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__nand2_1
XFILLER_109_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08096_ _07866_ VGND VGND VPWR VPWR _07867_ sky130_fd_sc_hd__inv_2
XFILLER_102_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08998_ _01287_ _01296_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__nor2_1
XFILLER_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07949_ _07617_ _07626_ VGND VGND VPWR VPWR _07635_ sky130_fd_sc_hd__nand2_1
XFILLER_18_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10960_ net126 net218 VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__nand2_1
X_09619_ _01913_ _01915_ _01917_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__a21oi_1
X_10891_ _03188_ _03189_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__nand2_1
XFILLER_71_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12630_ _04721_ _04712_ VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_100_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12561_ _04798_ _04792_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__and2_1
XFILLER_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15280_ _07516_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__clkbuf_1
X_14300_ _06539_ _06540_ VGND VGND VPWR VPWR _06541_ sky130_fd_sc_hd__nand2_1
X_12492_ _04769_ _04760_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__nand2_1
X_11512_ net189 net147 VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__nand2_1
X_14231_ _06439_ _06434_ VGND VGND VPWR VPWR _06472_ sky130_fd_sc_hd__nand2_1
XFILLER_11_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11443_ _03728_ _03739_ _03737_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__nand3_1
X_14162_ _05904_ VGND VGND VPWR VPWR _06404_ sky130_fd_sc_hd__inv_2
XFILLER_109_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13113_ _05410_ _05392_ VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__nand2_1
X_11374_ _03672_ _03464_ VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__nand2_1
X_10325_ _02620_ _02623_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__nand2_1
X_14093_ adder_inst.sum_raw_r\[17\] net251 _06200_ adder_inst.sum_raw_r\[16\] VGND
+ VGND VPWR VPWR _06350_ sky130_fd_sc_hd__a22o_1
X_10256_ _02553_ _02545_ _02473_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_111_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13044_ _05341_ _05342_ VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__nand2_1
XFILLER_78_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10187_ _02483_ _02485_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__nand2_1
XFILLER_93_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14995_ _07226_ _07238_ VGND VGND VPWR VPWR _07239_ sky130_fd_sc_hd__or2_1
X_13946_ _06216_ _06044_ _06131_ VGND VGND VPWR VPWR _06217_ sky130_fd_sc_hd__o21ai_1
XFILLER_62_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13877_ _06099_ _06092_ VGND VGND VPWR VPWR _06152_ sky130_fd_sc_hd__or2b_1
X_15616_ net278 VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__inv_2
XFILLER_61_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12828_ _05125_ _05122_ _05123_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__nand3b_1
X_15547_ net271 VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__inv_2
X_12759_ _04948_ _04947_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__nor2b_1
X_15478_ net399 VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__clkbuf_1
X_14429_ _06668_ VGND VGND VPWR VPWR _06669_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_77_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09970_ _02268_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__inv_2
XFILLER_115_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08921_ _01219_ _00939_ VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__nand2_1
X_08852_ _01149_ _01150_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__nand2_1
XFILLER_84_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08783_ _01038_ _01033_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__nand2_1
XFILLER_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09404_ _01686_ _01687_ _01691_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__nand3_1
XFILLER_52_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09335_ _01620_ _01631_ _01633_ VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__nand3_1
XFILLER_40_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09266_ _01564_ _01137_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__nor2_1
X_08217_ _00514_ _00515_ VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__nand2_1
XFILLER_119_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09197_ _01495_ VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__inv_2
XFILLER_4_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08148_ _07851_ _00446_ VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__nand2_1
X_08079_ _07848_ _07849_ VGND VGND VPWR VPWR _07850_ sky130_fd_sc_hd__nand2_1
X_10110_ _02391_ _02396_ _02387_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__a21boi_1
X_11090_ _03362_ _03388_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__nand2_1
X_10041_ _02252_ _02336_ _02339_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__nand3_1
Xhold20 adder_inst.i_a\[2\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 adder_inst.i_a\[18\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_48_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold42 adder_inst.i_a\[4\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 adder_inst.exp_a\[3\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 adder_inst.i_b\[20\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 add_res\[27\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 _06017_ VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
X_13800_ adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _06075_ sky130_fd_sc_hd__inv_2
Xhold86 add_res\[13\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
X_14780_ _07015_ _07019_ VGND VGND VPWR VPWR _07020_ sky130_fd_sc_hd__nand2_4
XFILLER_75_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11992_ _04288_ _04285_ _04286_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__nand3_1
XFILLER_29_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13731_ net381 adder_inst.is_zero_a_r VGND VGND VPWR VPWR _06017_ sky130_fd_sc_hd__nand2_1
XFILLER_56_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10943_ _03240_ _03241_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13662_ _05953_ _05954_ VGND VGND VPWR VPWR _05955_ sky130_fd_sc_hd__nand2_1
X_10874_ _03165_ _03170_ VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__nand2_1
XFILLER_16_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13593_ _05837_ _05838_ _05889_ VGND VGND VPWR VPWR _05890_ sky130_fd_sc_hd__nand3_1
X_15401_ _07530_ _07623_ _07627_ VGND VGND VPWR VPWR multiplier_inst.man_final\[6\]
+ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_61_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12613_ _04908_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__inv_2
XFILLER_12_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15332_ _02903_ _07556_ VGND VGND VPWR VPWR _07558_ sky130_fd_sc_hd__nor2_1
X_12544_ _04841_ _04842_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__nand2_1
X_15263_ _07492_ multiplier_inst.man_final_r\[9\] _07494_ VGND VGND VPWR VPWR _07506_
+ sky130_fd_sc_hd__and3_1
XFILLER_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12475_ _04771_ _04773_ VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__nand2_1
XANTENNA_6 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15194_ _07443_ _07448_ _07445_ VGND VGND VPWR VPWR _07449_ sky130_fd_sc_hd__nand3_1
X_14214_ _06449_ _06451_ _06454_ VGND VGND VPWR VPWR _06455_ sky130_fd_sc_hd__mux2_1
X_11426_ _03702_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__inv_2
X_14145_ _06392_ VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__inv_2
X_11357_ _03608_ _03650_ _03655_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__nand3_1
XFILLER_113_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10308_ _02606_ _02251_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__nand2_1
X_14076_ _06184_ _06332_ _06334_ VGND VGND VPWR VPWR _06335_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11288_ _03425_ _03426_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__nand2_1
X_13027_ _05324_ _05325_ VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__nand2_1
X_10239_ _02529_ _02537_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_72_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14978_ _07207_ _07220_ VGND VGND VPWR VPWR _07221_ sky130_fd_sc_hd__or2_1
XFILLER_81_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13929_ _06194_ adder_inst.sum_raw_r\[3\] adder_inst.sum_raw_r\[2\] _06195_ _06201_
+ VGND VGND VPWR VPWR _06202_ sky130_fd_sc_hd__o221a_1
XFILLER_34_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09120_ _00582_ _00581_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__nor2_1
X_09051_ _01347_ _01349_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08002_ _07762_ _07764_ _07772_ VGND VGND VPWR VPWR _07773_ sky130_fd_sc_hd__nand3_1
XFILLER_104_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09953_ _02251_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__inv_2
XFILLER_103_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09884_ _02162_ _02012_ _02182_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__a21oi_1
X_08904_ _00933_ _00765_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__nand2_1
X_08835_ _00979_ _00980_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__nand2_1
XFILLER_85_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08766_ adder_inst.man_b_r\[17\] net248 VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08697_ _00809_ _00807_ _00805_ VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_0_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09318_ _01615_ _01616_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__nand2_1
X_10590_ _02888_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__inv_2
XFILLER_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09249_ _01546_ _01547_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__nand2_1
XFILLER_21_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12260_ net189 net123 VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__nand2_1
XFILLER_107_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12191_ _04436_ _04487_ _04486_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__nand3_1
X_11211_ _03416_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__inv_2
X_11142_ _03440_ _03277_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__nand2_1
Xoutput76 net76 VGND VGND VPWR VPWR o_res[17] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput87 net87 VGND VGND VPWR VPWR o_res[27] sky130_fd_sc_hd__buf_2
X_15950_ clknet_leaf_3_clk net337 _00198_ VGND VGND VPWR VPWR adder_inst.man_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_2
Xoutput98 net98 VGND VGND VPWR VPWR o_res[8] sky130_fd_sc_hd__buf_2
XFILLER_49_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11073_ _03306_ _03303_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10024_ _02202_ _02035_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__nor2_1
X_14901_ _07136_ _07139_ _07020_ VGND VGND VPWR VPWR _07140_ sky130_fd_sc_hd__mux2_1
XFILLER_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15881_ clknet_leaf_24_clk net14 _00129_ VGND VGND VPWR VPWR adder_inst.i_a\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_14832_ _07067_ _07068_ _06019_ VGND VGND VPWR VPWR _07069_ sky130_fd_sc_hd__a21o_1
XFILLER_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14763_ _07002_ _06801_ VGND VGND VPWR VPWR _07003_ sky130_fd_sc_hd__nand2_1
X_11975_ _04112_ _04272_ VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__nand2_1
XFILLER_17_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13714_ adder_inst.i_b\[21\] adder_inst.i_b\[20\] adder_inst.i_b\[22\] _06001_ VGND
+ VGND VPWR VPWR _06002_ sky130_fd_sc_hd__or4_2
X_14694_ _06466_ _06835_ _06462_ _06837_ VGND VGND VPWR VPWR _06934_ sky130_fd_sc_hd__o211ai_1
X_10926_ _03224_ _03218_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__nand2_1
XFILLER_32_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13645_ _05838_ VGND VGND VPWR VPWR _05939_ sky130_fd_sc_hd__inv_2
XFILLER_44_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10857_ _03155_ _03041_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__nand2_1
XFILLER_16_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13576_ _05871_ _05862_ VGND VGND VPWR VPWR _05873_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10788_ _03023_ _03025_ _03056_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__nand3_1
XFILLER_8_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15315_ _05708_ _07538_ VGND VGND VPWR VPWR _07539_ sky130_fd_sc_hd__nand2_1
X_12527_ _04824_ _04822_ _04823_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__nand3_1
X_15246_ _07495_ VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__clkbuf_1
X_12458_ _04755_ _04751_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__nand2_1
XFILLER_8_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11409_ _03707_ VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__inv_2
XFILLER_99_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15177_ _07429_ _07430_ VGND VGND VPWR VPWR _07431_ sky130_fd_sc_hd__nand2_1
X_12389_ net123 net198 VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__nand2_1
X_14128_ _06374_ _06054_ VGND VGND VPWR VPWR _06381_ sky130_fd_sc_hd__nand2_1
XFILLER_98_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14059_ _06277_ adder_inst.sum_raw_r\[8\] VGND VGND VPWR VPWR _06319_ sky130_fd_sc_hd__and2_1
XFILLER_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08620_ _00917_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__inv_2
XFILLER_54_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08551_ _00849_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__inv_2
XFILLER_35_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08482_ _00780_ _00500_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__nand2_1
XFILLER_22_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09103_ _01398_ _01400_ _01401_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_33_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09034_ _01331_ _01332_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_96_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09936_ _02231_ _02233_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__nand2_1
XFILLER_89_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09867_ _02164_ _02165_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__nand2_1
X_09798_ _02087_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__inv_2
XFILLER_93_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08818_ _01114_ _01116_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__nand2_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08749_ _00865_ _00874_ _00873_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__nand3_1
XFILLER_26_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11760_ net189 net140 VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10711_ _03001_ _03009_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__nor2_1
XFILLER_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11691_ _03980_ _03989_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__nand2_1
XFILLER_13_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10642_ _02924_ _02918_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__nand2_1
X_13430_ _05726_ _04526_ VGND VGND VPWR VPWR _05729_ sky130_fd_sc_hd__nand2_1
XFILLER_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10573_ _02805_ _01448_ _02806_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__nor3_1
X_13361_ _05592_ _05629_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__or2b_1
X_16080_ clknet_leaf_18_clk multiplier_inst.man_final\[6\] _00328_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_15100_ _07347_ _06610_ VGND VGND VPWR VPWR _07350_ sky130_fd_sc_hd__nand2_1
X_13292_ _05590_ VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__inv_2
X_12312_ _04610_ _04601_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__nand2_1
X_15031_ _07273_ _07276_ VGND VGND VPWR VPWR _07277_ sky130_fd_sc_hd__nand2_1
X_12243_ _04051_ _04047_ _04049_ VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__nand3_1
XFILLER_107_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12174_ _04472_ _04445_ _04450_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__nand3_1
X_11125_ _03423_ VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__inv_2
X_15933_ clknet_leaf_9_clk adder_inst.sum_raw\[8\] _00181_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[8\]
+ sky130_fd_sc_hd__dfrtp_4
XPHY_EDGE_ROW_79_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11056_ _03351_ _03352_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__nand2_1
X_10007_ _02257_ _02302_ _02305_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__nand3_1
XFILLER_95_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15864_ clknet_leaf_6_clk net27 _00112_ VGND VGND VPWR VPWR adder_inst.i_a\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_108_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14815_ _07040_ _06908_ _07051_ VGND VGND VPWR VPWR _07052_ sky130_fd_sc_hd__a21oi_1
X_15795_ net284 VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__inv_2
XFILLER_64_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14746_ _06554_ net231 VGND VGND VPWR VPWR _06986_ sky130_fd_sc_hd__nand2_1
XFILLER_17_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11958_ _04085_ _04073_ VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__nand2_1
XFILLER_17_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14677_ _06507_ _06511_ _06487_ VGND VGND VPWR VPWR _06917_ sky130_fd_sc_hd__nand3_1
X_10909_ _03204_ _03207_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__nand2_1
XFILLER_20_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11889_ _04187_ _03920_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__nand2_1
X_13628_ _05916_ _05909_ VGND VGND VPWR VPWR _05923_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_80_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13559_ _05855_ adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR _05856_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15229_ adder_inst.exp_a_r\[2\] adder_inst.exp_b_r\[2\] _06563_ VGND VGND VPWR VPWR
+ _07483_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout118 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_2
Xfanout107 net108 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_2
X_07982_ _07750_ _07752_ VGND VGND VPWR VPWR _07753_ sky130_fd_sc_hd__nand2_1
Xfanout129 net130 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_91_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09721_ _01957_ _01963_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__nand2_1
XFILLER_67_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09652_ _01950_ _01881_ _01897_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__nand3_2
XFILLER_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09583_ _01881_ _01880_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08603_ _00900_ _00901_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__nand2_1
X_08534_ _00798_ _00831_ _00832_ VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__a21oi_2
XFILLER_70_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08465_ _00763_ _00760_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__nand2_1
X_08396_ _00694_ VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__inv_2
XFILLER_11_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09017_ _01314_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__inv_2
XFILLER_12_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09919_ _02217_ _02213_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__nand2_1
XFILLER_86_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12930_ _05228_ _05035_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__nand2_1
XFILLER_18_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12861_ _05159_ VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__inv_2
X_14600_ _06464_ _06454_ VGND VGND VPWR VPWR _06840_ sky130_fd_sc_hd__nor2_1
X_11812_ net123 net208 VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__nand2_1
XFILLER_34_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15580_ net273 VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__inv_2
XFILLER_14_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12792_ _04996_ _04994_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_103_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14531_ _06558_ _00588_ VGND VGND VPWR VPWR _06771_ sky130_fd_sc_hd__nand2_1
XFILLER_41_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11743_ _03883_ _04039_ _04038_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__nand3_1
X_14462_ _06508_ _06482_ _06701_ VGND VGND VPWR VPWR _06702_ sky130_fd_sc_hd__o21ai_1
X_11674_ _03971_ _03967_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__nand2_1
X_10625_ _02922_ _02923_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__nand2_1
X_13413_ _05663_ _05711_ VGND VGND VPWR VPWR _05712_ sky130_fd_sc_hd__nand2_1
X_16132_ clknet_leaf_14_clk _00089_ _00380_ VGND VGND VPWR VPWR mul_res\[25\] sky130_fd_sc_hd__dfrtp_1
X_14393_ _06519_ _06632_ VGND VGND VPWR VPWR _06633_ sky130_fd_sc_hd__nor2_1
X_10556_ _02837_ _02840_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__nand2_1
X_13344_ _05596_ VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__clkinvlp_2
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16063_ clknet_leaf_7_clk net351 _00311_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_10487_ _02632_ _02630_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__nand2_1
X_13275_ _05571_ _05573_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__nor2_1
X_15014_ _06757_ _06741_ VGND VGND VPWR VPWR _07259_ sky130_fd_sc_hd__nand2_1
X_12226_ _04524_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_114_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_87_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12157_ _04455_ _03627_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__nand2_1
XFILLER_68_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11108_ _03402_ _03406_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__nand2_1
X_12088_ _04384_ _04386_ VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__nand2_1
X_15916_ clknet_leaf_7_clk net49 _00164_ VGND VGND VPWR VPWR adder_inst.exp_b\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_110_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11039_ _03297_ _03334_ _03337_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__nand3_1
X_15847_ net305 VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_69_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15778_ net282 VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_96_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14729_ _06963_ _06968_ VGND VGND VPWR VPWR _06969_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_15_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08250_ _00547_ _00548_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_43_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08181_ net201 net164 VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__nand2_1
XFILLER_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07965_ net200 net158 VGND VGND VPWR VPWR _07736_ sky130_fd_sc_hd__nand2_1
XFILLER_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09704_ _01889_ _01767_ _01800_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__nand3_1
X_07896_ _07107_ adder_inst.exp_a_r\[1\] VGND VGND VPWR VPWR _07117_ sky130_fd_sc_hd__nand2_1
X_09635_ _01933_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__inv_2
XFILLER_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09566_ _01855_ _01860_ _01864_ VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09497_ _01795_ _01791_ VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__nand2_1
X_08517_ _00812_ _00813_ _00815_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__nand3_2
XFILLER_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08448_ _00746_ _00475_ VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__nand2_1
XFILLER_23_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10410_ _02615_ _02705_ _02708_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__nand3_2
X_08379_ net139 net229 VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__nand2_1
XFILLER_99_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11390_ _03687_ _03688_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__nand2_1
X_10341_ net162 net239 VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__nand2_1
X_10272_ _02570_ _02244_ VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__nand2_1
X_13060_ _05355_ _05358_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__nand2_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12011_ _04307_ _04309_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__nand2_1
X_13962_ _06066_ VGND VGND VPWR VPWR _06231_ sky130_fd_sc_hd__buf_2
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15701_ net290 VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__inv_2
XFILLER_74_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12913_ _05128_ _05119_ _05118_ VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__o21ai_1
X_13893_ net250 _06162_ _06163_ _06164_ _06167_ VGND VGND VPWR VPWR _06168_ sky130_fd_sc_hd__a311o_1
XFILLER_100_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15632_ net280 VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__inv_2
X_12844_ _05142_ _04096_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__nand2_1
X_15563_ net263 VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__inv_2
X_12775_ _04963_ _04961_ VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__nand2_1
X_14514_ _06753_ VGND VGND VPWR VPWR _06754_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_64_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11726_ _03751_ _03743_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__or2_1
X_15494_ net412 VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14445_ _06500_ _06446_ VGND VGND VPWR VPWR _06685_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_40_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11657_ _03954_ _03955_ _03770_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_116_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10608_ _02904_ _02906_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__nand2_1
X_14376_ _06615_ _06512_ VGND VGND VPWR VPWR _06616_ sky130_fd_sc_hd__nand2_1
X_11588_ _03722_ _03886_ _03717_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__o21ai_1
X_10539_ _02836_ _02760_ VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__nand2_1
X_16115_ clknet_leaf_19_clk _00102_ _00363_ VGND VGND VPWR VPWR mul_res\[8\] sky130_fd_sc_hd__dfrtp_1
X_13327_ _05502_ _05496_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__and2_1
XFILLER_10_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_16046_ clknet_leaf_12_clk _00059_ _00294_ VGND VGND VPWR VPWR add_res\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13258_ _05556_ _05554_ VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13189_ _05483_ _05487_ VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__xor2_1
X_12209_ _04500_ _04505_ _04507_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__nand3_1
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09420_ _01718_ _01714_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__nand2_1
XFILLER_80_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09351_ _01646_ _01649_ _01255_ VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__nand3_1
XFILLER_52_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09282_ _01128_ _01131_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__nand2_1
X_08302_ _00544_ _00600_ _00547_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__o21ai_1
XFILLER_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08233_ _07868_ _07869_ _07865_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__o21ai_1
XFILLER_119_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08164_ _00459_ _00462_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__nand2_1
X_08095_ net140 net221 VGND VGND VPWR VPWR _07866_ sky130_fd_sc_hd__nand2_1
XFILLER_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08997_ _01293_ _01295_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__nand2_1
XFILLER_56_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07948_ _07599_ _07349_ _07338_ VGND VGND VPWR VPWR _07626_ sky130_fd_sc_hd__nand3_1
XFILLER_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09618_ _01916_ _01711_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__nor2_1
X_10890_ _03013_ _03017_ _03010_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__a21oi_1
XFILLER_18_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09549_ _01641_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__inv_2
XFILLER_55_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12560_ _04858_ _04853_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__nand2_1
XFILLER_34_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12491_ _04786_ _04789_ _04784_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__o21ai_1
X_11511_ net189 net144 VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__nand2_1
XFILLER_11_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14230_ _06447_ _06455_ _06462_ _06470_ VGND VGND VPWR VPWR _06471_ sky130_fd_sc_hd__o211ai_1
X_11442_ _03729_ _03740_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__nand2_1
X_14161_ _05912_ VGND VGND VPWR VPWR _06403_ sky130_fd_sc_hd__inv_2
X_11373_ _03473_ _03465_ VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__or2_1
X_10324_ _02621_ _02622_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__nand2_1
X_13112_ _05392_ _05410_ VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__or2_1
X_14092_ adder_inst.sum_raw_r\[15\] _06204_ adder_inst.sum_raw_r\[14\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06349_ sky130_fd_sc_hd__o221a_1
XFILLER_3_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10255_ _02546_ _02553_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__nand2_1
XFILLER_105_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13043_ _05334_ _05337_ _05339_ VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_111_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10186_ _02478_ _02484_ _02480_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__nand3_1
XFILLER_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout290 net292 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_4
XFILLER_93_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14994_ _07220_ _06741_ _07237_ VGND VGND VPWR VPWR _07238_ sky130_fd_sc_hd__a21o_1
XFILLER_19_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13945_ adder_inst.sum_raw_r\[3\] VGND VGND VPWR VPWR _06216_ sky130_fd_sc_hd__inv_2
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13876_ _06110_ _06148_ _06150_ _06108_ adder_inst.sum_raw_r\[19\] VGND VGND VPWR
+ VPWR _06151_ sky130_fd_sc_hd__a221o_1
XFILLER_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15615_ net278 VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__inv_2
XFILLER_62_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12827_ _05124_ _05125_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__nand2_1
XFILLER_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15546_ net269 VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__inv_2
XFILLER_61_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12758_ _05056_ _05053_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__and2_1
X_15477_ net398 mul_ovf net260 VGND VGND VPWR VPWR _07694_ sky130_fd_sc_hd__mux2_1
X_11709_ _04007_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__inv_2
X_12689_ _04984_ _04986_ _04987_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__o21ai_1
XFILLER_30_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14428_ _06666_ _06667_ VGND VGND VPWR VPWR _06668_ sky130_fd_sc_hd__nor2_1
XFILLER_30_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14359_ _06598_ _06461_ VGND VGND VPWR VPWR _06599_ sky130_fd_sc_hd__nand2_1
X_16029_ clknet_leaf_16_clk _00040_ _00277_ VGND VGND VPWR VPWR add_res\[13\] sky130_fd_sc_hd__dfrtp_1
X_08920_ _00947_ VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__inv_2
X_08851_ net148 net228 VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__nand2_1
XFILLER_111_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08782_ _01037_ _01041_ _01080_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__nand3_1
XFILLER_38_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09403_ _01701_ _01692_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__nand2_1
XFILLER_52_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09334_ _01632_ _01627_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__nand2_1
X_09265_ net215 net165 VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09196_ _00564_ _00724_ _01494_ VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08216_ _07797_ _07799_ _00462_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__nand3_1
XFILLER_107_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08147_ _00442_ _00445_ VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__nand2_1
X_08078_ _07819_ _07842_ _07816_ VGND VGND VPWR VPWR _07849_ sky130_fd_sc_hd__a21boi_1
XFILLER_106_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10040_ _02337_ _02338_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__nand2_1
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold21 adder_inst.i_b\[0\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 adder_inst.i_a\[15\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 adder_inst.i_a\[19\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 adder_inst.exp_a\[7\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 adder_inst.exp_a\[0\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold43 adder_inst.i_b\[16\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 multiplier_inst.exp_final_r\[6\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 add_res\[28\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 add_res\[26\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
X_11991_ _04287_ _04289_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__nand2_1
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13730_ adder_inst.man_a\[23\] _06016_ VGND VGND VPWR VPWR adder_inst.is_zero_a sky130_fd_sc_hd__nor2_1
XFILLER_90_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10942_ _03216_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13661_ _05900_ _05902_ _05952_ VGND VGND VPWR VPWR _05954_ sky130_fd_sc_hd__o21ai_1
X_15400_ _07625_ _07530_ VGND VGND VPWR VPWR _07627_ sky130_fd_sc_hd__nand2_1
XFILLER_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10873_ _03166_ _03171_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__nand2_1
X_13592_ _05887_ _05888_ VGND VGND VPWR VPWR _05889_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12612_ _04867_ _04909_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__nand2_1
X_15331_ _07556_ _02903_ VGND VGND VPWR VPWR _07557_ sky130_fd_sc_hd__and2_1
X_12543_ _04813_ _04814_ _04839_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__nand3_1
X_15262_ _07505_ VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14213_ _06453_ VGND VGND VPWR VPWR _06454_ sky130_fd_sc_hd__buf_2
X_12474_ _04772_ _04747_ _04748_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__nand3_1
X_15193_ _06671_ VGND VGND VPWR VPWR _07448_ sky130_fd_sc_hd__inv_2
XANTENNA_7 net165 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11425_ _03702_ _03720_ _03723_ VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__nand3_1
X_14144_ _06186_ net103 _06160_ _00068_ VGND VGND VPWR VPWR _06392_ sky130_fd_sc_hd__a31oi_2
X_11356_ _03652_ _03654_ VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__nand2_1
X_14075_ _06078_ _06054_ _06333_ _06077_ VGND VGND VPWR VPWR _06334_ sky130_fd_sc_hd__o22a_1
X_10307_ _02339_ _02336_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__nand2_1
XFILLER_3_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13026_ _05319_ _05320_ _05322_ VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__nand3_1
X_11287_ _03585_ VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__inv_2
X_10238_ _02536_ _02533_ VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__nand2_1
XFILLER_79_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10169_ net230 net167 VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__nand2_1
XFILLER_86_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14977_ _07213_ _07219_ VGND VGND VPWR VPWR _07220_ sky130_fd_sc_hd__nand2_1
X_13928_ adder_inst.sum_raw_r\[1\] net251 _06200_ adder_inst.sum_raw_r\[0\] _06042_
+ VGND VGND VPWR VPWR _06201_ sky130_fd_sc_hd__a221o_1
XFILLER_35_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13859_ _06133_ net252 VGND VGND VPWR VPWR _06134_ sky130_fd_sc_hd__nand2_1
XFILLER_22_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15529_ net395 mul_res\[25\] net260 VGND VGND VPWR VPWR _07725_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_83_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09050_ _01343_ _01348_ _01344_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_20_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08001_ _07771_ VGND VGND VPWR VPWR _07772_ sky130_fd_sc_hd__inv_2
X_09952_ _02248_ _02250_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__nand2_1
XFILLER_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08903_ _01201_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__inv_2
XFILLER_106_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09883_ _02156_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__inv_2
XFILLER_97_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08834_ _01132_ _01128_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__nand2_1
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08765_ _01062_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__nand2_1
XFILLER_57_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08696_ _00991_ _00993_ _00994_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__nand3_1
XFILLER_38_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09317_ _01608_ _01597_ _01609_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__a21o_1
XFILLER_15_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09248_ _01234_ _01140_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__nand2_1
XFILLER_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09179_ _01476_ _01477_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__nand2_1
XFILLER_107_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12190_ _04436_ _04488_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__nand2b_1
XFILLER_5_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11210_ _03417_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__inv_2
XFILLER_107_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11141_ _03438_ _03439_ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput88 net88 VGND VGND VPWR VPWR o_res[28] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR o_res[18] sky130_fd_sc_hd__buf_2
XFILLER_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput99 net99 VGND VGND VPWR VPWR o_res[9] sky130_fd_sc_hd__buf_2
X_11072_ _03370_ _03303_ _03306_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__nand3_1
XFILLER_0_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10023_ _02321_ _02045_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__nand2_1
X_14900_ _06818_ _07137_ VGND VGND VPWR VPWR _07139_ sky130_fd_sc_hd__xor2_1
XFILLER_76_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15880_ clknet_leaf_24_clk net13 _00128_ VGND VGND VPWR VPWR adder_inst.i_a\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_48_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14831_ _07065_ _06933_ VGND VGND VPWR VPWR _07068_ sky130_fd_sc_hd__nand2_1
XFILLER_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14762_ _07001_ VGND VGND VPWR VPWR _07002_ sky130_fd_sc_hd__inv_2
XFILLER_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11974_ _04112_ _04272_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__or2_1
XFILLER_16_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14693_ _06932_ VGND VGND VPWR VPWR _06933_ sky130_fd_sc_hd__inv_2
X_13713_ adder_inst.i_b\[17\] adder_inst.i_b\[16\] adder_inst.i_b\[19\] adder_inst.i_b\[18\]
+ VGND VGND VPWR VPWR _06001_ sky130_fd_sc_hd__or4_1
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10925_ _03221_ _03222_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__nand2_1
X_13644_ _05938_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[5\] sky130_fd_sc_hd__inv_2
XFILLER_44_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10856_ _03044_ _03153_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__nor2_1
XFILLER_32_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13575_ _05862_ _05871_ VGND VGND VPWR VPWR _05872_ sky130_fd_sc_hd__or2_1
X_15314_ _02457_ VGND VGND VPWR VPWR _07538_ sky130_fd_sc_hd__inv_2
X_10787_ _03026_ _03058_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__nand2_1
XFILLER_12_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12526_ _04822_ _04823_ _04824_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__a21o_1
XFILLER_117_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15245_ _07492_ multiplier_inst.man_final_r\[0\] _07494_ VGND VGND VPWR VPWR _07495_
+ sky130_fd_sc_hd__and3_1
XFILLER_68_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12457_ _04751_ _04755_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__or2_1
XFILLER_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15176_ _06640_ _06636_ VGND VGND VPWR VPWR _07430_ sky130_fd_sc_hd__nand2_1
XFILLER_8_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11408_ net125 net208 VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__nand2_1
X_14127_ _06232_ _06333_ VGND VGND VPWR VPWR _06380_ sky130_fd_sc_hd__nand2_1
XFILLER_98_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12388_ _04685_ _04686_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__xor2_1
X_11339_ _03626_ _03627_ _03635_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__nand3_1
XFILLER_97_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14058_ _06318_ VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_67_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13009_ _05158_ _05160_ _05307_ VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_85_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08550_ _00826_ _00817_ _00848_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_53_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08481_ _00503_ _00504_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__nand2_1
XFILLER_22_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09102_ _01394_ _01396_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__nand2_1
XFILLER_31_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09033_ _07555_ _07413_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_107_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09935_ _02221_ _02231_ _02233_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__nand3b_1
XFILLER_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09866_ _02156_ _02162_ _02013_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_5_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08817_ _01110_ _01111_ _01115_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_116_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09797_ _02081_ _02089_ VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__nand2_1
XFILLER_85_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08748_ _01045_ _01046_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__nand2_1
XFILLER_45_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08679_ _00977_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__inv_2
XFILLER_81_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10710_ net195 net144 VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__nand2_1
XFILLER_14_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11690_ _03981_ _03988_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__xnor2_1
XFILLER_13_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10641_ _02915_ _02938_ _02939_ VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__nand3_2
XFILLER_13_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10572_ net171 net242 net174 net239 VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__a22o_1
X_13360_ _05658_ VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__inv_2
XFILLER_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13291_ _05588_ _05589_ VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__nand2_1
X_12311_ _04601_ _04603_ _04609_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__nand3_1
X_15030_ _07271_ _06788_ _07274_ VGND VGND VPWR VPWR _07276_ sky130_fd_sc_hd__nand3_1
X_12242_ _04056_ _04540_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__nor2_1
XFILLER_5_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12173_ _04470_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__inv_2
XFILLER_110_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11124_ _01378_ _01373_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__nand2_1
XFILLER_110_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15932_ clknet_leaf_9_clk adder_inst.sum_raw\[7\] _00180_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11055_ _03351_ _03352_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__nand3_1
X_10006_ _02303_ _02304_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_108_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15863_ clknet_leaf_3_clk net26 _00111_ VGND VGND VPWR VPWR adder_inst.i_a\[3\] sky130_fd_sc_hd__dfrtp_1
X_14814_ _07050_ VGND VGND VPWR VPWR _07051_ sky130_fd_sc_hd__inv_2
X_15794_ net284 VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__inv_2
XFILLER_36_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14745_ _06984_ _06802_ VGND VGND VPWR VPWR _06985_ sky130_fd_sc_hd__nand2_1
X_11957_ _04254_ _04255_ VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__nand2_1
XFILLER_83_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10908_ _03205_ _03111_ _03206_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_67_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14676_ _06484_ _06478_ _06512_ _06485_ VGND VGND VPWR VPWR _06916_ sky130_fd_sc_hd__o211ai_1
X_11888_ _03931_ _03921_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__or2_1
X_13627_ _05921_ VGND VGND VPWR VPWR _05922_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_80_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10839_ _03125_ _03137_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__nand2_1
XFILLER_20_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13558_ adder_inst.exp_b_r\[3\] VGND VGND VPWR VPWR _05855_ sky130_fd_sc_hd__inv_2
XFILLER_12_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_119_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12509_ _04806_ _04803_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__nand2_1
XFILLER_9_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15228_ _07482_ VGND VGND VPWR VPWR adder_inst.exp_larger\[1\] sky130_fd_sc_hd__clkbuf_1
X_13489_ _05664_ _05761_ VGND VGND VPWR VPWR _05788_ sky130_fd_sc_hd__nand2_1
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15159_ _07410_ _07411_ _06000_ VGND VGND VPWR VPWR _07412_ sky130_fd_sc_hd__a21o_1
XFILLER_113_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout108 adder_inst.man_b_r\[23\] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_4
X_07981_ _07751_ VGND VGND VPWR VPWR _07752_ sky130_fd_sc_hd__inv_2
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_2
XFILLER_99_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09720_ _02016_ _02018_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__nand2_1
XFILLER_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09651_ _01949_ _01921_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__nand2_1
XFILLER_27_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09582_ _01880_ _01726_ _01736_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__nand3_1
XFILLER_67_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08602_ _00838_ _00521_ _00559_ VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__nand3_1
X_08533_ _00797_ _00737_ VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__nor2_1
XFILLER_63_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08464_ _00756_ _00759_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__nor2_1
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08395_ _00683_ _00691_ _00693_ VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__a21oi_1
XFILLER_11_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09016_ _01313_ _01314_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__nand2_1
XFILLER_12_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09918_ _02211_ _02216_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__or2_1
XFILLER_100_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09849_ _01812_ _01814_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__nand2_1
XFILLER_37_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12860_ _00650_ _03911_ _05080_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__o21ai_1
XFILLER_37_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11811_ _04108_ _04109_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14530_ _06765_ _06637_ VGND VGND VPWR VPWR _06770_ sky130_fd_sc_hd__nand2_1
X_12791_ _05088_ _05089_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__nand2_1
XFILLER_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11742_ _03884_ _04040_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__nand2_1
X_14461_ _06453_ _06493_ VGND VGND VPWR VPWR _06701_ sky130_fd_sc_hd__nand2_1
XFILLER_41_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11673_ _03967_ _03971_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__or2_1
XFILLER_14_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10624_ net172 net246 net175 net243 VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__a22o_1
X_14392_ _06631_ _06473_ VGND VGND VPWR VPWR _06632_ sky130_fd_sc_hd__nand2_1
X_13412_ _01530_ _05710_ VGND VGND VPWR VPWR _05711_ sky130_fd_sc_hd__xnor2_2
X_16131_ clknet_leaf_14_clk _00088_ _00379_ VGND VGND VPWR VPWR mul_res\[24\] sky130_fd_sc_hd__dfrtp_1
X_13343_ _05641_ _05638_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__nand2_1
X_10555_ _02850_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__inv_2
X_16062_ clknet_leaf_11_clk net342 _00310_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_108_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10486_ _02782_ _02784_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__nand2_1
X_13274_ _05572_ _05556_ VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__nand2_1
XFILLER_5_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15013_ _07257_ _07141_ VGND VGND VPWR VPWR _07258_ sky130_fd_sc_hd__nand2_1
X_12225_ _04481_ _04484_ _04523_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12156_ _03635_ _03628_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__or2_1
XFILLER_110_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11107_ _03405_ _03247_ _03250_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__nand3_1
XFILLER_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12087_ _01401_ _01399_ _04385_ VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__a21o_1
X_15915_ clknet_leaf_7_clk net48 _00163_ VGND VGND VPWR VPWR adder_inst.exp_b\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_92_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11038_ _03335_ _03336_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__nand2_1
X_15846_ net299 VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__inv_2
XFILLER_94_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15777_ net287 VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__inv_2
XFILLER_45_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12989_ _05282_ _05283_ _05285_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__nand3_1
X_14728_ _06967_ _06959_ VGND VGND VPWR VPWR _06968_ sky130_fd_sc_hd__nand2_1
X_14659_ _06897_ _06898_ VGND VGND VPWR VPWR _06899_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08180_ _00470_ _00478_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__nand2_1
XFILLER_118_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07964_ _07734_ VGND VGND VPWR VPWR _07735_ sky130_fd_sc_hd__inv_2
X_07895_ adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR _07107_ sky130_fd_sc_hd__inv_2
X_09703_ _01890_ _01892_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__nand2_1
X_09634_ net151 net233 VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__nand2_1
XFILLER_55_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09565_ _01846_ _01863_ VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__nor2_1
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09496_ _01789_ _01791_ _01794_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__nand3_1
X_08516_ _00673_ _00814_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__xor2_1
XFILLER_51_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08447_ net200 net170 VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__nand2_1
X_08378_ _00676_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__inv_2
XFILLER_23_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10340_ _02536_ _02638_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__nand2_1
X_10271_ _02569_ _00651_ _02227_ VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__o21ai_1
XFILLER_105_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12010_ _00650_ _03261_ _04308_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__o21ai_1
XFILLER_78_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13961_ _06131_ _06226_ _06230_ _06181_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__a211oi_1
XFILLER_59_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15700_ net304 VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__inv_2
XFILLER_19_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12912_ _05208_ _05209_ _05210_ VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__a21oi_1
X_13892_ _06165_ _06126_ _06166_ VGND VGND VPWR VPWR _06167_ sky130_fd_sc_hd__a21oi_1
XFILLER_73_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15631_ net280 VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__inv_2
XFILLER_73_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12843_ _05141_ _05056_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__nand2_1
XFILLER_27_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15562_ net263 VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__inv_2
X_12774_ _05072_ _05068_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__nand2_1
X_15493_ add_res\[7\] net411 net258 VGND VGND VPWR VPWR _07704_ sky130_fd_sc_hd__mux2_1
X_14513_ _06660_ _06748_ _06752_ VGND VGND VPWR VPWR _06753_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_64_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11725_ _03763_ _03699_ _04023_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__a21oi_1
X_14444_ _06526_ _06465_ VGND VGND VPWR VPWR _06684_ sky130_fd_sc_hd__nand2_1
XFILLER_9_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11656_ net155 VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10607_ _02905_ _02853_ VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__nand2_1
X_14375_ _06613_ _06614_ VGND VGND VPWR VPWR _06615_ sky130_fd_sc_hd__nand2_1
X_11587_ _03713_ _03714_ _03703_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__a21oi_1
X_10538_ _02834_ _02760_ _02836_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__nand3_1
X_16114_ clknet_leaf_19_clk _00101_ _00362_ VGND VGND VPWR VPWR mul_res\[7\] sky130_fd_sc_hd__dfrtp_1
X_13326_ _05618_ _05624_ VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__xor2_1
XFILLER_6_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_16045_ clknet_leaf_11_clk _00057_ _00293_ VGND VGND VPWR VPWR add_res\[29\] sky130_fd_sc_hd__dfrtp_1
X_13257_ _05553_ _05554_ _05555_ VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__nand3_1
X_10469_ _02766_ _02767_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__nand2_1
XFILLER_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12208_ _04506_ _04457_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13188_ _05485_ _05486_ VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__nand2_1
X_12139_ _04396_ _04380_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__nand2_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15829_ net285 VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__inv_2
XFILLER_64_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09350_ _01263_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__inv_2
X_09281_ _01550_ _01579_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__nand2_1
X_08301_ _00548_ VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__inv_2
XFILLER_33_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08232_ _00530_ _07866_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__nand2_1
X_08163_ _00460_ _00461_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__nand2_1
XFILLER_109_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08094_ _07863_ _07864_ VGND VGND VPWR VPWR _07865_ sky130_fd_sc_hd__nand2_1
XFILLER_106_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08996_ _01291_ _01294_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__nand2_1
XFILLER_87_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07947_ _07608_ _07360_ VGND VGND VPWR VPWR _07617_ sky130_fd_sc_hd__nand2_1
XFILLER_18_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09617_ net215 net174 VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__nand2_1
XFILLER_71_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09548_ _01648_ _01650_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__nand2_1
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09479_ _01626_ _01624_ _01622_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__nand3b_1
XFILLER_70_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11510_ net195 net141 VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__nand2_1
XFILLER_24_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12490_ _04788_ _04717_ VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__nand2_1
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11441_ _03737_ _03739_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__nand2_1
X_14160_ _06401_ VGND VGND VPWR VPWR _06402_ sky130_fd_sc_hd__inv_2
XFILLER_50_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11372_ _03618_ _03644_ _03670_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__a21o_1
X_10323_ _02611_ _02587_ _02609_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__a21oi_1
X_13111_ _05408_ _05409_ VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__nand2_1
X_14091_ _06277_ adder_inst.sum_raw_r\[11\] _06232_ adder_inst.sum_raw_r\[12\] _06347_
+ VGND VGND VPWR VPWR _06348_ sky130_fd_sc_hd__a221o_1
XFILLER_3_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10254_ _02548_ _02550_ _02552_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__a21oi_1
X_13042_ _05338_ _05340_ VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_111_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10185_ _02482_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__inv_2
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14993_ _07236_ VGND VGND VPWR VPWR _07237_ sky130_fd_sc_hd__inv_2
Xfanout280 net286 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_4
XFILLER_47_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13944_ adder_inst.sum_raw_r\[1\] net253 _06067_ _06214_ VGND VGND VPWR VPWR _06215_
+ sky130_fd_sc_hd__a22o_1
XFILLER_74_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13875_ adder_inst.sum_raw_r\[17\] _06146_ _06149_ VGND VGND VPWR VPWR _06150_ sky130_fd_sc_hd__o21ai_1
XFILLER_74_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15614_ net278 VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__inv_2
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12826_ _04969_ _04971_ _04972_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__o21ba_1
XFILLER_15_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15545_ net303 VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__inv_2
XFILLER_70_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12757_ _05052_ _05053_ _05055_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__nand3_1
XFILLER_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15476_ _07693_ VGND VGND VPWR VPWR multiplier_inst.man_final\[22\] sky130_fd_sc_hd__clkbuf_1
X_11708_ _04002_ _04006_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__nand2_1
X_12688_ _04582_ _01670_ _04242_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__or3_1
X_14427_ _06663_ _03160_ _06568_ VGND VGND VPWR VPWR _06667_ sky130_fd_sc_hd__mux2_1
X_11639_ _03935_ VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__inv_2
X_14358_ _06445_ _06531_ _06597_ VGND VGND VPWR VPWR _06598_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_77_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13309_ _05594_ _05593_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__or2_1
X_14289_ _06527_ _06529_ VGND VGND VPWR VPWR _06530_ sky130_fd_sc_hd__nand2_1
X_16028_ clknet_leaf_19_clk _00039_ _00276_ VGND VGND VPWR VPWR add_res\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08850_ net145 net230 VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__nand2_1
XFILLER_111_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08781_ _01079_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__inv_2
XFILLER_38_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09402_ _01686_ _01687_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__nand2_1
XFILLER_53_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09333_ _01628_ _01630_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__nand2_1
XFILLER_52_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09264_ _01554_ _01561_ _01562_ VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_23_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08215_ _00459_ _07810_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__nand2_1
X_09195_ _00447_ _00451_ _00561_ VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08146_ _00443_ _00444_ _07886_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_99_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08077_ _07846_ _07847_ VGND VGND VPWR VPWR _07848_ sky130_fd_sc_hd__nand2_1
XFILLER_106_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold11 adder_inst.i_a\[5\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 adder_inst.i_a\[21\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 adder_inst.exp_b\[6\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 adder_inst.i_b\[8\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold33 adder_inst.i_a\[11\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
X_08979_ _01277_ _00931_ _00930_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__nand3_1
XFILLER_29_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold99 _07727_ VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 add_res\[25\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 add_res\[10\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 adder_inst.i_b\[22\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
X_11990_ _04288_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__inv_2
XFILLER_29_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10941_ _03237_ _03238_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_3_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13660_ _05900_ _05902_ _05952_ VGND VGND VPWR VPWR _05953_ sky130_fd_sc_hd__or3_1
XFILLER_71_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12611_ _04867_ _04908_ _04909_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__nand3_1
X_10872_ _03170_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__inv_2
XFILLER_16_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13591_ _05883_ net102 VGND VGND VPWR VPWR _05888_ sky130_fd_sc_hd__nand2_1
XFILLER_43_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15330_ _02853_ _02896_ _07554_ VGND VGND VPWR VPWR _07556_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_61_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12542_ _04815_ _04840_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__nand2_1
X_15261_ _07492_ multiplier_inst.man_final_r\[8\] _07494_ VGND VGND VPWR VPWR _07505_
+ sky130_fd_sc_hd__and3_1
XFILLER_61_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12473_ _04770_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__inv_2
X_14212_ _06452_ VGND VGND VPWR VPWR _06453_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_50_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11424_ _03721_ _03722_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__nand2_1
X_15192_ _07446_ _06671_ VGND VGND VPWR VPWR _07447_ sky130_fd_sc_hd__nand2_1
XANTENNA_8 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14143_ _06391_ VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__inv_2
X_11355_ _03584_ _03598_ _03653_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__a21oi_1
X_10306_ _02594_ _02591_ _02604_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__a21oi_1
XFILLER_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14074_ adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR _06333_ sky130_fd_sc_hd__inv_2
X_11286_ _01355_ _01353_ _01351_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__a21oi_2
X_10237_ _02530_ _02535_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__or2_1
XFILLER_106_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13025_ _05321_ _05323_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__nand2_1
XFILLER_94_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10168_ _02286_ _02466_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__or2_1
XFILLER_66_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10099_ _02387_ _02391_ _02396_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__a21o_1
XFILLER_86_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14976_ _07218_ VGND VGND VPWR VPWR _07219_ sky130_fd_sc_hd__inv_2
XFILLER_66_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13927_ _06083_ VGND VGND VPWR VPWR _06200_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_58_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13858_ _06109_ _06132_ VGND VGND VPWR VPWR _06133_ sky130_fd_sc_hd__or2b_1
X_13789_ adder_inst.sum_raw_r\[21\] net252 VGND VGND VPWR VPWR _06064_ sky130_fd_sc_hd__nor2_1
XFILLER_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12809_ _05102_ _05105_ _04999_ VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__nand3_1
X_15528_ _07724_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_83_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15459_ _07675_ _05828_ _05829_ VGND VGND VPWR VPWR _07680_ sky130_fd_sc_hd__nand3_1
X_08000_ _07770_ _07768_ VGND VGND VPWR VPWR _07771_ sky130_fd_sc_hd__nand2_1
X_09951_ _02237_ _02240_ _02249_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__nand3_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08902_ _01200_ _01196_ VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__nand2_1
XFILLER_97_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09882_ _02179_ _02180_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__nand2_1
XFILLER_112_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08833_ _01125_ _01128_ _01131_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__nand3b_1
X_08764_ _01058_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__inv_2
XFILLER_85_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08695_ _00795_ _00770_ _00791_ VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__nand3_1
XFILLER_41_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09316_ _01613_ _01165_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__nand2_1
X_09247_ _01142_ _01232_ _01139_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09178_ _01442_ _01474_ _01444_ VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__nand3_1
X_08129_ net132 net224 VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__nand2_1
X_11140_ _03276_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__inv_2
Xoutput89 net89 VGND VGND VPWR VPWR o_res[29] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR o_res[19] sky130_fd_sc_hd__buf_2
X_11071_ _03368_ _03369_ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10022_ _02041_ _02044_ _02043_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__a21o_1
X_14830_ _06933_ _07065_ VGND VGND VPWR VPWR _07067_ sky130_fd_sc_hd__or2_1
XFILLER_76_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14761_ _06800_ _06797_ VGND VGND VPWR VPWR _07001_ sky130_fd_sc_hd__nor2_1
XFILLER_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11973_ net128 net198 VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14692_ _06926_ _06931_ VGND VGND VPWR VPWR _06932_ sky130_fd_sc_hd__nand2_1
X_13712_ _06000_ VGND VGND VPWR VPWR multiplier_inst.sign_res sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_55_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10924_ _03218_ _03221_ _03222_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__nand3b_1
X_13643_ _05931_ _05937_ VGND VGND VPWR VPWR _05938_ sky130_fd_sc_hd__nand2_1
XFILLER_71_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10855_ _03044_ _03153_ _03042_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13574_ _05870_ _05867_ VGND VGND VPWR VPWR _05871_ sky130_fd_sc_hd__nand2_1
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15313_ _07535_ _02449_ VGND VGND VPWR VPWR _07537_ sky130_fd_sc_hd__nand2_1
X_12525_ _04756_ _04752_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__nand2_1
X_10786_ _03057_ _03059_ _03084_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__nand3_1
X_15244_ _07493_ VGND VGND VPWR VPWR _07494_ sky130_fd_sc_hd__clkbuf_2
X_12456_ _04752_ _04754_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__nand2_1
X_15175_ _07409_ _06642_ VGND VGND VPWR VPWR _07429_ sky130_fd_sc_hd__nand2_1
X_11407_ _03343_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__inv_2
X_12387_ net192 net128 VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__nand2_1
X_14126_ _06229_ _06379_ _06181_ VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__nor3_1
X_11338_ _03628_ _03636_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__nand2_1
X_14057_ _06183_ _06190_ _06317_ VGND VGND VPWR VPWR _06318_ sky130_fd_sc_hd__and3_1
XFILLER_79_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11269_ _03566_ _03567_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__nand2_1
XFILLER_97_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13008_ _05161_ VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__inv_2
XFILLER_94_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14959_ _07199_ _06726_ _06830_ VGND VGND VPWR VPWR _07200_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08480_ _00778_ _00774_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__nand2_1
XFILLER_35_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09101_ _01399_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_33_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09032_ _01328_ _01330_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_96_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09934_ _02232_ _02229_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__nand2_1
X_09865_ _02163_ _02012_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__nand2_1
XFILLER_58_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08816_ _01113_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__inv_2
X_09796_ _02093_ _02094_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__nor2b_1
XFILLER_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08747_ _00873_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__inv_2
XFILLER_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08678_ net218 net153 VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__nand2_1
XFILLER_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10640_ _02913_ _02884_ _02877_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__nand3_1
XFILLER_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10571_ _02868_ _02869_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__nand2_1
X_13290_ _05531_ _05560_ _05533_ VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__a21bo_1
XFILLER_42_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12310_ _04608_ VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__inv_2
X_12241_ _04539_ _04358_ _04361_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__nand3_1
X_12172_ _04451_ _04470_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__nand2_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11123_ _03421_ _03077_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__nand2_1
XFILLER_107_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15931_ clknet_leaf_9_clk adder_inst.sum_raw\[6\] _00179_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[6\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_95_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11054_ _03285_ _03282_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__nand2_1
X_10005_ _02301_ _02295_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__nand2_1
XFILLER_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15862_ clknet_leaf_5_clk net23 _00110_ VGND VGND VPWR VPWR adder_inst.i_a\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_108_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14813_ _06903_ _06894_ VGND VGND VPWR VPWR _07050_ sky130_fd_sc_hd__nand2_1
X_15793_ net281 VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__inv_2
XFILLER_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14744_ _06975_ _06976_ VGND VGND VPWR VPWR _06984_ sky130_fd_sc_hd__nand2_1
X_11956_ _04251_ _04252_ _04101_ VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__nand3_1
XFILLER_72_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10907_ _03107_ _03101_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__nor2_1
XFILLER_32_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14675_ _06727_ _06728_ _06516_ VGND VGND VPWR VPWR _06915_ sky130_fd_sc_hd__nand3_1
XFILLER_44_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11887_ _03948_ _03940_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__nand2_1
XFILLER_32_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13626_ _05919_ _05920_ VGND VGND VPWR VPWR _05921_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_80_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10838_ _03136_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__inv_2
XFILLER_13_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13557_ _05853_ adder_inst.exp_b_r\[3\] VGND VGND VPWR VPWR _05854_ sky130_fd_sc_hd__nand2_1
X_10769_ _03060_ _03067_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_30_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13488_ _05778_ _05786_ VGND VGND VPWR VPWR _05787_ sky130_fd_sc_hd__nor2_1
X_12508_ _04803_ _04806_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__or2_1
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15227_ adder_inst.exp_a_r\[1\] adder_inst.exp_b_r\[1\] _06563_ VGND VGND VPWR VPWR
+ _07482_ sky130_fd_sc_hd__mux2_1
X_12439_ _04737_ _04725_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__nand2_1
XFILLER_9_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15158_ _07409_ _07386_ VGND VGND VPWR VPWR _07411_ sky130_fd_sc_hd__nand2_1
XFILLER_113_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14109_ _06295_ _06062_ VGND VGND VPWR VPWR _06364_ sky130_fd_sc_hd__nor2_1
X_15089_ _07009_ _06593_ _06592_ VGND VGND VPWR VPWR _07337_ sky130_fd_sc_hd__o21a_1
Xfanout109 net110 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_2
X_07980_ net200 net152 VGND VGND VPWR VPWR _07751_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09650_ _01907_ _01921_ _01919_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__nand3_1
XFILLER_79_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08601_ _00839_ _00841_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__nand2_1
X_09581_ _01719_ _01724_ _01722_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_38_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08532_ _00827_ _00830_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__nand2_1
XFILLER_51_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08463_ _00756_ _00759_ _00761_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__o21ai_1
XFILLER_35_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08394_ _00692_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__inv_2
XFILLER_10_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09015_ _07233_ _07296_ _07201_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__a21oi_1
XFILLER_104_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09917_ _02213_ _02215_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__nand2_1
XFILLER_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09848_ _02018_ _02001_ VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__nand2_1
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09779_ _02077_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__inv_2
XFILLER_85_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11810_ _04002_ _04004_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__nand2_1
X_12790_ _05075_ _05077_ _05086_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__nand3_1
X_11741_ _04038_ _04039_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__nand2_1
XFILLER_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14460_ _06472_ VGND VGND VPWR VPWR _06700_ sky130_fd_sc_hd__buf_2
XFILLER_53_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11672_ _03811_ _03968_ _03970_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__o21ai_1
X_10623_ _02921_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__inv_2
X_14391_ _06487_ _06544_ VGND VGND VPWR VPWR _06631_ sky130_fd_sc_hd__nor2_1
X_13411_ _05709_ _01299_ _01300_ VGND VGND VPWR VPWR _05710_ sky130_fd_sc_hd__a21bo_1
X_16130_ clknet_leaf_13_clk _00087_ _00378_ VGND VGND VPWR VPWR mul_res\[23\] sky130_fd_sc_hd__dfrtp_1
X_10554_ _02799_ _02774_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_21_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
X_13342_ _05633_ _05640_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__nand2_1
XFILLER_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16061_ clknet_leaf_11_clk net356 _00309_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_10485_ _02783_ _02709_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__nand2_1
X_13273_ _05553_ _05554_ _05555_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__a21o_1
X_15012_ _07247_ _07256_ VGND VGND VPWR VPWR _07257_ sky130_fd_sc_hd__nand2_1
X_12224_ _04480_ _04477_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_114_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12155_ _04452_ _04391_ _04453_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__a21o_1
XFILLER_78_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11106_ _03403_ _03404_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__nand2_1
XFILLER_96_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12086_ _01396_ _01394_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__nor2_1
XFILLER_76_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15914_ clknet_leaf_0_clk net47 _00162_ VGND VGND VPWR VPWR adder_inst.i_b\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_11037_ _03276_ _03270_ _03267_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__a21boi_1
XFILLER_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15845_ net299 VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__inv_2
XFILLER_92_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15776_ net282 VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__inv_2
X_12988_ _05284_ _05286_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__nand2_1
X_14727_ _06965_ _06966_ VGND VGND VPWR VPWR _06967_ sky130_fd_sc_hd__nand2_1
XFILLER_72_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11939_ _04236_ _04237_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__nand2_1
XFILLER_17_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14658_ _06554_ _01448_ VGND VGND VPWR VPWR _06898_ sky130_fd_sc_hd__nand2_1
XFILLER_60_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13609_ _05901_ _05903_ VGND VGND VPWR VPWR _05904_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_43_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
X_14589_ _06828_ _06724_ VGND VGND VPWR VPWR _06829_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07963_ _07732_ _07444_ VGND VGND VPWR VPWR _07734_ sky130_fd_sc_hd__nand2_1
X_07894_ _07086_ adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR _07097_ sky130_fd_sc_hd__nand2_1
X_09702_ _01894_ _02000_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__nand2_1
X_09633_ _01931_ _01751_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__nand2_1
XFILLER_68_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09564_ _01861_ _01862_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__nand2_1
XFILLER_70_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08515_ _00680_ _00676_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__nand2_1
X_09495_ _01792_ _01793_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__nand2_1
X_08446_ _00744_ _00474_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__nand2_1
X_08377_ _00674_ _00675_ VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__nand2_1
XFILLER_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10270_ adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__inv_2
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13960_ net249 _06227_ _06228_ _06076_ _06229_ VGND VGND VPWR VPWR _06230_ sky130_fd_sc_hd__a221o_1
XFILLER_86_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12911_ _05207_ _05132_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__nor2_1
X_13891_ _06165_ _06126_ _06131_ VGND VGND VPWR VPWR _06166_ sky130_fd_sc_hd__o21ai_1
X_15630_ net289 VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__inv_2
XFILLER_73_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12842_ _05139_ _05140_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__nand2_1
X_15561_ net265 VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__inv_2
XFILLER_64_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12773_ _05067_ _05071_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__or2_1
X_15492_ _07703_ VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__clkbuf_1
X_14512_ _06660_ net136 VGND VGND VPWR VPWR _06752_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11724_ _03762_ _03761_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__nor2_1
X_14443_ _06466_ _06681_ _06462_ _06682_ VGND VGND VPWR VPWR _06683_ sky130_fd_sc_hd__o211ai_1
X_11655_ _03127_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_12_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10606_ _02896_ _02854_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__nand2_1
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14374_ _06582_ _06446_ VGND VGND VPWR VPWR _06614_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_40_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11586_ _03833_ _03825_ VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_116_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10537_ _02835_ _02758_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__nand2_1
X_16113_ clknet_leaf_18_clk _00100_ _00361_ VGND VGND VPWR VPWR mul_res\[6\] sky130_fd_sc_hd__dfrtp_1
X_13325_ _05619_ _05617_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__nand2b_1
X_16044_ clknet_leaf_12_clk _00056_ _00292_ VGND VGND VPWR VPWR add_res\[28\] sky130_fd_sc_hd__dfrtp_1
XFILLER_115_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10468_ _02759_ _02751_ _02746_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__a21boi_1
X_13256_ _05547_ _05545_ VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__nand2_1
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12207_ _04467_ _04468_ _04462_ VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__a21o_1
X_10399_ _02691_ _02695_ _02694_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_75_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13187_ _05484_ _05458_ VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__nand2_1
XFILLER_111_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12138_ _04423_ _04400_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__nand2_1
XFILLER_2_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
X_12069_ _01489_ _04367_ _01416_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__o21ai_1
XFILLER_65_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15828_ net283 VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_48_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15759_ net300 VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__inv_2
X_09280_ _01563_ _01574_ _01578_ VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__a21boi_1
X_08300_ _00598_ _00592_ VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__nand2_1
X_08231_ _07870_ _00529_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__nor2_1
X_08162_ _07808_ _07806_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__nand2_1
XFILLER_118_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08093_ net146 net214 VGND VGND VPWR VPWR _07864_ sky130_fd_sc_hd__nand2_1
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_10_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08995_ _01103_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__inv_2
XFILLER_102_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07946_ _07599_ _07338_ VGND VGND VPWR VPWR _07608_ sky130_fd_sc_hd__nand2_1
XFILLER_28_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09616_ _01914_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__inv_2
XFILLER_71_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09547_ _01815_ _01841_ _01845_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__a21oi_1
XFILLER_70_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09478_ _01774_ _01776_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__nand2_1
XFILLER_11_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08429_ _00726_ _00727_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__nand2_1
XFILLER_11_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload0 clknet_1_0__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_2
X_11440_ _03733_ _03738_ _03734_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__nand3_1
XFILLER_50_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11371_ _03617_ _03615_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__nor2_1
XFILLER_109_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10322_ _02619_ _02380_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__nand2_1
X_14090_ _06231_ _06346_ VGND VGND VPWR VPWR _06347_ sky130_fd_sc_hd__nand2_1
X_13110_ _05407_ _05400_ VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__nand2_1
X_13041_ _05339_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__inv_2
X_10253_ _02471_ _02551_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__nor2_1
XFILLER_105_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10184_ _02481_ _02482_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__nand2_1
XFILLER_105_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout292 net295 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_2
Xfanout270 net279 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__buf_2
Xfanout281 net286 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__clkbuf_4
X_14992_ _06739_ _06734_ VGND VGND VPWR VPWR _07236_ sky130_fd_sc_hd__nand2_1
XFILLER_47_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13943_ net253 _06196_ VGND VGND VPWR VPWR _06214_ sky130_fd_sc_hd__nor2_1
XFILLER_75_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13874_ _06104_ _06106_ _06107_ VGND VGND VPWR VPWR _06149_ sky130_fd_sc_hd__o21ai_1
XFILLER_47_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15613_ net289 VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__inv_2
XFILLER_74_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12825_ _05122_ _05123_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__nand2_1
X_15544_ net303 VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__inv_2
XFILLER_91_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12756_ _04984_ _05054_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__xor2_1
X_15475_ _05838_ _05837_ VGND VGND VPWR VPWR _07693_ sky130_fd_sc_hd__or2_1
X_11707_ _04003_ _04005_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__nand2_1
X_12687_ _04985_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__inv_2
X_14426_ _06665_ VGND VGND VPWR VPWR _06666_ sky130_fd_sc_hd__inv_2
X_11638_ _03905_ _03908_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__nand2_1
X_14357_ _06542_ _06445_ VGND VGND VPWR VPWR _06597_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13308_ _05600_ _05602_ VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__xnor2_1
XFILLER_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11569_ _03867_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__inv_2
XFILLER_115_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14288_ _04882_ _04241_ _06440_ VGND VGND VPWR VPWR _06529_ sky130_fd_sc_hd__mux2_1
XFILLER_6_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_16027_ clknet_leaf_16_clk _00038_ _00275_ VGND VGND VPWR VPWR add_res\[11\] sky130_fd_sc_hd__dfrtp_1
X_13239_ _05537_ _05529_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__nand2_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08780_ _01078_ _01077_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__nand2_1
XFILLER_111_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09401_ _01536_ _01699_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__nand2_1
XFILLER_53_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09332_ _01627_ _01628_ _01630_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__nand3b_1
XFILLER_52_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09263_ _01552_ _01225_ _01224_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__nand3_1
XFILLER_60_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09194_ _01491_ _01492_ VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__nand2_1
XFILLER_21_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08214_ _00507_ _00512_ VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__nand2_1
XFILLER_107_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08145_ _00435_ _00436_ _00438_ VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_99_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08076_ _07745_ _07746_ _07777_ VGND VGND VPWR VPWR _07847_ sky130_fd_sc_hd__nand3_1
XFILLER_20_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 adder_inst.i_b\[7\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold12 adder_inst.i_a\[10\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 adder_inst.exp_a\[4\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 adder_inst.i_b\[4\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 adder_inst.i_b\[12\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08978_ _01030_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__inv_2
XFILLER_29_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold78 adder_inst.is_zero_a_r VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 multiplier_inst.exp_final_r\[0\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 _07725_ VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
X_07929_ net197 net158 VGND VGND VPWR VPWR _07465_ sky130_fd_sc_hd__nand2_1
XFILLER_56_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10940_ _03216_ _03237_ _03238_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__nand3_1
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12610_ _04866_ _04864_ _04865_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__nand3b_1
X_10871_ _03169_ _03122_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__nand2_1
X_13590_ net102 _05883_ VGND VGND VPWR VPWR _05887_ sky130_fd_sc_hd__or2_1
XFILLER_31_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12541_ _04839_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__inv_2
X_15260_ _07503_ VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__clkbuf_1
X_12472_ _04749_ _04770_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__nand2_1
XFILLER_12_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14211_ _06439_ _05651_ VGND VGND VPWR VPWR _06452_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11423_ _03719_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__inv_2
X_15191_ _07443_ _07445_ VGND VGND VPWR VPWR _07446_ sky130_fd_sc_hd__nand2_1
XANTENNA_9 net188 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14142_ _06186_ net103 _06144_ _00068_ VGND VGND VPWR VPWR _06391_ sky130_fd_sc_hd__a31oi_2
X_11354_ _03583_ _03582_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__nor2_1
X_10305_ _02593_ _02592_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__nor2_1
X_14073_ _06329_ _06330_ _06331_ VGND VGND VPWR VPWR _06332_ sky130_fd_sc_hd__a21oi_1
XFILLER_79_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11285_ _03582_ _03583_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__nand2_1
X_10236_ _02533_ _02534_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__nand2_1
X_13024_ _05322_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_72_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10167_ net228 net174 VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__nand2_1
XFILLER_94_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10098_ _02387_ _02391_ _02396_ VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__nand3_1
X_14975_ _07214_ _07217_ VGND VGND VPWR VPWR _07218_ sky130_fd_sc_hd__nand2_1
XFILLER_66_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13926_ _06199_ VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_19_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13857_ _06045_ _06101_ VGND VGND VPWR VPWR _06132_ sky130_fd_sc_hd__nand2_1
X_13788_ adder_inst.sum_raw_r\[8\] adder_inst.sum_raw_r\[11\] adder_inst.sum_raw_r\[16\]
+ _06062_ VGND VGND VPWR VPWR _06063_ sky130_fd_sc_hd__or4_1
XFILLER_62_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12808_ _05103_ _05106_ VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__nand2_1
X_15527_ add_res\[24\] net419 net261 VGND VGND VPWR VPWR _07724_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_83_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12739_ _05034_ _05033_ _05029_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__a21boi_1
X_15458_ _07604_ _07678_ _07679_ VGND VGND VPWR VPWR multiplier_inst.man_final\[16\]
+ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_20_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14409_ _06647_ _06646_ VGND VGND VPWR VPWR _06649_ sky130_fd_sc_hd__or2b_1
XFILLER_30_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15389_ _07610_ _07614_ VGND VGND VPWR VPWR _07616_ sky130_fd_sc_hd__nand2_1
XFILLER_7_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09950_ _02247_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__inv_2
XFILLER_89_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08901_ _01198_ _01199_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__nand2_1
XFILLER_97_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09881_ _02171_ _01855_ _01860_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__nand3_1
XFILLER_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08832_ _01129_ _01130_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__nand2_1
X_08763_ _01060_ _00872_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__nand2_1
XFILLER_38_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08694_ _00992_ _00792_ VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__nand2_1
XFILLER_80_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09315_ _01610_ _01165_ _01613_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__nand3_1
XFILLER_40_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09246_ _01239_ _01231_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__nand2_1
XFILLER_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09177_ _01445_ _01475_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__nand2_1
XFILLER_119_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08128_ _00425_ _00426_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__nand2_1
X_08059_ _07829_ VGND VGND VPWR VPWR _07830_ sky130_fd_sc_hd__inv_2
X_11070_ _03367_ _03363_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__nand2_1
X_10021_ _02314_ _02319_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__nand2_1
Xoutput79 net79 VGND VGND VPWR VPWR o_res[1] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR o_res[0] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14760_ _06993_ _06999_ VGND VGND VPWR VPWR _07000_ sky130_fd_sc_hd__nand2_2
X_13711_ _05999_ VGND VGND VPWR VPWR _06000_ sky130_fd_sc_hd__clkbuf_4
X_11972_ net123 net205 VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__nand2_1
XFILLER_17_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14691_ _06930_ _06922_ VGND VGND VPWR VPWR _06931_ sky130_fd_sc_hd__nand2_1
XFILLER_71_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10923_ _03090_ _03219_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13642_ _05837_ _05838_ _05936_ VGND VGND VPWR VPWR _05937_ sky130_fd_sc_hd__nand3_1
XFILLER_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10854_ _03040_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__inv_2
XFILLER_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13573_ _07149_ _05869_ VGND VGND VPWR VPWR _05870_ sky130_fd_sc_hd__or2_1
XFILLER_31_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15312_ _02449_ _07535_ VGND VGND VPWR VPWR _07536_ sky130_fd_sc_hd__or2_1
X_12524_ _04821_ _04819_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__or2_1
XFILLER_40_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10785_ _03083_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__inv_2
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15243_ multiplier_inst.overflow_calc_r multiplier_inst.is_zero_r VGND VGND VPWR
+ VPWR _07493_ sky130_fd_sc_hd__nor2_2
X_12455_ _00623_ _04241_ _04753_ VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__o21ai_1
X_15174_ _07427_ _07141_ VGND VGND VPWR VPWR _07428_ sky130_fd_sc_hd__nand2_1
X_11406_ net123 net216 VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__nand2_1
X_12386_ net125 net195 VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__nand2_1
X_14125_ _06194_ _06044_ _06049_ _06195_ _06378_ VGND VGND VPWR VPWR _06379_ sky130_fd_sc_hd__o221a_1
XFILLER_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11337_ _03635_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__inv_2
X_14056_ _06184_ _06314_ _06316_ VGND VGND VPWR VPWR _06317_ sky130_fd_sc_hd__o21ai_1
X_11268_ _03557_ _03561_ _03558_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__nand3_1
X_10219_ _02517_ _02502_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__nand2_1
X_11199_ _03495_ _03497_ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__nand2_1
X_13007_ _05304_ _05305_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__nand2_1
XFILLER_94_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14958_ _06801_ _06818_ _06817_ VGND VGND VPWR VPWR _07199_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13909_ _06042_ VGND VGND VPWR VPWR _06184_ sky130_fd_sc_hd__buf_2
X_14889_ _06962_ _06959_ VGND VGND VPWR VPWR _07127_ sky130_fd_sc_hd__nand2_1
XFILLER_23_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09100_ _00436_ _00426_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_33_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09031_ _01329_ _01315_ _01317_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__nand3_1
XFILLER_30_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_96_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09933_ _02230_ _02065_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__nand2_1
XFILLER_85_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09864_ _02156_ _02162_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08815_ _01112_ _01113_ VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__nand2_1
X_09795_ _02092_ _02034_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08746_ _00865_ _00874_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__nand2_1
XFILLER_26_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08677_ net150 net221 VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__nand2_1
XFILLER_38_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10570_ _02867_ _02865_ VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09229_ _01524_ _01527_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__nand2_1
XFILLER_21_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12240_ _04537_ _04538_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__nand2_1
XFILLER_107_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12171_ _04466_ _04469_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__nand2_1
XFILLER_1_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11122_ _03071_ _03076_ _03073_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__a21o_1
XFILLER_110_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15930_ clknet_leaf_8_clk adder_inst.sum_raw\[5\] _00178_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[5\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11053_ _03349_ _03346_ _03347_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__nand3_1
X_15861_ clknet_leaf_5_clk net12 _00109_ VGND VGND VPWR VPWR adder_inst.i_a\[1\] sky130_fd_sc_hd__dfrtp_1
X_10004_ _02281_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__inv_2
XFILLER_76_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14812_ _07048_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07049_ sky130_fd_sc_hd__nand2_1
XFILLER_76_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15792_ net303 VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__inv_2
XFILLER_64_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14743_ _06980_ _06982_ VGND VGND VPWR VPWR _06983_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_48_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11955_ _04253_ _04102_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__nand2_1
XFILLER_17_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14674_ _06714_ _06632_ VGND VGND VPWR VPWR _06914_ sky130_fd_sc_hd__or2_1
X_10906_ _03101_ _03107_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__nand2_1
XFILLER_17_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13625_ _05918_ _05908_ VGND VGND VPWR VPWR _05920_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_67_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11886_ _04181_ _04184_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10837_ _03133_ _03135_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__nand2_1
X_13556_ adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR _05853_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_80_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10768_ _03063_ _03066_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13487_ _05779_ _05785_ VGND VGND VPWR VPWR _05786_ sky130_fd_sc_hd__nand2_1
X_12507_ _04804_ _04805_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__nand2_1
XFILLER_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15226_ _07481_ _06657_ _07141_ VGND VGND VPWR VPWR adder_inst.sum_raw\[24\] sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_57_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12438_ _04735_ _04736_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__nand2_1
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10699_ _02990_ _02997_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_10_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15157_ _07386_ _07409_ VGND VGND VPWR VPWR _07410_ sky130_fd_sc_hd__or2_1
X_12369_ _04665_ _04667_ VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__nand2b_1
XFILLER_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14108_ _06363_ VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__clkbuf_1
X_15088_ _07301_ _07011_ VGND VGND VPWR VPWR _07336_ sky130_fd_sc_hd__nand2_1
XFILLER_4_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14039_ _06277_ adder_inst.sum_raw_r\[6\] _06232_ adder_inst.sum_raw_r\[7\] _06300_
+ VGND VGND VPWR VPWR _06301_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_91_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08600_ _00897_ _00898_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__nand2_1
XFILLER_28_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09580_ _01875_ _01878_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08531_ _00828_ _00817_ _00829_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__nand3_1
XFILLER_63_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08462_ _00760_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__inv_2
XFILLER_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08393_ _00671_ _00681_ _00610_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__nand3_1
XFILLER_109_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09014_ _01310_ _01312_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__nand2_1
XFILLER_117_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09916_ _02214_ _02191_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__nand2_1
XFILLER_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09847_ _02145_ _02142_ VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__nand2_1
XFILLER_19_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09778_ _02074_ _02076_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__nand2_1
XFILLER_39_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08729_ _01024_ _01027_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__nand2_1
X_11740_ _04020_ _04021_ _04036_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__nand3_1
XFILLER_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11671_ _03810_ _03969_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__nand2_1
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10622_ _02920_ net172 net243 VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__and3_1
X_14390_ _06628_ _06629_ VGND VGND VPWR VPWR _06630_ sky130_fd_sc_hd__nand2_1
X_13410_ _05708_ _02459_ _01874_ VGND VGND VPWR VPWR _05709_ sky130_fd_sc_hd__a21o_1
XFILLER_53_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10553_ _02797_ _02851_ VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__nand2_1
X_13341_ _05638_ _05639_ VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__and2_1
XFILLER_10_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16060_ clknet_leaf_7_clk net358 _00308_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10484_ _02713_ _02711_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__nand2_1
X_15011_ _07255_ _07173_ VGND VGND VPWR VPWR _07256_ sky130_fd_sc_hd__nand2_1
X_13272_ _05568_ _05569_ _05570_ VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12223_ _04521_ VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__inv_2
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12154_ _04388_ _04384_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__nor2_1
XFILLER_96_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11105_ _03393_ _03396_ _03339_ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__nand3_1
XFILLER_77_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12085_ _04383_ _03643_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__nand2_1
X_15913_ clknet_leaf_25_clk net46 _00161_ VGND VGND VPWR VPWR adder_inst.i_b\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_11036_ _03296_ _03293_ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__nand2_1
X_15844_ net299 VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__inv_2
XFILLER_77_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_69_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15775_ net287 VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__inv_2
XFILLER_91_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14726_ _06551_ _02505_ VGND VGND VPWR VPWR _06966_ sky130_fd_sc_hd__nand2_1
XFILLER_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12987_ _05285_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__inv_2
XFILLER_91_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11938_ _04234_ _04230_ _04232_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__nand3_1
XFILLER_17_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14657_ _06895_ _06896_ _06802_ VGND VGND VPWR VPWR _06897_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_15_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11869_ _04165_ _04162_ _04163_ VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__nand3_1
X_13608_ adder_inst.exp_b_r\[5\] _05902_ VGND VGND VPWR VPWR _05903_ sky130_fd_sc_hd__nor2_1
X_14588_ _06693_ VGND VGND VPWR VPWR _06828_ sky130_fd_sc_hd__inv_2
XFILLER_60_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13539_ _05664_ _05667_ VGND VGND VPWR VPWR _05838_ sky130_fd_sc_hd__nand2_4
XFILLER_13_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15209_ _07463_ VGND VGND VPWR VPWR _07464_ sky130_fd_sc_hd__inv_2
XFILLER_114_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09701_ _01999_ _01963_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__nand2_1
XFILLER_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07962_ net197 net161 VGND VGND VPWR VPWR _07732_ sky130_fd_sc_hd__nand2_1
X_07893_ adder_inst.exp_a_r\[1\] VGND VGND VPWR VPWR _07086_ sky130_fd_sc_hd__inv_2
XFILLER_83_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09632_ _01930_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__inv_2
XFILLER_67_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09563_ _01849_ _01651_ _01679_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__nand3_1
XFILLER_55_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08514_ _00800_ _00802_ _00810_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__nand3_1
XFILLER_24_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09494_ _01669_ _01671_ _01667_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__a21o_1
X_08445_ _00743_ _00472_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_83_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08376_ net138 net226 VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__nand2_1
XFILLER_109_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_92_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13890_ adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR _06165_ sky130_fd_sc_hd__inv_2
XFILLER_74_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12910_ _05202_ _05195_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__nand2_1
XFILLER_19_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12841_ _05055_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__inv_2
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15560_ net262 VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__inv_2
XFILLER_64_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12772_ _05068_ _05070_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__nand2_1
X_15491_ add_res\[6\] mul_res\[6\] net258 VGND VGND VPWR VPWR _07703_ sky130_fd_sc_hd__mux2_1
X_14511_ _06750_ VGND VGND VPWR VPWR _06751_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_64_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11723_ _04020_ _04021_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__nand2_1
X_14442_ _06447_ _06495_ VGND VGND VPWR VPWR _06682_ sky130_fd_sc_hd__or2_1
X_11654_ _03774_ _03952_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__or2_1
XFILLER_14_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10605_ _02853_ _02854_ _02896_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__nand3b_1
XFILLER_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16112_ clknet_leaf_18_clk _00099_ _00360_ VGND VGND VPWR VPWR mul_res\[5\] sky130_fd_sc_hd__dfrtp_1
X_14373_ _06574_ _06445_ VGND VGND VPWR VPWR _06613_ sky130_fd_sc_hd__nand2_1
X_11585_ _03883_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10536_ _02746_ _02751_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__nand2_1
X_13324_ _05621_ _05622_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__nand2_1
XFILLER_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16043_ clknet_leaf_13_clk _00055_ _00291_ VGND VGND VPWR VPWR add_res\[27\] sky130_fd_sc_hd__dfrtp_1
X_10467_ _02764_ _02762_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13255_ _05552_ _05540_ _05525_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__nand3b_1
X_12206_ _04502_ _04504_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__nand2_1
XFILLER_111_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10398_ _02654_ _02696_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13186_ _05484_ _05458_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__or2_1
X_12137_ _04430_ _04421_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__nand2_1
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12068_ _01415_ _01412_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__nor2_1
XFILLER_49_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11019_ _03317_ _03312_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__nand2_1
XFILLER_92_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15827_ net285 VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__inv_2
XFILLER_65_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15758_ net293 VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__inv_2
XFILLER_52_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14709_ _06948_ VGND VGND VPWR VPWR _06949_ sky130_fd_sc_hd__inv_2
X_15689_ net268 VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__inv_2
XFILLER_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08230_ _07865_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__inv_2
XFILLER_33_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08161_ _07801_ _07804_ _07805_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__o21ai_1
XFILLER_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08092_ net143 net218 VGND VGND VPWR VPWR _07863_ sky130_fd_sc_hd__nand2_1
XFILLER_109_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08994_ _01292_ _01103_ VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__nand2_1
X_07945_ _07577_ _07588_ VGND VGND VPWR VPWR _07599_ sky130_fd_sc_hd__nand2_1
XFILLER_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09615_ net219 net167 VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__nand2_1
XFILLER_83_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09546_ _01805_ _01844_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__nor2_1
XFILLER_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09477_ _01775_ _01634_ _01770_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__nand3_1
X_08428_ _00721_ _00722_ _00719_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__nand3_1
XFILLER_24_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload1 clknet_leaf_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__bufinv_16
XFILLER_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08359_ _00656_ _00657_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__nand2_1
XFILLER_7_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11370_ _03666_ _03668_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__nand2_1
XFILLER_119_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10321_ _02616_ _02380_ _02619_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__nand3_1
X_13040_ _05310_ _05304_ VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__nand2_1
X_10252_ net230 net174 VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__nand2_1
XFILLER_3_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10183_ net160 net236 VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__nand2_1
XFILLER_78_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14991_ _07234_ _07141_ VGND VGND VPWR VPWR _07235_ sky130_fd_sc_hd__nand2_1
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_4
Xfanout260 net261 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_4
X_13942_ _06213_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__clkbuf_1
Xfanout282 net286 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__buf_4
XFILLER_47_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout293 net294 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_4
X_13873_ _06092_ _06045_ VGND VGND VPWR VPWR _06148_ sky130_fd_sc_hd__or2_1
XFILLER_47_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15612_ net289 VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__inv_2
XFILLER_62_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12824_ _05121_ _05113_ _05065_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__nand3b_1
X_15543_ net303 VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__inv_2
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12755_ _04987_ _04985_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__nand2_1
XFILLER_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11706_ _04004_ _03965_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__nand2_1
XFILLER_30_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15474_ _07690_ _05668_ _05837_ VGND VGND VPWR VPWR multiplier_inst.man_final\[21\]
+ sky130_fd_sc_hd__a21oi_1
X_12686_ _04239_ _01670_ _04699_ VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_25_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14425_ _06660_ _06663_ _06664_ VGND VGND VPWR VPWR _06665_ sky130_fd_sc_hd__o21a_1
X_11637_ _03905_ _03908_ _03935_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__nand3_1
X_14356_ _06595_ _06487_ VGND VGND VPWR VPWR _06596_ sky130_fd_sc_hd__nand2_1
X_11568_ _03564_ _03550_ _03545_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a21boi_1
X_10519_ _02814_ _02817_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13307_ _05604_ _05605_ VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__or2b_1
XFILLER_115_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16026_ clknet_leaf_16_clk _00037_ _00274_ VGND VGND VPWR VPWR add_res\[10\] sky130_fd_sc_hd__dfrtp_1
X_14287_ net117 net190 _06491_ VGND VGND VPWR VPWR _06528_ sky130_fd_sc_hd__mux2_1
X_11499_ _03796_ _03797_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__nand2_1
X_13238_ _05535_ _05536_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__nand2_1
X_13169_ _05467_ _05414_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__nor2_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09400_ _01698_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__inv_2
XFILLER_18_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09331_ _01629_ _01152_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__nand2_1
XFILLER_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09262_ _01556_ _01558_ _01560_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08213_ _00509_ _00510_ _00511_ VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__nand3_1
X_09193_ _01416_ _01489_ _01417_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__nand3_1
X_08144_ _00437_ _00440_ VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__nand2_1
XFILLER_119_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08075_ _07747_ _07781_ VGND VGND VPWR VPWR _07846_ sky130_fd_sc_hd__nand2_1
XFILLER_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold13 adder_inst.i_a\[17\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold46 adder_inst.exp_b\[1\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 adder_inst.exp_b\[5\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 adder_inst.i_a\[3\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08977_ _01202_ _01272_ _01275_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__a21boi_1
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold68 multiplier_inst.exp_final_r\[7\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 adder_inst.exp_a\[1\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 mul_res\[16\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
X_07928_ net191 net161 VGND VGND VPWR VPWR _07455_ sky130_fd_sc_hd__nand2_1
XFILLER_28_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_634 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10870_ _03121_ _03167_ _03168_ VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__nand3b_1
X_09529_ net139 net246 VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__nand2_1
XFILLER_12_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12540_ _04837_ _04838_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__nand2_1
XFILLER_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12471_ _04768_ _04769_ VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__nand2_1
X_15190_ _06675_ _06648_ VGND VGND VPWR VPWR _07445_ sky130_fd_sc_hd__nand2_1
X_14210_ _06450_ VGND VGND VPWR VPWR _06451_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_50_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11422_ _03716_ _03717_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__nand2_1
X_14141_ _06390_ VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__inv_2
X_11353_ _03651_ _03529_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__nand2_1
X_10304_ _02602_ _02598_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__nand2_1
X_14072_ adder_inst.sum_raw_r\[15\] net251 _06200_ adder_inst.sum_raw_r\[14\] VGND
+ VGND VPWR VPWR _06331_ sky130_fd_sc_hd__a22o_1
X_11284_ _01338_ _01359_ _03571_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10235_ _02505_ _01449_ _02503_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__o21ai_1
X_13023_ _05244_ _05238_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__nand2_1
XFILLER_105_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10166_ _02464_ _02301_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__nand2_1
XFILLER_66_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10097_ _02394_ _02395_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__nand2_1
X_14974_ _07215_ _07216_ VGND VGND VPWR VPWR _07217_ sky130_fd_sc_hd__and2_1
XFILLER_47_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13925_ _06192_ _06193_ _06198_ VGND VGND VPWR VPWR _06199_ sky130_fd_sc_hd__and3_1
X_13856_ _06040_ VGND VGND VPWR VPWR _06131_ sky130_fd_sc_hd__clkbuf_4
XFILLER_74_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12807_ _05105_ _04999_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__nand2_1
X_13787_ _06056_ VGND VGND VPWR VPWR _06062_ sky130_fd_sc_hd__inv_2
XFILLER_62_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10999_ net116 net229 VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__nand2_1
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15526_ net409 VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_83_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12738_ _04927_ _05036_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__nand2_1
XFILLER_30_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15457_ _05940_ _07673_ VGND VGND VPWR VPWR _07679_ sky130_fd_sc_hd__or2_1
X_12669_ _04965_ _04967_ VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__nand2_1
X_14408_ _06646_ _06647_ VGND VGND VPWR VPWR _06648_ sky130_fd_sc_hd__nand2b_1
XFILLER_30_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15388_ _07614_ _07610_ VGND VGND VPWR VPWR _07615_ sky130_fd_sc_hd__or2_1
X_14339_ _06527_ _06523_ VGND VGND VPWR VPWR _06579_ sky130_fd_sc_hd__nand2_1
XFILLER_7_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16009_ clknet_leaf_13_clk net308 _00257_ VGND VGND VPWR VPWR adder_inst.i_vld_r
+ sky130_fd_sc_hd__dfrtp_1
X_09880_ _02172_ _01859_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__nand2_1
X_08900_ _01195_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__inv_2
XFILLER_106_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08831_ net218 net156 VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__nand2_1
XFILLER_111_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08762_ _01058_ _00872_ _01060_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__nand3_1
XFILLER_38_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08693_ _00795_ _00770_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__nand2_1
XFILLER_53_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09314_ _01611_ _01612_ VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__nand2_1
XFILLER_34_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09245_ _01542_ _01543_ VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__nand2_1
XFILLER_31_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09176_ _01474_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__inv_2
X_08127_ _00420_ _00423_ _00421_ VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__nand3_2
XFILLER_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08058_ net211 net149 VGND VGND VPWR VPWR _07829_ sky130_fd_sc_hd__nand2_1
XFILLER_103_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10020_ _02317_ _02318_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__nand2_1
XFILLER_88_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 net69 VGND VGND VPWR VPWR o_res[10] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11971_ _04269_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__inv_2
XFILLER_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13710_ _05998_ VGND VGND VPWR VPWR _05999_ sky130_fd_sc_hd__inv_2
X_10922_ _03091_ _03220_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__nand2_1
XFILLER_17_637 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14690_ _06928_ _06929_ VGND VGND VPWR VPWR _06930_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_55_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13641_ _05933_ _05935_ VGND VGND VPWR VPWR _05936_ sky130_fd_sc_hd__nand2_1
X_10853_ _03148_ _03151_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__nand2_1
X_13572_ _05867_ _05868_ VGND VGND VPWR VPWR _05869_ sky130_fd_sc_hd__nand2_1
XFILLER_72_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10784_ _03082_ _03081_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__nand2_1
X_15311_ _07534_ _02185_ VGND VGND VPWR VPWR _07535_ sky130_fd_sc_hd__nand2_1
X_12523_ _04819_ _04821_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__nand2_1
XFILLER_12_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15242_ _07491_ VGND VGND VPWR VPWR _07492_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_40_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12454_ net119 net190 VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__nand2_1
X_15173_ _07419_ _07426_ VGND VGND VPWR VPWR _07427_ sky130_fd_sc_hd__nand2_1
X_11405_ _03703_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__inv_2
X_12385_ _04683_ _04610_ VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__nand2_1
X_14124_ _06205_ _06373_ _06375_ _06376_ _06377_ VGND VGND VPWR VPWR _06378_ sky130_fd_sc_hd__a41o_1
X_11336_ _03633_ _03634_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__nand2_1
XFILLER_99_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14055_ _06194_ _06315_ _06305_ _06195_ VGND VGND VPWR VPWR _06316_ sky130_fd_sc_hd__o22a_1
X_13006_ _05303_ _05265_ _05260_ VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__nand3b_1
X_11267_ _03559_ _03560_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__nand2_1
X_10218_ _02504_ _02506_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__nand2_1
XFILLER_39_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11198_ _03496_ _03157_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__nand2_1
X_10149_ _01867_ _02178_ _02186_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__nand3_1
XFILLER_94_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14957_ _07000_ _07187_ VGND VGND VPWR VPWR _07198_ sky130_fd_sc_hd__nand2_1
XFILLER_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13908_ _06182_ VGND VGND VPWR VPWR _06183_ sky130_fd_sc_hd__clkbuf_2
X_14888_ _07123_ VGND VGND VPWR VPWR _07126_ sky130_fd_sc_hd__inv_2
XFILLER_90_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13839_ _06113_ VGND VGND VPWR VPWR _06114_ sky130_fd_sc_hd__inv_2
XFILLER_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15509_ net416 mul_res\[15\] net259 VGND VGND VPWR VPWR _07713_ sky130_fd_sc_hd__mux2_1
XFILLER_50_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09030_ _01319_ _01326_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__xor2_1
XFILLER_30_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09932_ _02229_ _02065_ _02230_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__nand3b_1
XFILLER_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09863_ _02159_ _02161_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09794_ _02034_ _02092_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__nor2_1
XFILLER_85_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08814_ _01098_ _01101_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__nand2_1
X_08745_ _01043_ _00890_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__nand2_1
XFILLER_85_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08676_ _00974_ _00778_ _00970_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__nand3_1
XFILLER_81_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09228_ _01526_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__inv_2
X_09159_ net116 net238 VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__nand2_1
XFILLER_5_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12170_ _04467_ _04461_ _04468_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__nand3_1
XFILLER_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11121_ _03252_ _03255_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11052_ _03348_ _03350_ VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__nand2_1
X_10003_ _02281_ _02295_ _02301_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__nand3_1
XFILLER_103_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15860_ clknet_leaf_3_clk net1 _00108_ VGND VGND VPWR VPWR adder_inst.i_a\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_88_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14811_ _07045_ _07047_ _07021_ VGND VGND VPWR VPWR _07048_ sky130_fd_sc_hd__mux2_1
XFILLER_67_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15791_ net293 VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_103_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14742_ net231 _06552_ _06981_ VGND VGND VPWR VPWR _06982_ sky130_fd_sc_hd__o21ai_1
X_11954_ _04251_ _04252_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__nand2_1
X_14673_ _06910_ _06912_ VGND VGND VPWR VPWR _06913_ sky130_fd_sc_hd__nand2_2
XFILLER_44_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10905_ _03202_ _03203_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__nand2_1
X_11885_ _04182_ _04183_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__nand2_1
X_13624_ _05908_ _05918_ VGND VGND VPWR VPWR _05919_ sky130_fd_sc_hd__or2_1
XFILLER_83_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10836_ _03126_ _03130_ _03134_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_80_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13555_ adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR _05852_ sky130_fd_sc_hd__inv_2
XFILLER_12_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10767_ _03064_ _03065_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__nand2_1
XFILLER_13_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13486_ _05646_ _05647_ _05784_ VGND VGND VPWR VPWR _05785_ sky130_fd_sc_hd__nand3_1
X_12506_ _03954_ _00588_ _04731_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__o21ai_1
X_10698_ _02995_ _02996_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__nand2_1
X_15225_ _07480_ _06659_ VGND VGND VPWR VPWR _07481_ sky130_fd_sc_hd__nand2_1
XFILLER_66_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12437_ _04734_ _04730_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_112_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15156_ _07405_ _07408_ VGND VGND VPWR VPWR _07409_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14107_ _06183_ _06190_ _06362_ VGND VGND VPWR VPWR _06363_ sky130_fd_sc_hd__and3_1
X_12368_ _04632_ _04666_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__nand2_1
X_15087_ _07325_ _07335_ VGND VGND VPWR VPWR adder_inst.sum_raw\[17\] sky130_fd_sc_hd__nand2_1
X_11319_ _03615_ _03617_ VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__nand2_1
X_12299_ _04573_ net183 net138 VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__and3_1
X_14038_ _06231_ _06299_ VGND VGND VPWR VPWR _06300_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15989_ clknet_leaf_5_clk net322 _00237_ VGND VGND VPWR VPWR adder_inst.man_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_82_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08530_ _00824_ _00821_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__nand2_1
XFILLER_63_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08461_ net207 net160 VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_18_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08392_ _00690_ _00687_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__nand2_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09013_ _01311_ _01306_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__nand2_1
Xhold110 mul_res\[19\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
X_09915_ net154 net239 VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__nand2_1
X_09846_ _02136_ _02142_ _02144_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__nand3_1
XFILLER_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09777_ _02052_ _02053_ _02075_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__nand3_1
XFILLER_37_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08728_ _01025_ _01026_ _01015_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__nand3_1
XFILLER_39_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_551 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08659_ _00957_ VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__inv_2
XFILLER_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11670_ net186 net147 VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__nand2_1
X_10621_ _02919_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__inv_2
XFILLER_41_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10552_ _02799_ _02850_ _02774_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__nand3_1
X_13340_ _05637_ _05636_ VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__nand2_1
XFILLER_10_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13271_ _04910_ _05567_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__nor2_1
XFILLER_6_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10483_ _02714_ _02781_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__nand2_1
X_15010_ _07248_ _07253_ VGND VGND VPWR VPWR _07255_ sky130_fd_sc_hd__xor2_1
XFILLER_6_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12222_ _04520_ _04508_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__nand2_1
X_12153_ _04384_ _04388_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__nand2_1
X_11104_ _03339_ _03398_ _03399_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__nand3b_1
X_12084_ _04381_ _04382_ VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__nand2_1
XFILLER_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15912_ clknet_leaf_25_clk net45 _00160_ VGND VGND VPWR VPWR adder_inst.i_b\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_11035_ _03332_ _03333_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__nand2_1
X_15843_ net299 VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__inv_2
XFILLER_77_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15774_ net282 VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__inv_2
XFILLER_64_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12986_ _04220_ _04213_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__nand2_2
X_14725_ _06964_ _06637_ VGND VGND VPWR VPWR _06965_ sky130_fd_sc_hd__nand2_1
XFILLER_45_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11937_ _04233_ _04235_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__nand2_1
X_14656_ _06601_ _06547_ VGND VGND VPWR VPWR _06896_ sky130_fd_sc_hd__or2b_1
XFILLER_60_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11868_ _04164_ _04166_ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__nand2_1
XFILLER_32_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13607_ adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR _05902_ sky130_fd_sc_hd__inv_2
X_14587_ _06826_ VGND VGND VPWR VPWR _06827_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_43_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11799_ _03160_ _04097_ _03952_ VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__o21ai_1
X_10819_ _03117_ _03105_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__nand2_1
XFILLER_20_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13538_ _05670_ _05836_ VGND VGND VPWR VPWR _05837_ sky130_fd_sc_hd__nor2_2
XFILLER_9_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13469_ _05690_ _05747_ VGND VGND VPWR VPWR _05768_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15208_ _07015_ _07019_ _06670_ VGND VGND VPWR VPWR _07463_ sky130_fd_sc_hd__nand3_1
X_15139_ _07388_ _07389_ VGND VGND VPWR VPWR _07390_ sky130_fd_sc_hd__nand2_1
XFILLER_87_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07961_ _07720_ _07484_ VGND VGND VPWR VPWR _07726_ sky130_fd_sc_hd__nor2_1
XFILLER_101_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09700_ _01957_ _01963_ _01998_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__nand3_1
XFILLER_68_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07892_ _07066_ VGND VGND VPWR VPWR _07076_ sky130_fd_sc_hd__inv_2
XFILLER_68_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09631_ net156 net230 VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__nand2_1
XFILLER_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09562_ _01850_ _01853_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__nand2_1
XFILLER_67_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08513_ _00803_ _00811_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__nand2_1
XFILLER_70_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09493_ _01672_ _01667_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__nand2b_1
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08444_ _00742_ _00465_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__nand2_1
X_08375_ net134 net229 VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__nand2_1
XFILLER_11_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09829_ _02126_ _02127_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__nand2_1
XFILLER_104_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12840_ _05052_ _05053_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__nand2_1
XFILLER_64_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12771_ _01042_ _05069_ _04959_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__o21ai_1
XFILLER_27_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15490_ _07701_ VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__clkbuf_1
X_14510_ net209 _06660_ _06749_ VGND VGND VPWR VPWR _06750_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_64_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11722_ _04018_ _04014_ _04016_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__nand3_2
X_14441_ _06680_ _06508_ _06454_ VGND VGND VPWR VPWR _06681_ sky130_fd_sc_hd__mux2_1
XFILLER_9_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11653_ net179 net153 VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10604_ _02900_ _02902_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__nand2_1
X_14372_ _06611_ VGND VGND VPWR VPWR _06612_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_12_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16111_ clknet_leaf_18_clk _00098_ _00359_ VGND VGND VPWR VPWR mul_res\[4\] sky130_fd_sc_hd__dfrtp_1
X_13323_ _05620_ _05614_ VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_40_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11584_ _03862_ _03882_ _03846_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__o21ai_1
X_10535_ _02826_ _02832_ _02833_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__a21o_1
XFILLER_6_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10466_ _02761_ _02762_ _02764_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__nand3_1
X_16042_ clknet_leaf_14_clk _00054_ _00290_ VGND VGND VPWR VPWR add_res\[26\] sky130_fd_sc_hd__dfrtp_1
X_13254_ _05541_ _05552_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__nand2_1
XFILLER_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13185_ net181 net113 VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__nand2_1
X_12205_ _04450_ _04470_ _04503_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__a21oi_1
X_10397_ _02691_ _02694_ _02695_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__a21boi_1
XFILLER_69_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12136_ _04432_ _04434_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12067_ _04365_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__inv_2
XFILLER_49_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11018_ _03309_ _03316_ VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__or2_1
XFILLER_92_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15826_ net285 VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__inv_2
XFILLER_64_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15757_ net294 VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__inv_2
XFILLER_80_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12969_ _05250_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__clkinvlp_2
X_14708_ _06946_ _06947_ VGND VGND VPWR VPWR _06948_ sky130_fd_sc_hd__nand2_1
XFILLER_60_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15688_ net268 VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__inv_2
X_14639_ _06877_ VGND VGND VPWR VPWR _06879_ sky130_fd_sc_hd__inv_2
XFILLER_33_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08160_ _07797_ _07799_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__nand2_1
XFILLER_119_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08091_ _07852_ _07861_ VGND VGND VPWR VPWR _07862_ sky130_fd_sc_hd__xnor2_1
XFILLER_114_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08993_ _01291_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__inv_2
X_07944_ _07180_ VGND VGND VPWR VPWR _07588_ sky130_fd_sc_hd__inv_2
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09614_ _01911_ _01912_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__nand2_1
XFILLER_56_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09545_ _01842_ _01843_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__nand2_1
X_09476_ _01746_ _01757_ _01772_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__a21oi_1
X_08427_ _00663_ _00665_ _00718_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__nand3_1
XFILLER_8_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload2 clknet_leaf_1_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_16
X_08358_ _00641_ _00642_ _00654_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__nand3_1
XFILLER_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08289_ net130 VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__inv_2
X_10320_ _02617_ _02618_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__nand2_1
X_10251_ _02549_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__inv_2
XFILLER_105_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10182_ _02478_ _02480_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__nand2_1
XFILLER_78_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout250 adder_inst.sum_raw_r\[24\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_2
X_14990_ _07229_ _07232_ VGND VGND VPWR VPWR _07234_ sky130_fd_sc_hd__nand2_1
XFILLER_78_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout261 opcode_stage1 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_2
Xfanout272 net279 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_4
X_13941_ _06192_ _06193_ _06212_ VGND VGND VPWR VPWR _06213_ sky130_fd_sc_hd__and3_1
Xfanout283 net286 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_2
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13872_ _06135_ adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _06147_ sky130_fd_sc_hd__nand2_1
XFILLER_75_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15611_ net289 VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_45_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12823_ _05120_ _05121_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__nand2_1
X_15542_ _07733_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12754_ _05049_ _05051_ _04943_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__nand3b_1
XFILLER_15_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11705_ _03964_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__inv_2
XFILLER_91_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15473_ _07692_ VGND VGND VPWR VPWR multiplier_inst.man_final\[20\] sky130_fd_sc_hd__clkbuf_1
XFILLER_42_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12685_ net192 net131 VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14424_ _06660_ net111 VGND VGND VPWR VPWR _06664_ sky130_fd_sc_hd__nand2_1
X_11636_ _03933_ _03934_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__nand2_1
X_14355_ _06537_ _06446_ VGND VGND VPWR VPWR _06595_ sky130_fd_sc_hd__nand2_1
X_11567_ _03864_ _03865_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__nand2_1
X_10518_ _02816_ VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_77_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13306_ _05603_ _05599_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__nand2_1
X_14286_ _06452_ VGND VGND VPWR VPWR _06527_ sky130_fd_sc_hd__inv_2
XFILLER_115_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16025_ clknet_leaf_16_clk _00067_ _00273_ VGND VGND VPWR VPWR add_res\[9\] sky130_fd_sc_hd__dfrtp_1
X_13237_ _05528_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__inv_2
X_11498_ _03793_ _03238_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__nand2_1
X_10449_ _02727_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__inv_2
X_13168_ _05465_ _05466_ VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__nand2_1
XFILLER_97_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13099_ _05396_ _05397_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__nand2_1
XFILLER_2_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12119_ _04416_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__inv_2
XFILLER_111_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15809_ net296 VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__inv_2
XFILLER_80_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09330_ _01154_ _01001_ _01151_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__o21ai_1
XFILLER_46_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09261_ _01559_ _01223_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__nor2_1
XFILLER_33_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08212_ _00496_ _00497_ VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__nand2_1
X_09192_ _01418_ _01490_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__nand2_1
X_08143_ _07886_ _00439_ _00441_ VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__nand3b_1
XFILLER_119_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08074_ _07783_ _07844_ VGND VGND VPWR VPWR _07845_ sky130_fd_sc_hd__nand2_1
XFILLER_106_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold14 adder_inst.i_a\[22\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 adder_inst.i_b\[6\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 adder_inst.i_b\[13\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08976_ _01273_ _01274_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__nand2_1
Xhold47 adder_inst.i_a\[14\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold58 adder_inst.exp_b\[2\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 multiplier_inst.exp_final_r\[2\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
X_07927_ net194 net164 VGND VGND VPWR VPWR _07444_ sky130_fd_sc_hd__nand2_1
XFILLER_28_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09528_ net133 net248 VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__nand2_1
XFILLER_71_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09459_ _01749_ _01757_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12470_ _04767_ _04759_ _04760_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_22_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11421_ _03716_ _03717_ _03719_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__nand3_1
X_14140_ _06186_ net103 _06080_ _00068_ VGND VGND VPWR VPWR _06390_ sky130_fd_sc_hd__a31oi_2
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11352_ _03601_ _03605_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__nand2_1
X_10303_ _02598_ _02601_ _02573_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__nand3_1
X_14071_ adder_inst.sum_raw_r\[13\] _06204_ adder_inst.sum_raw_r\[12\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06330_ sky130_fd_sc_hd__o221a_1
X_11283_ _03581_ _03513_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__nand2_1
X_10234_ _02532_ net154 net242 VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__nand3_1
XFILLER_10_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13022_ _05319_ _05320_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__nand2_1
X_10165_ _02463_ _02299_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__nand2_1
XFILLER_105_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10096_ _02393_ _02056_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__nand2_1
X_14973_ _06719_ _06723_ VGND VGND VPWR VPWR _07216_ sky130_fd_sc_hd__nand2_1
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13924_ adder_inst.sum_raw_r\[2\] _06194_ adder_inst.sum_raw_r\[1\] _06195_ _06197_
+ VGND VGND VPWR VPWR _06198_ sky130_fd_sc_hd__o221a_1
XFILLER_47_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13855_ _06119_ _06106_ VGND VGND VPWR VPWR _06130_ sky130_fd_sc_hd__and2_1
XFILLER_74_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12806_ _05104_ _04997_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__nand2_1
X_13786_ _06044_ _06048_ _06050_ _06060_ VGND VGND VPWR VPWR _06061_ sky130_fd_sc_hd__o22a_1
X_10998_ _03278_ _03293_ _03296_ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__nand3_1
X_15525_ net408 mul_res\[23\] net261 VGND VGND VPWR VPWR _07723_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_83_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12737_ _05035_ _05029_ VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__nand2_1
X_15456_ _07676_ _07677_ VGND VGND VPWR VPWR _07678_ sky130_fd_sc_hd__nand2_1
X_12668_ _04966_ _04664_ _04957_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__nand3_1
X_14407_ _06645_ _03323_ _06551_ VGND VGND VPWR VPWR _06647_ sky130_fd_sc_hd__mux2_1
X_11619_ _03917_ _03739_ _03733_ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__nand3_1
XFILLER_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15387_ _05692_ VGND VGND VPWR VPWR _07614_ sky130_fd_sc_hd__inv_2
X_12599_ _04893_ _04897_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__xor2_2
XFILLER_116_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14338_ _06575_ _06488_ _06577_ VGND VGND VPWR VPWR _06578_ sky130_fd_sc_hd__nand3_1
X_14269_ _06509_ _06454_ VGND VGND VPWR VPWR _06510_ sky130_fd_sc_hd__nor2_1
X_16008_ clknet_leaf_11_clk _00034_ _00256_ VGND VGND VPWR VPWR adder_inst.is_nan_r
+ sky130_fd_sc_hd__dfrtp_1
X_08830_ net154 net223 VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__nand2_1
XFILLER_111_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08761_ _01059_ _00866_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__nand2_1
XFILLER_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08692_ _00968_ _00989_ _00990_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09313_ _01162_ VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__inv_2
XFILLER_25_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09244_ _01253_ _01241_ _01247_ VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__nand3_1
X_09175_ _01472_ _01473_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__nand2_1
X_08126_ _00422_ _00424_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__nand2_1
XFILLER_119_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08057_ _07827_ _07767_ VGND VGND VPWR VPWR _07828_ sky130_fd_sc_hd__nand2_1
XFILLER_103_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08959_ _01166_ VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__inv_2
XFILLER_56_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11970_ _04267_ _04268_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__nand2_1
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10921_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__inv_2
XFILLER_17_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13640_ _05934_ VGND VGND VPWR VPWR _05935_ sky130_fd_sc_hd__inv_2
X_10852_ _03149_ _03150_ _03054_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__nand3_1
X_13571_ _07107_ _07086_ _05866_ VGND VGND VPWR VPWR _05868_ sky130_fd_sc_hd__o21ai_1
X_10783_ _03068_ _03080_ _03081_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__nand3b_1
XFILLER_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15310_ _07531_ _07532_ VGND VGND VPWR VPWR _07534_ sky130_fd_sc_hd__or2b_1
X_12522_ _04820_ VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__inv_2
X_15241_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r _06394_ VGND VGND VPWR
+ VPWR _07491_ sky130_fd_sc_hd__nor3_2
XFILLER_40_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12453_ _00623_ _04239_ _04620_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__or3_1
X_15172_ _07425_ _07178_ VGND VGND VPWR VPWR _07426_ sky130_fd_sc_hd__nand2_1
X_11404_ _03199_ net131 net208 _03195_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__a31o_1
X_12384_ _04601_ _04603_ _04609_ VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__a21o_1
X_14123_ _06052_ net252 _06083_ _06112_ _06042_ VGND VGND VPWR VPWR _06377_ sky130_fd_sc_hd__a221o_1
X_11335_ _03632_ _03630_ VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__nand2_1
XFILLER_4_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14054_ adder_inst.sum_raw_r\[15\] VGND VGND VPWR VPWR _06315_ sky130_fd_sc_hd__inv_2
X_11266_ _03551_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__nand2_1
X_10217_ _02513_ _02515_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__nand2_1
XFILLER_106_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13005_ _05301_ _05303_ VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__nand2_1
X_11197_ _03494_ _03163_ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__nand2_1
XFILLER_94_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10148_ _02442_ _02445_ _02446_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__nand3_1
XFILLER_39_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10079_ _02375_ _02340_ _02336_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__nand3_1
X_14956_ _07195_ _07196_ _07177_ VGND VGND VPWR VPWR _07197_ sky130_fd_sc_hd__a21o_1
X_13907_ _06181_ VGND VGND VPWR VPWR _06182_ sky130_fd_sc_hd__inv_2
X_14887_ _07065_ _07124_ VGND VGND VPWR VPWR _07125_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13838_ net254 _06112_ VGND VGND VPWR VPWR _06113_ sky130_fd_sc_hd__nor2_2
XFILLER_90_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13769_ _06043_ VGND VGND VPWR VPWR _06044_ sky130_fd_sc_hd__buf_2
XFILLER_90_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15508_ net401 VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15439_ _07659_ _05766_ VGND VGND VPWR VPWR _07662_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_96_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09931_ _02061_ _02064_ _02063_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__a21o_1
X_09862_ _02006_ _02017_ _02160_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_5_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09793_ _02036_ _02091_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__nor2_1
X_08813_ _01110_ _01111_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__nand2_1
XFILLER_100_668 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08744_ _01042_ _00651_ _00705_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__o21ai_1
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08675_ _00955_ _00958_ _00953_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__a21o_1
XFILLER_81_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09227_ _01111_ _01115_ _01525_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__a21oi_2
X_09158_ _00628_ _00621_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__nand2_1
X_09089_ net138 net214 VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__nand2_1
X_08109_ _07874_ _07878_ VGND VGND VPWR VPWR _07880_ sky130_fd_sc_hd__nand2_1
X_11120_ _03410_ _03418_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__nand2_1
XFILLER_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11051_ _03349_ VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__inv_2
X_10002_ _02296_ _02295_ _02300_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__nand3_1
XFILLER_76_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14810_ _06881_ _07046_ VGND VGND VPWR VPWR _07047_ sky130_fd_sc_hd__xnor2_1
XFILLER_76_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15790_ net303 VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__inv_2
XFILLER_91_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_251 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14741_ _06975_ _06802_ _06976_ VGND VGND VPWR VPWR _06981_ sky130_fd_sc_hd__nand3_1
X_11953_ _04236_ _04237_ _04249_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__nand3_1
X_14672_ _06911_ _06880_ _06878_ VGND VGND VPWR VPWR _06912_ sky130_fd_sc_hd__a21boi_1
XFILLER_44_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10904_ _03201_ _03190_ _03191_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__nand3b_2
X_11884_ _04176_ _04180_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__nand2_1
X_13623_ _05917_ _05913_ VGND VGND VPWR VPWR _05918_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_67_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10835_ _03132_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_24_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
X_13554_ adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR _05851_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_80_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10766_ net138 net207 VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__nand2_1
XFILLER_13_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12505_ _03127_ _00588_ _04731_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__or3_1
XFILLER_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10697_ _02991_ _02993_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13485_ _05782_ _05783_ VGND VGND VPWR VPWR _05784_ sky130_fd_sc_hd__nand2_1
X_15224_ _07471_ _07472_ VGND VGND VPWR VPWR _07480_ sky130_fd_sc_hd__nand2_1
X_12436_ _04730_ _04734_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__or2_1
X_15155_ _07403_ _07358_ _07407_ VGND VGND VPWR VPWR _07408_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_10_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14106_ _06184_ _06360_ _06361_ VGND VGND VPWR VPWR _06362_ sky130_fd_sc_hd__o21ai_1
X_12367_ _04631_ _04628_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__nand2_1
XFILLER_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15086_ _07334_ _07141_ VGND VGND VPWR VPWR _07335_ sky130_fd_sc_hd__nand2_1
X_11318_ _03591_ _03592_ _03616_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__a21oi_1
X_12298_ _04596_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__inv_2
X_14037_ adder_inst.sum_raw_r\[8\] net255 VGND VGND VPWR VPWR _06299_ sky130_fd_sc_hd__nand2_1
X_11249_ _03546_ _03547_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__nand2_1
XFILLER_95_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15988_ clknet_leaf_6_clk net341 _00236_ VGND VGND VPWR VPWR adder_inst.man_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_94_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14939_ _07176_ _07178_ VGND VGND VPWR VPWR _07179_ sky130_fd_sc_hd__nand2_1
XFILLER_82_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08460_ _00758_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__inv_2
X_08391_ _00684_ _00687_ _00689_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_18_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09012_ _07223_ _01304_ _01309_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__o21ai_1
XFILLER_12_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold100 add_res\[9\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
Xhold111 _07718_ VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09914_ _02212_ _02193_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__or2_1
X_09845_ _02124_ _02143_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__nor2_1
XFILLER_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09776_ _02073_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__inv_2
XFILLER_58_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08727_ _01022_ _00816_ _01019_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__nand3_1
XFILLER_26_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08658_ net211 net160 VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__nand2_1
XFILLER_26_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08589_ net121 net248 VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__nand2_1
X_10620_ net175 net245 VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__nand2_1
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10551_ _02845_ _02849_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_118_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10482_ _02778_ _02780_ _02709_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__nand3_1
X_13270_ _04909_ _04865_ VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__nand2_1
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12221_ _04518_ _04519_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__nand2_1
X_12152_ _04445_ _04450_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__nand2_1
XFILLER_111_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11103_ _03251_ _03401_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__nand2_1
X_12083_ _03639_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__inv_2
X_15911_ clknet_leaf_24_clk net43 _00159_ VGND VGND VPWR VPWR adder_inst.i_b\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11034_ _03319_ _03330_ _03320_ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__nand3_1
XFILLER_103_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15842_ net299 VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__inv_2
XFILLER_91_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15773_ net287 VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__inv_2
XFILLER_64_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12985_ _05282_ _05283_ VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__nand2_1
X_14724_ _06955_ _06956_ VGND VGND VPWR VPWR _06964_ sky130_fd_sc_hd__nand2_1
XFILLER_45_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11936_ _04234_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__inv_2
XFILLER_17_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14655_ _06882_ _06888_ _06521_ VGND VGND VPWR VPWR _06895_ sky130_fd_sc_hd__nand3_1
XFILLER_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11867_ _04165_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__inv_2
XFILLER_32_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13606_ adder_inst.exp_a_r\[5\] _05900_ VGND VGND VPWR VPWR _05901_ sky130_fd_sc_hd__nor2_1
X_14586_ _06758_ _06791_ VGND VGND VPWR VPWR _06826_ sky130_fd_sc_hd__nand2_1
X_11798_ net150 VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__inv_2
X_10818_ _03106_ _03115_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__nor2_1
X_13537_ _05740_ _05807_ _05835_ VGND VGND VPWR VPWR _05836_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_43_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10749_ net200 net149 VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__nand2_1
XFILLER_13_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15207_ _07446_ _06669_ VGND VGND VPWR VPWR _07462_ sky130_fd_sc_hd__nand2_1
X_13468_ _05766_ VGND VGND VPWR VPWR _05767_ sky130_fd_sc_hd__clkinvlp_2
XTAP_TAPCELL_ROW_93_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13399_ _05696_ _05697_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__nand2_1
X_12419_ _04717_ _04715_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__and2_1
X_15138_ _06630_ VGND VGND VPWR VPWR _07389_ sky130_fd_sc_hd__inv_2
XFILLER_87_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15069_ _07315_ _07293_ VGND VGND VPWR VPWR _07317_ sky130_fd_sc_hd__nand2_1
X_07960_ net197 net164 VGND VGND VPWR VPWR _07720_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_4_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_07891_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _07066_
+ sky130_fd_sc_hd__nor2_1
XFILLER_67_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09630_ _01927_ _01928_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__nand2_1
XFILLER_82_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09561_ _01859_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__inv_2
X_08512_ _00810_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__inv_2
X_09492_ _01790_ _01778_ _01780_ VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_102_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08443_ _00475_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__inv_2
X_08374_ net132 net232 VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__nand2_1
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09828_ _02125_ _02124_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__nand2_1
XFILLER_104_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09759_ _02055_ _01828_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__nand2_1
XFILLER_104_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12770_ net209 VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__inv_2
XFILLER_27_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11721_ _04017_ _04019_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14440_ _06509_ VGND VGND VPWR VPWR _06680_ sky130_fd_sc_hd__inv_2
X_11652_ net184 net149 VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__nand2_1
X_10603_ _02901_ _02795_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__nand2_1
X_14371_ _06465_ _06576_ VGND VGND VPWR VPWR _06611_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_12_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16110_ clknet_leaf_20_clk _00097_ _00358_ VGND VGND VPWR VPWR mul_res\[3\] sky130_fd_sc_hd__dfrtp_1
X_13322_ _05614_ _05620_ VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_40_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11583_ _03849_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__inv_2
X_10534_ _02825_ _02803_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__nor2_1
XFILLER_6_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10465_ _02763_ _02662_ VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__nand2_1
XFILLER_108_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16041_ clknet_leaf_14_clk _00053_ _00289_ VGND VGND VPWR VPWR add_res\[25\] sky130_fd_sc_hd__dfrtp_1
X_13253_ _05547_ _05550_ _05551_ VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__nand3_1
XFILLER_6_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10396_ _02656_ _02657_ _02689_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__nand3_1
XFILLER_89_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13184_ net108 net187 VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__nand2_1
X_12204_ _04449_ _04447_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__nor2_1
X_12135_ _04433_ _04429_ _04430_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__nand3_2
XFILLER_111_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12066_ _01511_ _01498_ _01497_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__a21boi_1
XFILLER_65_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11017_ _03312_ _03315_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__nand2_1
X_15825_ net285 VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__inv_2
XFILLER_49_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15756_ net293 VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__inv_2
XFILLER_80_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12968_ _05264_ _05265_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__nand2_1
X_14707_ _06942_ _06943_ _06944_ VGND VGND VPWR VPWR _06947_ sky130_fd_sc_hd__nand3_1
XFILLER_60_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15687_ net264 VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__inv_2
XFILLER_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12899_ _05195_ _05197_ VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__nand2_1
X_11919_ _04150_ _04217_ _04152_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__o21a_1
XFILLER_33_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14638_ _06874_ _06877_ VGND VGND VPWR VPWR _06878_ sky130_fd_sc_hd__nand2_1
X_14569_ _06743_ _06488_ _06744_ VGND VGND VPWR VPWR _06809_ sky130_fd_sc_hd__nand3_1
XFILLER_9_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload20 clknet_leaf_19_clk VGND VGND VPWR VPWR clkload20/Y sky130_fd_sc_hd__inv_6
X_08090_ _07857_ _07860_ VGND VGND VPWR VPWR _07861_ sky130_fd_sc_hd__nand2_1
XFILLER_114_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08992_ _01290_ _01096_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__nand2_1
X_07943_ _07328_ VGND VGND VPWR VPWR _07577_ sky130_fd_sc_hd__inv_2
XFILLER_56_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09613_ net211 net174 VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__nand2_1
XFILLER_83_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09544_ _01810_ _01607_ _01639_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__nand3_1
XFILLER_24_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09475_ _01771_ _01773_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__nand2_1
XFILLER_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08426_ _00565_ _00724_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__nand2_1
Xclkload3 clknet_leaf_3_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__inv_6
X_08357_ _00643_ _00655_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__nand2_1
X_08288_ _00586_ _00571_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_115_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10250_ net233 net167 VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__nand2_1
X_10181_ _02201_ _02479_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__nand2_1
XFILLER_94_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout240 adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout273 net277 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__buf_4
X_13940_ _06194_ adder_inst.sum_raw_r\[4\] adder_inst.sum_raw_r\[3\] _06195_ _06211_
+ VGND VGND VPWR VPWR _06212_ sky130_fd_sc_hd__o221a_1
Xfanout251 net252 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout262 net264 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_4
XFILLER_86_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout295 net307 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
XFILLER_74_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout284 net286 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_4
X_15610_ net303 VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__inv_2
X_13871_ _06105_ _06145_ VGND VGND VPWR VPWR _06146_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_45_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12822_ _04974_ _04968_ _04967_ VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__o21ai_1
X_15541_ net402 mul_res\[31\] net260 VGND VGND VPWR VPWR _07733_ sky130_fd_sc_hd__mux2_1
XFILLER_55_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12753_ _05049_ _05050_ _05051_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__o21bai_1
XFILLER_91_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15472_ _07690_ _07604_ _07691_ VGND VGND VPWR VPWR _07692_ sky130_fd_sc_hd__and3_1
XFILLER_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11704_ _04000_ _04001_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__nand2_1
X_14423_ _06662_ _06521_ VGND VGND VPWR VPWR _06663_ sky130_fd_sc_hd__nand2_1
X_12684_ _04982_ _04690_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11635_ _03931_ _03918_ _03920_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__nand3_1
X_14354_ _06573_ _06593_ _06591_ VGND VGND VPWR VPWR _06594_ sky130_fd_sc_hd__o21ai_1
X_11566_ _03862_ _03846_ _03849_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__nand3_1
X_10517_ _02721_ _02815_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_77_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13305_ _05599_ _05603_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__nor2_1
X_14285_ _06482_ _06523_ _06525_ VGND VGND VPWR VPWR _06526_ sky130_fd_sc_hd__a21o_1
XFILLER_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16024_ clknet_leaf_19_clk _00066_ _00272_ VGND VGND VPWR VPWR add_res\[8\] sky130_fd_sc_hd__dfrtp_1
X_13236_ _05526_ _05527_ VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__nand2_1
X_11497_ _03794_ _03795_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__nand2_1
X_10448_ _02745_ _02743_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__nand2_1
X_10379_ _02670_ _02677_ _02674_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__o21a_1
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13167_ _05464_ _05456_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__nand2b_1
XFILLER_97_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13098_ net182 net120 net183 net118 VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__a22o_1
X_12118_ _04404_ _04416_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__nand2_1
XFILLER_38_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12049_ _04204_ _04206_ _04207_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__a21oi_1
XFILLER_65_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15808_ net283 VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__inv_2
XFILLER_53_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15739_ net293 VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__inv_2
X_09260_ net210 net175 VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__nand2_1
XFILLER_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08211_ _00506_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__inv_2
X_09191_ _01489_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__inv_2
X_08142_ _00435_ _00436_ _00440_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_99_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08073_ _07843_ _07816_ VGND VGND VPWR VPWR _07844_ sky130_fd_sc_hd__nand2_1
XFILLER_115_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08975_ _01265_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__inv_2
XFILLER_0_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold37 adder_inst.i_b\[1\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 adder_inst.i_b\[5\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 adder_inst.i_b\[3\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07926_ _07413_ _07423_ VGND VGND VPWR VPWR _07434_ sky130_fd_sc_hd__nand2_1
Xhold59 adder_inst.exp_a\[2\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_96_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold48 adder_inst.i_b\[15\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_110_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09527_ _01824_ _01825_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__nand2_1
XFILLER_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09458_ _01756_ _01752_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09389_ _01657_ _01654_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__nor2_1
XFILLER_61_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08409_ _00707_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11420_ _03344_ net123 net220 _03718_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__a31o_1
X_11351_ _03646_ _03649_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__nand2_1
X_10302_ _02599_ _02600_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__nand2_1
X_14070_ _06277_ adder_inst.sum_raw_r\[9\] _06232_ adder_inst.sum_raw_r\[10\] _06328_
+ VGND VGND VPWR VPWR _06329_ sky130_fd_sc_hd__a221o_1
X_11282_ _03573_ _03577_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__nand2_1
X_10233_ _02531_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__inv_2
XFILLER_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13021_ _05317_ _05312_ _05314_ VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__nand3_1
X_10164_ _02296_ _02295_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_72_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10095_ _02056_ _02393_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__or2_1
XFILLER_87_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14972_ _06722_ _06724_ _07183_ VGND VGND VPWR VPWR _07215_ sky130_fd_sc_hd__a21o_1
XFILLER_59_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13923_ _06196_ _06044_ _06131_ VGND VGND VPWR VPWR _06197_ sky130_fd_sc_hd__o21ai_1
X_13854_ adder_inst.exp_larger_r\[6\] _06077_ _06074_ _06098_ _06128_ VGND VGND VPWR
+ VPWR _06129_ sky130_fd_sc_hd__o2111a_1
XFILLER_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12805_ _04989_ _04990_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__nand2_1
XFILLER_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15524_ net392 VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__clkbuf_1
X_13785_ _06052_ _06053_ _06049_ _06059_ VGND VGND VPWR VPWR _06060_ sky130_fd_sc_hd__o211a_1
X_10997_ _03294_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__nand2_1
XFILLER_27_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12736_ _05029_ _05033_ _05034_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__nand3_1
XFILLER_89_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15455_ _07670_ _05823_ VGND VGND VPWR VPWR _07677_ sky130_fd_sc_hd__nand2_1
XFILLER_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12667_ _04961_ _04963_ _04960_ VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__o21ai_1
X_15386_ _07613_ VGND VGND VPWR VPWR multiplier_inst.man_final\[3\] sky130_fd_sc_hd__clkbuf_1
X_14406_ _06645_ _04560_ _06568_ VGND VGND VPWR VPWR _06646_ sky130_fd_sc_hd__mux2_1
X_11618_ _03915_ _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__nand2_1
XFILLER_30_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14337_ _06576_ _06484_ VGND VGND VPWR VPWR _06577_ sky130_fd_sc_hd__nand2_1
X_12598_ _04894_ _04896_ VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__or2b_1
X_11549_ _03401_ _03250_ _03247_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__a21boi_1
X_14268_ _02569_ _03911_ _06491_ VGND VGND VPWR VPWR _06509_ sky130_fd_sc_hd__mux2_1
XFILLER_112_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16007_ clknet_leaf_8_clk adder_inst.man_b\[23\] _00255_ VGND VGND VPWR VPWR adder_inst.man_b_r\[23\]
+ sky130_fd_sc_hd__dfrtp_2
X_14199_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] _06440_ VGND VGND VPWR VPWR
+ _06441_ sky130_fd_sc_hd__mux2_1
XFILLER_97_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13219_ _05512_ _05517_ VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__or2_1
XFILLER_111_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08760_ _00870_ _00871_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__nand2_1
XFILLER_65_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08691_ _00967_ _00938_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__nor2_1
XFILLER_93_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09312_ _01160_ _01164_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__nand2_1
XFILLER_53_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09243_ _01541_ _01246_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__nand2_1
X_09174_ _01455_ _01468_ _01470_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__nand3_1
X_08125_ _00423_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__inv_2
XFILLER_107_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08056_ _07826_ VGND VGND VPWR VPWR _07827_ sky130_fd_sc_hd__inv_2
XFILLER_88_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08958_ _01256_ _01123_ _01014_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__nand3_1
XFILLER_48_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08889_ _01187_ _01070_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__nor2_1
XFILLER_56_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07909_ _07201_ _07243_ VGND VGND VPWR VPWR _07254_ sky130_fd_sc_hd__nor2_1
XFILLER_56_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10920_ net184 net155 VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__nand2_1
XFILLER_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10851_ _03035_ _03045_ _03037_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__nand3_1
XFILLER_16_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13570_ _07107_ _07086_ _05866_ VGND VGND VPWR VPWR _05867_ sky130_fd_sc_hd__or3_1
XFILLER_40_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10782_ _03069_ _03078_ _03007_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__nand3_1
XFILLER_25_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12521_ net115 net193 VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__nand2_1
X_15240_ _07489_ VGND VGND VPWR VPWR adder_inst.exp_larger\[7\] sky130_fd_sc_hd__clkbuf_1
X_12452_ net115 net196 VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__nand2_1
XFILLER_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11403_ _03354_ _03352_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__nand2_1
X_15171_ _07422_ _07424_ VGND VGND VPWR VPWR _07425_ sky130_fd_sc_hd__nand2_1
X_12383_ _04680_ _04681_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__nand2_1
X_14122_ net257 net254 VGND VGND VPWR VPWR _06376_ sky130_fd_sc_hd__nand2_1
X_11334_ _03630_ _03632_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__or2_1
XFILLER_4_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14053_ _06311_ _06312_ _06313_ VGND VGND VPWR VPWR _06314_ sky130_fd_sc_hd__a21oi_1
X_11265_ _03562_ _03563_ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__nand2_1
X_10216_ _02491_ _02514_ _02493_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__nand3_1
XFILLER_106_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13004_ _05302_ _05156_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__nand2_1
X_11196_ _03493_ _03494_ _03163_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__nand3_1
XFILLER_94_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10147_ _01704_ _01865_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__nand2_1
XFILLER_67_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10078_ _02341_ _02376_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__nand2_1
X_14955_ _06741_ _07194_ VGND VGND VPWR VPWR _07196_ sky130_fd_sc_hd__or2_1
X_13906_ _06161_ _06169_ _06180_ VGND VGND VPWR VPWR _06181_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_85_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14886_ _06949_ _06933_ _07123_ VGND VGND VPWR VPWR _07124_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_85_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13837_ adder_inst.sum_raw_r\[19\] VGND VGND VPWR VPWR _06112_ sky130_fd_sc_hd__inv_2
X_13768_ net252 VGND VGND VPWR VPWR _06043_ sky130_fd_sc_hd__inv_2
XFILLER_22_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15507_ net400 mul_res\[14\] net259 VGND VGND VPWR VPWR _07712_ sky130_fd_sc_hd__mux2_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_15_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12719_ _04678_ _04670_ _04669_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__o21ai_1
X_13699_ _05988_ _05989_ VGND VGND VPWR VPWR _05990_ sky130_fd_sc_hd__nand2_1
X_15438_ _07620_ _07660_ _07661_ VGND VGND VPWR VPWR multiplier_inst.man_final\[12\]
+ sky130_fd_sc_hd__o21ai_1
X_15369_ _07530_ _07597_ VGND VGND VPWR VPWR _07598_ sky130_fd_sc_hd__nand2_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09930_ _02224_ _02226_ _02228_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__a21oi_1
XFILLER_98_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09861_ _02001_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_5_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09792_ _02032_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__inv_2
X_08812_ _01108_ _00918_ _00920_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__nand3_1
XFILLER_85_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08743_ _00623_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__buf_6
XFILLER_53_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08674_ _00971_ _00972_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09226_ _00918_ _00920_ _01108_ VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__a21oi_1
XFILLER_42_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09157_ _01455_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__inv_2
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09088_ net134 net218 VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__nand2_1
X_08108_ _07874_ _07876_ _07878_ VGND VGND VPWR VPWR _07879_ sky130_fd_sc_hd__nand3_1
X_08039_ _07807_ _07809_ VGND VGND VPWR VPWR _07810_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11050_ _02990_ _02997_ _02995_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__o21ai_1
XFILLER_107_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10001_ _02299_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__inv_2
XFILLER_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14740_ _06979_ VGND VGND VPWR VPWR _06980_ sky130_fd_sc_hd__inv_2
XFILLER_29_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11952_ _04238_ _04250_ VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__nand2_1
XFILLER_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14671_ _06900_ VGND VGND VPWR VPWR _06911_ sky130_fd_sc_hd__inv_2
X_10903_ _03192_ _03201_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__nand2_1
X_11883_ _04058_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__inv_2
X_13622_ _05909_ _05916_ VGND VGND VPWR VPWR _05917_ sky130_fd_sc_hd__nand2_1
XFILLER_44_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10834_ _03131_ _03132_ VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__nand2_1
XFILLER_16_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13553_ _05850_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[0\] sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_17_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12504_ net183 net124 VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__nand2_1
XFILLER_9_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10765_ net134 net211 VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10696_ _02992_ _02994_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__nand2_1
XFILLER_13_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13484_ _05781_ _05780_ VGND VGND VPWR VPWR _05783_ sky130_fd_sc_hd__nand2_1
X_15223_ _07478_ _07479_ VGND VGND VPWR VPWR adder_inst.sum_raw\[23\] sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12435_ _04732_ _04733_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__nand2_1
XFILLER_8_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15154_ _07382_ _07367_ _07406_ VGND VGND VPWR VPWR _07407_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_10_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12366_ _04664_ _04660_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__nand2_1
X_14105_ _06078_ _06204_ _06112_ _06077_ VGND VGND VPWR VPWR _06361_ sky130_fd_sc_hd__o22a_1
X_11317_ _03589_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__inv_2
X_15085_ _07329_ _07333_ VGND VGND VPWR VPWR _07334_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_26_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12297_ net186 net132 VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__nand2_1
X_14036_ _06298_ VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_79_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11248_ _03401_ _03247_ _03250_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_91_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11179_ _03440_ _03452_ _03277_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__nand3_1
XFILLER_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15987_ clknet_leaf_6_clk net333 _00235_ VGND VGND VPWR VPWR adder_inst.man_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_94_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14938_ _07177_ VGND VGND VPWR VPWR _07178_ sky130_fd_sc_hd__buf_4
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14869_ _07105_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07106_ sky130_fd_sc_hd__nand2_1
XFILLER_35_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08390_ _00688_ _00605_ VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_18_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09011_ _01305_ _01307_ _01309_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__nand3_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold101 add_res\[23\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold112 mul_res\[24\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09913_ net156 net239 VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__nand2_1
XFILLER_100_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09844_ _02125_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__inv_2
XFILLER_100_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09775_ _02054_ _02073_ VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__nand2_1
X_08726_ _01021_ _01016_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__nand2_1
XFILLER_66_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08657_ _00955_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__inv_2
XFILLER_26_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08588_ _00886_ VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__inv_2
XFILLER_53_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10550_ _02848_ _02772_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__nand2_1
XFILLER_10_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10481_ _02779_ _02717_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__nand2_1
X_09209_ _01507_ _00647_ VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_118_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_62_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12220_ _04507_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__inv_2
XFILLER_108_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12151_ _04447_ _04449_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__nand2_1
XFILLER_78_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11102_ _03397_ _03400_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__nand2_1
X_12082_ _03622_ _03642_ VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__nand2_1
XFILLER_89_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15910_ clknet_leaf_24_clk net42 _00158_ VGND VGND VPWR VPWR adder_inst.i_b\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11033_ _03321_ _03331_ VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__nand2_1
XFILLER_103_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15841_ net299 VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__inv_2
XFILLER_92_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_71_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15772_ net287 VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__inv_2
X_12984_ _05276_ _05278_ _05280_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__nand3_1
X_14723_ _06960_ _06962_ VGND VGND VPWR VPWR _06963_ sky130_fd_sc_hd__nand2_1
X_11935_ _04066_ _04063_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__nand2_1
XFILLER_27_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14654_ _06892_ _06893_ VGND VGND VPWR VPWR _06894_ sky130_fd_sc_hd__nand2_1
XFILLER_72_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13605_ adder_inst.exp_b_r\[5\] VGND VGND VPWR VPWR _05900_ sky130_fd_sc_hd__inv_2
X_11866_ _04001_ _03996_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__nand2_1
X_14585_ _06823_ _06791_ _06824_ VGND VGND VPWR VPWR _06825_ sky130_fd_sc_hd__a21oi_1
XFILLER_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11797_ _04095_ VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__inv_2
X_10817_ _03106_ _03115_ _03104_ VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_15_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13536_ _05824_ _05834_ VGND VGND VPWR VPWR _05835_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_43_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10748_ _01342_ _03028_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__nand2_1
X_13467_ _05762_ _05765_ VGND VGND VPWR VPWR _05766_ sky130_fd_sc_hd__nand2_1
XFILLER_9_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10679_ _02794_ _02977_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__nand2_2
X_15206_ _07442_ _07461_ VGND VGND VPWR VPWR adder_inst.sum_raw\[22\] sky130_fd_sc_hd__nand2_1
X_12418_ _04558_ _04715_ _04716_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_93_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13398_ _05663_ _05688_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__nand2_1
XFILLER_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15137_ _07008_ _07387_ VGND VGND VPWR VPWR _07388_ sky130_fd_sc_hd__nand2_1
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12349_ _04597_ _04647_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__xor2_1
X_15068_ _07293_ _07315_ VGND VGND VPWR VPWR _07316_ sky130_fd_sc_hd__or2_1
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14019_ _06280_ _06281_ _06282_ VGND VGND VPWR VPWR _06283_ sky130_fd_sc_hd__a21oi_1
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09560_ _01856_ _01858_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__nor2_1
XFILLER_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09491_ _01788_ _01785_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__nand2_1
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08511_ _00805_ _00807_ _00809_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__a21oi_1
XFILLER_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08442_ _00740_ _00517_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__nand2_1
XFILLER_36_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08373_ _00671_ _00610_ VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__nand2_1
XFILLER_117_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_113_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09827_ _02124_ _02125_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__or2_1
XFILLER_59_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09758_ _02056_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__inv_2
XFILLER_86_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08709_ _01007_ _01003_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__nand2_1
XFILLER_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09689_ _01987_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__inv_2
XFILLER_64_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11720_ _04018_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__inv_2
XFILLER_54_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11651_ _03949_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__inv_2
X_10602_ _02851_ _02774_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__nand2_1
X_14370_ _06608_ _06609_ VGND VGND VPWR VPWR _06610_ sky130_fd_sc_hd__nand2_2
X_11582_ _03880_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_12_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10533_ _02830_ _02831_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__and2_1
X_13321_ _05617_ _05618_ _05619_ VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_40_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16040_ clknet_leaf_13_clk _00052_ _00288_ VGND VGND VPWR VPWR add_res\[24\] sky130_fd_sc_hd__dfrtp_1
X_10464_ _02688_ _02686_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__nand2_1
X_13252_ _05546_ _05542_ VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__nand2_1
XFILLER_13_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10395_ _02692_ _02693_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__and2_1
X_13183_ _05480_ _05481_ VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__nand2_1
X_12203_ _04501_ _03684_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__nand2_1
X_12134_ _01523_ _01518_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12065_ _04057_ _04363_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__nand2_1
XFILLER_1_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11016_ _03313_ _03314_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__nand2_1
X_15824_ net294 VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__inv_2
XFILLER_64_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15755_ net291 VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__inv_2
XFILLER_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12967_ _05252_ _05264_ _05265_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__nand3_1
X_14706_ _06942_ _06945_ VGND VGND VPWR VPWR _06946_ sky130_fd_sc_hd__or2b_1
X_15686_ net264 VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__inv_2
X_12898_ _05180_ _05150_ _05196_ VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__nand3_1
X_11918_ _04154_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__inv_2
X_14637_ _06875_ _06876_ VGND VGND VPWR VPWR _06877_ sky130_fd_sc_hd__nand2_1
XFILLER_21_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11849_ _04145_ _04141_ _04143_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__nand3_1
XFILLER_33_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14568_ _06806_ _06462_ _06807_ VGND VGND VPWR VPWR _06808_ sky130_fd_sc_hd__nand3_1
XFILLER_119_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14499_ _06737_ VGND VGND VPWR VPWR _06739_ sky130_fd_sc_hd__inv_2
Xclkload10 clknet_leaf_25_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__inv_12
X_13519_ _05814_ _05817_ VGND VGND VPWR VPWR _05818_ sky130_fd_sc_hd__or2_1
XFILLER_9_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload21 clknet_leaf_20_clk VGND VGND VPWR VPWR clkload21/Y sky130_fd_sc_hd__inv_6
X_16169_ clknet_leaf_13_clk _00023_ _00417_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
XFILLER_87_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08991_ _01288_ _01289_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__nand2_1
X_07942_ _07533_ _07555_ VGND VGND VPWR VPWR _07566_ sky130_fd_sc_hd__nand2_1
XFILLER_95_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09612_ net215 net171 VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__nand2_1
XFILLER_28_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09543_ _01811_ _01813_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__nand2_1
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09474_ _01746_ _01757_ _01772_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__a21o_1
XFILLER_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08425_ _00720_ _00723_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__nand2_1
X_08356_ _00654_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__inv_2
XFILLER_24_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload4 clknet_leaf_4_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_16
X_08287_ net129 net232 VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10180_ net162 net233 VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__nand2_1
XFILLER_105_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout230 net231 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_4
Xfanout241 net243 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
Xfanout274 net276 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_4
Xfanout252 adder_inst.sum_raw_r\[22\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout263 net264 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__buf_4
XFILLER_115_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13870_ _06093_ VGND VGND VPWR VPWR _06145_ sky130_fd_sc_hd__inv_2
Xfanout296 net306 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_4
Xfanout285 net286 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12821_ _05113_ _05065_ VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_45_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15540_ _07731_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12752_ _04232_ _04227_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__nand2_1
X_15471_ _05836_ _05665_ VGND VGND VPWR VPWR _07691_ sky130_fd_sc_hd__nand2_1
X_11703_ _03966_ _04000_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__nand3_1
X_12683_ _04689_ _04687_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__or2_1
X_14422_ _06661_ _06473_ VGND VGND VPWR VPWR _06662_ sky130_fd_sc_hd__and2_1
X_11634_ _03921_ _03932_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14353_ _06591_ _06592_ VGND VGND VPWR VPWR _06593_ sky130_fd_sc_hd__nand2_2
X_11565_ _03850_ _03863_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__nand2_1
X_10516_ net166 net245 VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13304_ _03954_ _00650_ _05484_ _05600_ _05602_ VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__o32a_1
X_14284_ _06524_ _06482_ VGND VGND VPWR VPWR _06525_ sky130_fd_sc_hd__nor2_1
X_11496_ _03238_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__inv_2
XFILLER_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10447_ _02741_ _02743_ _02745_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__nand3_1
X_16023_ clknet_leaf_18_clk _00065_ _00271_ VGND VGND VPWR VPWR add_res\[7\] sky130_fd_sc_hd__dfrtp_1
X_13235_ _05531_ _05533_ VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__nand2_1
XFILLER_6_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10378_ _02674_ _02676_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__nand2_1
XFILLER_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13166_ _05456_ _05464_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__nand2b_1
X_13097_ _05395_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__inv_2
X_12117_ _04414_ _04415_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__nand2_1
X_12048_ _04345_ _04342_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_88_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15807_ net298 VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__inv_2
X_13999_ _06264_ _06131_ VGND VGND VPWR VPWR _06265_ sky130_fd_sc_hd__and2_1
XFILLER_65_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15738_ net292 VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__inv_2
XFILLER_80_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15669_ net293 VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__inv_2
X_08210_ _00508_ VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__inv_2
XFILLER_33_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09190_ _01484_ _01488_ VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__nand2_1
X_08141_ _00438_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__inv_2
X_08072_ _07816_ _07819_ _07842_ VGND VGND VPWR VPWR _07843_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_99_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_110_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08974_ _01270_ _01271_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__nand2_1
Xhold27 adder_inst.i_b\[2\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 adder_inst.i_a\[1\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold38 adder_inst.i_b\[11\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07925_ _07275_ _07307_ _07391_ VGND VGND VPWR VPWR _07423_ sky130_fd_sc_hd__nand3_1
XFILLER_29_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold49 adder_inst.exp_b\[4\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_96_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09526_ _01818_ _01822_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__nand2_1
XFILLER_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09457_ _01752_ _01754_ _01755_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08408_ _00702_ _00704_ _00706_ VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09388_ _01684_ _01538_ _01539_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__nand3_1
XFILLER_8_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08339_ _00631_ _00637_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_50_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11350_ _03647_ _03648_ _03644_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__nand3_1
XFILLER_117_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10301_ _02597_ _02595_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nand2_1
X_11281_ _03572_ _03579_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__nand2_1
X_13020_ _05315_ _05318_ VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__nand2_1
X_10232_ net157 net245 VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_72_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10163_ _01879_ _02461_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__nor2_1
X_10094_ _02366_ _02367_ _02392_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__a21oi_1
XFILLER_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14971_ _07164_ _07209_ VGND VGND VPWR VPWR _07214_ sky130_fd_sc_hd__nand2_1
XFILLER_59_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13922_ adder_inst.sum_raw_r\[0\] VGND VGND VPWR VPWR _06196_ sky130_fd_sc_hd__inv_2
XFILLER_19_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13853_ _06126_ _06042_ _06127_ VGND VGND VPWR VPWR _06128_ sky130_fd_sc_hd__or3b_1
XFILLER_74_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12804_ _05102_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__inv_2
X_15523_ net391 mul_res\[22\] net260 VGND VGND VPWR VPWR _07722_ sky130_fd_sc_hd__mux2_1
X_13784_ adder_inst.sum_raw_r\[19\] adder_inst.exp_larger_r\[1\] _06057_ _06058_ net253
+ VGND VGND VPWR VPWR _06059_ sky130_fd_sc_hd__a221o_1
X_10996_ _03292_ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__inv_2
X_12735_ _05024_ _05019_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_83_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15454_ _07675_ VGND VGND VPWR VPWR _07676_ sky130_fd_sc_hd__inv_2
X_12666_ _04958_ _04960_ _04964_ VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__nand3_1
X_14405_ _06644_ _06521_ VGND VGND VPWR VPWR _06645_ sky130_fd_sc_hd__nand2_1
X_15385_ _07612_ _07607_ _07604_ VGND VGND VPWR VPWR _07613_ sky130_fd_sc_hd__mux2_1
X_12597_ _00650_ _04619_ _04895_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__o21ai_1
X_11617_ _03914_ _03909_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__nand2_1
XFILLER_30_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14336_ _06539_ _06536_ VGND VGND VPWR VPWR _06576_ sky130_fd_sc_hd__nand2_1
XFILLER_51_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11548_ _03845_ _03842_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__nand2_1
XFILLER_116_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14267_ net142 net216 _06491_ VGND VGND VPWR VPWR _06508_ sky130_fd_sc_hd__mux2_1
X_11479_ _03776_ _03777_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__nand2_1
X_14198_ _06413_ VGND VGND VPWR VPWR _06440_ sky130_fd_sc_hd__buf_4
X_16006_ clknet_leaf_22_clk net373 _00254_ VGND VGND VPWR VPWR adder_inst.man_b_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_13218_ _05515_ _05516_ VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__nand2_1
XFILLER_112_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13149_ _05444_ _05445_ _05447_ VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__nand3b_1
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08690_ _00988_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__inv_2
XFILLER_38_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09311_ _01608_ _01597_ _01609_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__a21oi_1
XFILLER_80_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09242_ _01253_ _01241_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__nand2_1
XFILLER_21_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09173_ _01456_ _01471_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__nand2_1
X_08124_ _07879_ _07874_ VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__nand2_1
XFILLER_107_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08055_ net207 net157 VGND VGND VPWR VPWR _07826_ sky130_fd_sc_hd__nand2_1
XFILLER_102_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08957_ _01245_ _01146_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__nand2_1
X_08888_ net130 net248 VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__nand2_1
X_07908_ _07233_ VGND VGND VPWR VPWR _07243_ sky130_fd_sc_hd__inv_2
XFILLER_17_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10850_ _03035_ _03037_ _03045_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__a21o_1
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09509_ _01806_ _01807_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__nand2_1
X_10781_ _03070_ _03079_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__nand2_1
XFILLER_24_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12520_ _04817_ _04818_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_35_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12451_ _04623_ _04618_ VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__nand2_1
X_15170_ _07420_ _06639_ _07416_ VGND VGND VPWR VPWR _07424_ sky130_fd_sc_hd__nand3_1
X_11402_ _03208_ _03180_ _03700_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__a21o_1
X_14121_ _06374_ _06112_ _06054_ net254 VGND VGND VPWR VPWR _06375_ sky130_fd_sc_hd__a211o_1
X_12382_ _04668_ _04669_ _04678_ VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__nand3_1
X_11333_ _03631_ _03467_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__xor2_1
XFILLER_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14052_ adder_inst.sum_raw_r\[13\] net251 _06200_ adder_inst.sum_raw_r\[12\] VGND
+ VGND VPWR VPWR _06313_ sky130_fd_sc_hd__a22o_1
XFILLER_4_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11264_ _03557_ _03560_ _03558_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__nand3_1
X_10215_ _02512_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__inv_2
X_13003_ _05163_ _05157_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__or2_1
X_11195_ _03164_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__inv_2
X_10146_ _02444_ _01866_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__nand2_1
X_10077_ _02375_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__inv_2
X_14954_ _07194_ _06741_ VGND VGND VPWR VPWR _07195_ sky130_fd_sc_hd__nand2_1
X_13905_ _06174_ _06179_ VGND VGND VPWR VPWR _06180_ sky130_fd_sc_hd__nor2_1
X_14885_ _06969_ _06989_ VGND VGND VPWR VPWR _07123_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13836_ _06105_ _06056_ _06107_ _06108_ _06110_ VGND VGND VPWR VPWR _06111_ sky130_fd_sc_hd__a221o_1
X_13767_ _06041_ VGND VGND VPWR VPWR _06042_ sky130_fd_sc_hd__clkbuf_4
X_10979_ _03277_ _03267_ VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_99_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15506_ _07711_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__clkbuf_1
X_12718_ _05010_ _04955_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__nand2_1
X_13698_ adder_inst.exp_b\[0\] VGND VGND VPWR VPWR _05989_ sky130_fd_sc_hd__inv_2
X_15437_ _07530_ _07656_ VGND VGND VPWR VPWR _07661_ sky130_fd_sc_hd__or2_1
X_12649_ _04946_ _04944_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__nor2_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15368_ _07595_ _07596_ VGND VGND VPWR VPWR _07597_ sky130_fd_sc_hd__and2_1
X_15299_ net105 _07525_ net376 _00104_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14319_ _06557_ _06559_ VGND VGND VPWR VPWR _06560_ sky130_fd_sc_hd__and2_1
X_09860_ _02157_ _02158_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_5_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09791_ _02081_ _02088_ _02089_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__nand3_1
XFILLER_97_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08811_ _00921_ _01109_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__nand2_1
XFILLER_100_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08742_ _01038_ _01040_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__nand2_1
XFILLER_66_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08673_ _00955_ _00958_ _00953_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__a21oi_1
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_105_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09225_ _01522_ _01523_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09156_ _01453_ _01454_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__nand2_1
XFILLER_107_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08107_ _07869_ _07877_ VGND VGND VPWR VPWR _07878_ sky130_fd_sc_hd__nand2_1
X_09087_ _00430_ _01385_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__nand2_1
X_08038_ _07808_ _07805_ VGND VGND VPWR VPWR _07809_ sky130_fd_sc_hd__nand2_1
XFILLER_107_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10000_ _02297_ _02298_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__xor2_1
XFILLER_89_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09989_ _02270_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__inv_2
XFILLER_103_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11951_ _04249_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__inv_2
XFILLER_17_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14670_ _06860_ _06909_ VGND VGND VPWR VPWR _06910_ sky130_fd_sc_hd__nand2_1
X_10902_ _03193_ _03200_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__xnor2_1
XFILLER_17_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11882_ _04058_ _04176_ _04180_ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__nand3_1
X_13621_ _05915_ VGND VGND VPWR VPWR _05916_ sky130_fd_sc_hd__inv_2
X_10833_ net184 net158 VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__nand2_1
X_13552_ _05849_ _05843_ VGND VGND VPWR VPWR _05850_ sky130_fd_sc_hd__nand2_1
X_10764_ _03062_ _02992_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__nand2_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12503_ _04743_ _04739_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__nand2_1
XFILLER_40_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_636 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10695_ _02993_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__inv_2
X_13483_ _05780_ _05781_ VGND VGND VPWR VPWR _05782_ sky130_fd_sc_hd__or2_1
X_15222_ _07470_ _06658_ _07475_ VGND VGND VPWR VPWR _07479_ sky130_fd_sc_hd__nand3_1
X_12434_ net180 net128 net183 net127 VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__a22o_1
XFILLER_8_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15153_ _06622_ _06621_ VGND VGND VPWR VPWR _07406_ sky130_fd_sc_hd__or2b_1
X_12365_ _04658_ _04663_ VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__or2_1
X_14104_ _06357_ _06358_ _06359_ VGND VGND VPWR VPWR _06360_ sky130_fd_sc_hd__a21oi_1
X_15084_ _07331_ _07332_ _07173_ VGND VGND VPWR VPWR _07333_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_10_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11316_ _03613_ _03479_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__nand2_1
XFILLER_113_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14035_ _06192_ _06193_ _06297_ VGND VGND VPWR VPWR _06298_ sky130_fd_sc_hd__and3_1
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12296_ net180 net137 net183 net134 VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__a22o_1
X_11247_ _03251_ _03405_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11178_ _03475_ _03476_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__nand2_1
X_10129_ _02426_ _02427_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__nand2_1
XFILLER_67_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15986_ clknet_leaf_6_clk net334 _00234_ VGND VGND VPWR VPWR adder_inst.man_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14937_ _07020_ VGND VGND VPWR VPWR _07177_ sky130_fd_sc_hd__inv_2
XFILLER_48_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14868_ _07101_ _07104_ _07021_ VGND VGND VPWR VPWR _07105_ sky130_fd_sc_hd__mux2_1
XFILLER_51_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13819_ _06093_ adder_inst.exp_larger_r\[4\] VGND VGND VPWR VPWR _06094_ sky130_fd_sc_hd__nand2_1
XFILLER_63_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14799_ _07027_ VGND VGND VPWR VPWR _07037_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_18_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09010_ _07190_ _01308_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__nand2_1
XFILLER_31_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold113 adder_inst.is_zero_b_r VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 _07723_ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
X_09912_ net151 net242 VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__nand2_1
XFILLER_86_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09843_ _02139_ _02141_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__nand2_1
X_09774_ _02072_ _02071_ VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__nand2_1
XFILLER_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08725_ _01015_ _01020_ _01023_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__nand3b_1
XFILLER_81_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08656_ _00954_ _00755_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__nand2_1
XFILLER_81_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08587_ _00884_ _00885_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__nand2_1
XFILLER_54_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10480_ _02615_ _02708_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__nand2_1
X_09208_ _01505_ _01506_ VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__nand2_1
XFILLER_10_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09139_ _01434_ _01435_ _01437_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__nand3_1
XFILLER_108_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12150_ _04448_ _03656_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__nand2_1
XFILLER_108_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11101_ _03398_ _03399_ _03339_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__nand3_1
XFILLER_118_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12081_ _04377_ _04379_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__nand2_2
XFILLER_78_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11032_ _03330_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__inv_2
XFILLER_1_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15840_ net297 VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__inv_2
XFILLER_94_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15771_ net287 VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__inv_2
X_12983_ _05279_ _05281_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__nand2_1
XFILLER_91_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14722_ _02505_ _06637_ _06961_ VGND VGND VPWR VPWR _06962_ sky130_fd_sc_hd__o21ai_1
XFILLER_72_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11934_ _04230_ _04232_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__nand2_1
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14653_ _06802_ net168 VGND VGND VPWR VPWR _06893_ sky130_fd_sc_hd__nand2_1
XFILLER_45_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13604_ adder_inst.exp_a_r\[4\] VGND VGND VPWR VPWR _05899_ sky130_fd_sc_hd__inv_2
X_11865_ _04162_ _04163_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__nand2_1
X_14584_ _06789_ _06777_ _06769_ VGND VGND VPWR VPWR _06824_ sky130_fd_sc_hd__o21ai_1
X_11796_ _03771_ net177 net149 VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__and3_1
X_10816_ _03103_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_15_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13535_ _05830_ _05833_ VGND VGND VPWR VPWR _05834_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_43_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10747_ _03038_ _03045_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__nand2_1
XFILLER_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10678_ _02970_ _02971_ _02976_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__nand3_1
X_13466_ _05690_ _05764_ VGND VGND VPWR VPWR _05765_ sky130_fd_sc_hd__nand2_1
XFILLER_40_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15205_ _07460_ _06019_ VGND VGND VPWR VPWR _07461_ sky130_fd_sc_hd__nand2_1
XFILLER_64_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12417_ _04714_ _04712_ _04657_ VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_93_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13397_ _05671_ _05695_ VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15136_ _07012_ VGND VGND VPWR VPWR _07387_ sky130_fd_sc_hd__inv_2
X_12348_ _04598_ _04595_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__and2b_1
XFILLER_99_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15067_ _07312_ _07314_ VGND VGND VPWR VPWR _07315_ sky130_fd_sc_hd__nand2_2
XFILLER_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12279_ _04576_ _04577_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__nand2_1
X_14018_ adder_inst.sum_raw_r\[10\] net251 _06200_ adder_inst.sum_raw_r\[9\] VGND
+ VGND VPWR VPWR _06282_ sky130_fd_sc_hd__a22o_1
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15969_ clknet_leaf_24_clk net317 _00217_ VGND VGND VPWR VPWR adder_inst.man_a_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_82_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09490_ _01781_ _01785_ _01788_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__nand3_1
X_08510_ _00808_ _00535_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__nor2_1
XFILLER_63_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08441_ _00738_ _00739_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__nand2_1
XFILLER_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08372_ _00670_ _00604_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__nand2_1
XFILLER_23_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09826_ _02028_ _02050_ _02074_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__o21ai_1
XFILLER_48_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09757_ _02055_ _01828_ VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__nor2_1
X_08708_ _01003_ _01005_ _01006_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__nand3_1
XFILLER_27_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09688_ _01986_ _01982_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__nand2_1
XFILLER_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08639_ _00937_ _00793_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__nand2_1
XFILLER_14_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11650_ _03947_ _03948_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__nand2_1
X_10601_ _02795_ _02774_ _02851_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__nand3b_1
XFILLER_80_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11581_ _03878_ _03879_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10532_ _02828_ _02827_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__nand2_1
XFILLER_80_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13320_ _05616_ _05493_ VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_40_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10463_ _02662_ _02688_ _02686_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__nand3b_1
X_13251_ _05549_ VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__inv_2
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10394_ _02650_ _02242_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__nand2_1
XFILLER_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13182_ _05479_ _05476_ _05477_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__nand3b_1
X_12202_ _04494_ _04497_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__nand2_1
X_12133_ _04431_ _01518_ _01523_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__nand3_1
XFILLER_96_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12064_ _04350_ _04362_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__nor2_1
X_11015_ net121 net227 VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__nand2_1
X_15823_ net303 VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__inv_2
XFILLER_92_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15754_ net291 VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__inv_2
XFILLER_92_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14705_ _06943_ _06944_ VGND VGND VPWR VPWR _06945_ sky130_fd_sc_hd__nand2_1
XFILLER_45_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12966_ _05259_ _05260_ _05262_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__nand3_1
XFILLER_18_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15685_ net267 VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__inv_2
X_12897_ _05194_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__inv_2
X_11917_ _04213_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__nand2_1
X_14636_ _06553_ _00624_ VGND VGND VPWR VPWR _06876_ sky130_fd_sc_hd__nand2_1
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11848_ _04144_ _04146_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__nand2_1
XFILLER_33_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14567_ _06702_ _06484_ VGND VGND VPWR VPWR _06807_ sky130_fd_sc_hd__nand2_1
XFILLER_119_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13518_ _05815_ _05816_ VGND VGND VPWR VPWR _05817_ sky130_fd_sc_hd__nand2_1
X_11779_ _03983_ _04077_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__nand2_1
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14498_ _06734_ _06737_ VGND VGND VPWR VPWR _06738_ sky130_fd_sc_hd__nand2_1
Xclkload11 clknet_leaf_9_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__inv_12
Xclkload22 clknet_leaf_21_clk VGND VGND VPWR VPWR clkload22/Y sky130_fd_sc_hd__clkinv_16
X_13449_ _05681_ _05747_ VGND VGND VPWR VPWR _05748_ sky130_fd_sc_hd__nand2_1
X_16168_ clknet_leaf_11_clk _00021_ _00416_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
XFILLER_114_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15119_ _07365_ _07368_ VGND VGND VPWR VPWR _07369_ sky130_fd_sc_hd__nand2_1
X_16099_ clknet_leaf_14_clk multiplier_inst.exp_final\[2\] _00347_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
X_08990_ _01087_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__inv_2
X_07941_ _07413_ _07544_ _07423_ VGND VGND VPWR VPWR _07555_ sky130_fd_sc_hd__nand3_1
XFILLER_56_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09611_ _01909_ _01718_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__nand2_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09542_ _01838_ _01840_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__nand2_1
XFILLER_55_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09473_ _01745_ _01744_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__nor2_1
XFILLER_63_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08424_ _00721_ _00722_ _00718_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__nand3_1
XFILLER_51_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08355_ _00647_ _00653_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__nand2_1
Xclkload5 clknet_leaf_5_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_6
X_08286_ net122 net235 VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__nand2_1
XFILLER_105_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout231 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__clkbuf_4
Xfanout220 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_4
XFILLER_59_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout242 net243 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout253 adder_inst.sum_raw_r\[20\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
Xfanout264 net268 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_2
XFILLER_59_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout275 net276 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_4
X_09809_ _02030_ _02047_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__nand2_1
XFILLER_86_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout297 net306 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_4
Xfanout286 net287 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12820_ _05117_ _05118_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__nand2_1
XFILLER_74_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12751_ _04943_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__inv_2
XFILLER_91_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15470_ _05665_ _05836_ VGND VGND VPWR VPWR _07690_ sky130_fd_sc_hd__or2_1
XFILLER_42_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11702_ _03995_ _03996_ _03998_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__nand3_1
X_12682_ _04980_ _04705_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__nand2_1
X_14421_ _06487_ _06595_ VGND VGND VPWR VPWR _06661_ sky130_fd_sc_hd__nor2_1
XFILLER_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11633_ _03931_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_25_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14352_ _06590_ _06588_ VGND VGND VPWR VPWR _06592_ sky130_fd_sc_hd__or2b_1
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11564_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__inv_2
X_10515_ net162 net245 net166 net243 VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_77_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13303_ _03954_ _00650_ _05484_ _05601_ VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__o31ai_1
X_14283_ _01663_ _04629_ _06491_ VGND VGND VPWR VPWR _06524_ sky130_fd_sc_hd__mux2_1
X_11495_ _03793_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__inv_2
XFILLER_115_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10446_ _02744_ _02682_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__nand2_1
X_16022_ clknet_leaf_18_clk _00064_ _00270_ VGND VGND VPWR VPWR add_res\[6\] sky130_fd_sc_hd__dfrtp_1
X_13234_ _05532_ _05503_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__nand2_1
XFILLER_40_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10377_ _02551_ _02675_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__nand2_1
XFILLER_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13165_ _05462_ _05463_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__nand2_1
XFILLER_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13096_ _05394_ net183 net120 VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__and3_1
X_12116_ _04413_ _04408_ _04411_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__nand3b_1
XFILLER_111_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12047_ _04208_ _04342_ _04345_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__nand3_1
XFILLER_65_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15806_ net297 VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_88_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13998_ _06261_ _06262_ _06263_ VGND VGND VPWR VPWR _06264_ sky130_fd_sc_hd__a21o_1
XFILLER_18_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15737_ net292 VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__inv_2
XFILLER_92_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12949_ _05246_ _05247_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__nand2_1
XFILLER_18_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15668_ net276 VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__inv_2
XFILLER_45_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14619_ _06851_ _06855_ VGND VGND VPWR VPWR _06859_ sky130_fd_sc_hd__nand2_1
X_15599_ net264 VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__inv_2
XFILLER_21_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08140_ _00437_ _00438_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__nand2_1
X_08071_ _07836_ _07841_ VGND VGND VPWR VPWR _07842_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_99_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08973_ _01265_ _01270_ _01271_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__nand3_1
Xhold17 adder_inst.i_a\[7\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_114_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold28 adder_inst.i_a\[16\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
X_07924_ _07318_ _07402_ VGND VGND VPWR VPWR _07413_ sky130_fd_sc_hd__nand2_1
Xhold39 adder_inst.i_b\[14\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_110_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09525_ _01819_ _01823_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__nand2_1
XFILLER_71_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09456_ _01750_ _01593_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__nand2_1
XFILLER_24_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08407_ _00705_ _00632_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__nor2_1
XFILLER_52_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09387_ _01540_ _01685_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__nand2_1
XFILLER_51_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08338_ _00635_ _00636_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08269_ _00567_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__inv_2
X_10300_ _02579_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__inv_2
X_11280_ _03574_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__nand2_1
X_10231_ net151 net247 VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__nand2_1
XFILLER_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10162_ _02454_ _02460_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__nor2_1
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10093_ _02362_ _02360_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__nor2_1
XFILLER_86_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14970_ _07131_ _07211_ VGND VGND VPWR VPWR _07213_ sky130_fd_sc_hd__nand2_1
X_13921_ _06077_ VGND VGND VPWR VPWR _06195_ sky130_fd_sc_hd__buf_2
XFILLER_19_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13852_ _06125_ adder_inst.exp_larger_r\[6\] VGND VGND VPWR VPWR _06127_ sky130_fd_sc_hd__nand2_1
XFILLER_74_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13783_ _06053_ net257 VGND VGND VPWR VPWR _06058_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12803_ _05101_ _05099_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__nand2_1
XFILLER_28_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15522_ _07721_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12734_ _05030_ _05032_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__nand2_1
X_10995_ _03288_ _03291_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__nand2_1
XFILLER_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15453_ _05823_ _07670_ VGND VGND VPWR VPWR _07675_ sky130_fd_sc_hd__nor2_1
X_12665_ _04961_ _04963_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__or2_1
X_14404_ _06515_ _06643_ VGND VGND VPWR VPWR _06644_ sky130_fd_sc_hd__nor2_1
X_15384_ _07610_ _07611_ VGND VGND VPWR VPWR _07612_ sky130_fd_sc_hd__and2b_1
X_12596_ net113 net193 VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__nand2_1
X_11616_ _03909_ _03914_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__or2_1
X_14335_ _06465_ _06574_ VGND VGND VPWR VPWR _06575_ sky130_fd_sc_hd__or2_1
XFILLER_11_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11547_ _03698_ _03842_ _03845_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__nand3_1
XFILLER_116_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16005_ clknet_leaf_22_clk net370 _00253_ VGND VGND VPWR VPWR adder_inst.man_b_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_14266_ _06506_ _06447_ VGND VGND VPWR VPWR _06507_ sky130_fd_sc_hd__nand2_1
X_11478_ net186 net149 VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__nand2_1
X_10429_ net171 net237 VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__nand2_1
X_14197_ _06438_ VGND VGND VPWR VPWR _06439_ sky130_fd_sc_hd__buf_4
X_13217_ _04904_ _04877_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__nand2_1
X_13148_ _05446_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__inv_2
XFILLER_2_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13079_ _05229_ _05377_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__nand2b_1
XFILLER_38_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09310_ _01584_ _01583_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__nor2_1
XFILLER_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09241_ _01538_ _01539_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__nand2_1
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09172_ _01468_ _01470_ VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__nand2_1
XFILLER_119_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08123_ _00420_ _00421_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__nand2_1
X_08054_ _07823_ _07822_ VGND VGND VPWR VPWR _07825_ sky130_fd_sc_hd__nand2b_1
XFILLER_103_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08956_ _01212_ _01254_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__nand2_1
X_08887_ _01184_ _01181_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__nand2_1
XFILLER_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07907_ _07212_ _07223_ VGND VGND VPWR VPWR _07233_ sky130_fd_sc_hd__nand2_1
XFILLER_29_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09508_ _01253_ _01241_ _01246_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_55_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10780_ _03078_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__inv_2
XFILLER_12_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09439_ _01726_ _01736_ _01737_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12450_ _04747_ _04748_ VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__nand2_1
XFILLER_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11401_ _03210_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__inv_2
X_14120_ _06108_ adder_inst.sum_raw_r\[15\] VGND VGND VPWR VPWR _06374_ sky130_fd_sc_hd__nand2_1
X_12381_ _04670_ _04679_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__nand2_1
X_11332_ net110 net241 VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__nand2_1
X_14051_ adder_inst.sum_raw_r\[11\] _06204_ adder_inst.sum_raw_r\[10\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06312_ sky130_fd_sc_hd__o221a_1
XFILLER_4_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11263_ _03559_ _03561_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__nand2_1
X_10214_ _02494_ _02512_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__nand2_1
X_11194_ _03157_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__inv_2
XFILLER_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13002_ _05265_ _05260_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__nand2_1
XFILLER_79_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10145_ _02443_ _01693_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_7_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10076_ _02373_ _02374_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__nand2_1
X_14953_ _07119_ _07187_ _07193_ VGND VGND VPWR VPWR _07194_ sky130_fd_sc_hd__a21o_1
X_13904_ _06125_ _06175_ _06131_ _06177_ _06178_ VGND VGND VPWR VPWR _06179_ sky130_fd_sc_hd__a311o_1
X_14884_ _07121_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07122_ sky130_fd_sc_hd__nand2_1
X_13835_ adder_inst.exp_larger_r\[3\] _06109_ net257 VGND VGND VPWR VPWR _06110_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_85_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13766_ _06040_ VGND VGND VPWR VPWR _06041_ sky130_fd_sc_hd__inv_2
XFILLER_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10978_ _03267_ _03270_ _03276_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__nand3_1
X_13697_ adder_inst.exp_b\[1\] VGND VGND VPWR VPWR _05988_ sky130_fd_sc_hd__inv_2
X_15505_ net393 mul_res\[13\] net259 VGND VGND VPWR VPWR _07711_ sky130_fd_sc_hd__mux2_1
X_12717_ _05015_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__inv_2
X_15436_ _07658_ _07659_ VGND VGND VPWR VPWR _07660_ sky130_fd_sc_hd__nand2_1
X_12648_ _04944_ _04946_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__nand2_1
XFILLER_31_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15367_ _05723_ _05738_ VGND VGND VPWR VPWR _07596_ sky130_fd_sc_hd__nand2_1
X_12579_ _04876_ _04810_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__nand2_1
XFILLER_11_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15298_ net105 _07525_ net379 _00104_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14318_ _06558_ net175 VGND VGND VPWR VPWR _06559_ sky130_fd_sc_hd__nand2_1
X_14249_ _06471_ _06474_ _06489_ VGND VGND VPWR VPWR _06490_ sky130_fd_sc_hd__nand3_1
XFILLER_98_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08810_ _01108_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__inv_2
XFILLER_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09790_ _02079_ _01915_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__nand2_1
XFILLER_85_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08741_ _01023_ _01015_ _01039_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08672_ _00970_ _00778_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__nand2_1
XFILLER_38_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_18_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09224_ _01521_ _01518_ _01519_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__nand3b_1
XFILLER_21_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09155_ _01452_ _01447_ VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__nand2_1
X_09086_ _01384_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__inv_2
X_08106_ net211 net146 VGND VGND VPWR VPWR _07877_ sky130_fd_sc_hd__nand2_1
X_08037_ _07801_ _07804_ VGND VGND VPWR VPWR _07808_ sky130_fd_sc_hd__nor2_1
XFILLER_103_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09988_ _02286_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__inv_2
XFILLER_67_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08939_ _01224_ _01226_ _01228_ VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__a21o_1
X_11950_ _04247_ _04248_ VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__nand2_1
XFILLER_29_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10901_ _03196_ _03199_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__nand2_1
XFILLER_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11881_ _04179_ _04174_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__nand2_1
X_13620_ _05913_ _05914_ VGND VGND VPWR VPWR _05915_ sky130_fd_sc_hd__nand2_1
X_10832_ _03126_ _03130_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__nand2_1
XFILLER_16_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13551_ _05848_ _05841_ VGND VGND VPWR VPWR _05849_ sky130_fd_sc_hd__nand2_1
X_10763_ _03061_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_80_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12502_ _04772_ _04747_ _04748_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__a21boi_1
XFILLER_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15221_ _07477_ _06659_ VGND VGND VPWR VPWR _07478_ sky130_fd_sc_hd__nand2_1
XFILLER_9_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10694_ net137 net205 VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__nand2_1
X_13482_ _04550_ _05331_ _05365_ VGND VGND VPWR VPWR _05781_ sky130_fd_sc_hd__a21o_1
X_12433_ _04560_ _00588_ _04731_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__or3_1
XFILLER_32_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15152_ _07315_ _07404_ VGND VGND VPWR VPWR _07405_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12364_ _04660_ _04662_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__nand2_1
XFILLER_99_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14103_ net255 net251 _06200_ adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR _06359_
+ sky130_fd_sc_hd__a22o_1
X_15083_ _07330_ _06573_ _07320_ VGND VGND VPWR VPWR _07332_ sky130_fd_sc_hd__nand3_1
XFILLER_59_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11315_ _03610_ _03479_ _03613_ VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__nand3_1
XFILLER_113_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14034_ _06184_ _06294_ _06296_ VGND VGND VPWR VPWR _06297_ sky130_fd_sc_hd__o21ai_1
X_12295_ _04591_ _04593_ VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__nand2_1
X_11246_ _03407_ _03544_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11177_ _03473_ _03462_ _03464_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__nand3_1
X_15985_ clknet_leaf_6_clk net344 _00233_ VGND VGND VPWR VPWR adder_inst.man_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_10128_ _02412_ _02410_ _02406_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__a21boi_1
XFILLER_79_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10059_ _02070_ _02071_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__nand2_1
X_14936_ _06725_ _07175_ VGND VGND VPWR VPWR _07176_ sky130_fd_sc_hd__xor2_1
XFILLER_48_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14867_ _06969_ _07103_ VGND VGND VPWR VPWR _07104_ sky130_fd_sc_hd__xor2_1
XFILLER_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13818_ _06047_ _06092_ VGND VGND VPWR VPWR _06093_ sky130_fd_sc_hd__nor2_1
X_14798_ _07035_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07036_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_18_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13749_ _06029_ VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15419_ _07643_ VGND VGND VPWR VPWR _07644_ sky130_fd_sc_hd__inv_4
XFILLER_8_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold103 add_res\[4\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
X_09911_ _02208_ _02200_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__or2b_1
X_09842_ _02140_ _02134_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__nand2_1
X_09773_ _02059_ _02070_ _02071_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__nand3b_1
XFILLER_86_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08724_ _01021_ _01022_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__nand2_1
XFILLER_66_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08655_ net207 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_37_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08586_ _00883_ _00704_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__nand2_1
XFILLER_81_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09207_ _01503_ _01501_ VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__nand2_1
XFILLER_10_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09138_ _01436_ _01432_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__nand2_1
XFILLER_108_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09069_ _07887_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__inv_2
X_11100_ _03392_ _03389_ _03390_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__nand3_1
XFILLER_89_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12080_ _04378_ _01410_ _01366_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__o21ai_1
X_11031_ _03328_ _03329_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__nand2_1
X_15770_ net287 VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__inv_2
X_12982_ _05280_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__inv_2
X_14721_ _06955_ _06568_ _06956_ VGND VGND VPWR VPWR _06961_ sky130_fd_sc_hd__nand3_1
XFILLER_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11933_ _04224_ _04231_ _04227_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__nand3_1
X_14652_ _06890_ _06891_ _06554_ VGND VGND VPWR VPWR _06892_ sky130_fd_sc_hd__nand3_1
XFILLER_60_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11864_ _04130_ _04160_ _04132_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__nand3_1
X_13603_ adder_inst.exp_b_r\[4\] VGND VGND VPWR VPWR _05898_ sky130_fd_sc_hd__inv_2
XFILLER_60_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10815_ _03112_ _03113_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__nand2_1
XFILLER_32_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14583_ _06822_ VGND VGND VPWR VPWR _06823_ sky130_fd_sc_hd__inv_2
X_11795_ _04092_ _04093_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13534_ _05831_ _05832_ VGND VGND VPWR VPWR _05833_ sky130_fd_sc_hd__nand2_1
XFILLER_40_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10746_ _03040_ _03042_ _03044_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__a21oi_2
XFILLER_13_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10677_ _02972_ _02975_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__nor2_1
X_13465_ _05763_ _05756_ VGND VGND VPWR VPWR _05764_ sky130_fd_sc_hd__nand2_1
X_15204_ _07451_ _07459_ VGND VGND VPWR VPWR _07460_ sky130_fd_sc_hd__nand2_1
X_12416_ _04713_ _04714_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15135_ _06642_ VGND VGND VPWR VPWR _07386_ sky130_fd_sc_hd__inv_2
X_13396_ _04350_ _05694_ VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__xor2_2
XFILLER_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12347_ _04644_ _04645_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__nand2_1
X_15066_ _07131_ _07313_ VGND VGND VPWR VPWR _07314_ sky130_fd_sc_hd__nand2_1
X_12278_ _04575_ _04565_ _04566_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__nand3b_1
X_14017_ adder_inst.sum_raw_r\[8\] _06204_ adder_inst.sum_raw_r\[7\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06281_ sky130_fd_sc_hd__o221a_1
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11229_ _03524_ _03527_ VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__nand2_1
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15968_ clknet_leaf_24_clk net338 _00216_ VGND VGND VPWR VPWR adder_inst.man_a_r\[18\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_36_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15899_ clknet_leaf_6_clk net62 _00147_ VGND VGND VPWR VPWR adder_inst.i_b\[7\] sky130_fd_sc_hd__dfrtp_1
X_14919_ _07153_ _07157_ _07020_ VGND VGND VPWR VPWR _07158_ sky130_fd_sc_hd__mux2_1
XFILLER_48_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08440_ _00490_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__inv_2
XFILLER_51_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08371_ _00607_ _00609_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__nand2_1
XFILLER_117_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09825_ _01834_ _02123_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__nand2_1
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09756_ net136 net247 VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__nand2_1
XFILLER_73_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09687_ _01979_ _01982_ _01985_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__nand3b_1
X_08707_ _00808_ _01001_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__nand2_1
XFILLER_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08638_ _00933_ _00936_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__nand2_1
XFILLER_82_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08569_ _00867_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__inv_2
XFILLER_30_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10600_ _02852_ _02897_ _02898_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__a21oi_1
X_11580_ _03696_ _03875_ _03876_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_12_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10531_ _02829_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_40_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13250_ _05548_ _05517_ VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__nand2_1
XFILLER_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10462_ _02760_ _02746_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__nand2_1
XFILLER_108_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12201_ _04493_ _04499_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__nand2_1
X_10393_ _02651_ VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__inv_2
X_13181_ _05478_ _05479_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__nand2_1
X_12132_ _04429_ _04430_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__nand2_1
XFILLER_111_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12063_ _04358_ _04361_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__nand2_1
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11014_ net117 net231 VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__nand2_1
X_15822_ net300 VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__inv_2
XFILLER_77_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15753_ net291 VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_48_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12965_ _05261_ _05263_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__nand2_1
XFILLER_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14704_ net159 _06414_ VGND VGND VPWR VPWR _06944_ sky130_fd_sc_hd__or2_1
X_11916_ _04173_ _04168_ _04214_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__nand3_1
X_15684_ net267 VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__inv_2
XFILLER_72_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12896_ _05192_ _05194_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__nand2_1
XFILLER_72_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14635_ _06869_ _06870_ _06660_ VGND VGND VPWR VPWR _06875_ sky130_fd_sc_hd__nand3_1
X_11847_ _04145_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__inv_2
X_14566_ _06465_ _06804_ _06805_ VGND VGND VPWR VPWR _06806_ sky130_fd_sc_hd__or3_1
X_11778_ _04076_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__inv_2
X_13517_ _05587_ _05575_ VGND VGND VPWR VPWR _05816_ sky130_fd_sc_hd__nand2_1
X_10729_ _03027_ VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__inv_2
X_14497_ _06735_ _06736_ VGND VGND VPWR VPWR _06737_ sky130_fd_sc_hd__nand2_1
XFILLER_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload12 clknet_leaf_10_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__inv_16
XFILLER_70_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13448_ _05746_ VGND VGND VPWR VPWR _05747_ sky130_fd_sc_hd__inv_2
X_16167_ clknet_leaf_12_clk _00020_ _00415_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
X_13379_ _05677_ _05673_ VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__nand2_1
X_16098_ clknet_leaf_14_clk multiplier_inst.exp_final\[1\] _00346_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_15118_ _07366_ _07367_ VGND VGND VPWR VPWR _07368_ sky130_fd_sc_hd__nand2_1
X_15049_ _07119_ _07006_ VGND VGND VPWR VPWR _07295_ sky130_fd_sc_hd__nand2_1
X_07940_ _07528_ VGND VGND VPWR VPWR _07544_ sky130_fd_sc_hd__inv_2
XFILLER_68_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09610_ _01908_ _01715_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__nand2_1
XFILLER_68_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09541_ _01824_ _01839_ _01825_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__nand3_1
XFILLER_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09472_ _01770_ _01634_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__nand2_1
XFILLER_51_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08423_ _00662_ _00567_ _00659_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_63_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08354_ _00650_ _00651_ _00652_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__o21ai_1
Xclkload6 clknet_leaf_7_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_6
XFILLER_109_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08285_ _00580_ _00583_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__nand2_1
XFILLER_78_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout232 net234 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_4
Xfanout210 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_2
Xfanout221 net223 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_4
Xfanout243 adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_4
Xfanout254 adder_inst.sum_raw_r\[20\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout265 net267 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_4
Xfanout276 net277 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_4
Xfanout298 net306 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_4
X_09808_ _02046_ _02038_ _02048_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__nand3b_1
Xfanout287 net288 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09739_ _02030_ _02037_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__nand2_1
XFILLER_86_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12750_ _04942_ _04940_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__nor2_1
XFILLER_27_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11701_ _03997_ _03999_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__nand2_1
X_12681_ _04979_ _04691_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__nand2_1
X_14420_ _06550_ VGND VGND VPWR VPWR _06660_ sky130_fd_sc_hd__buf_2
XFILLER_42_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11632_ _03929_ _03930_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__nand2_1
XFILLER_30_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14351_ _06588_ _06590_ VGND VGND VPWR VPWR _06591_ sky130_fd_sc_hd__or2b_1
X_13302_ _03954_ _03323_ _05596_ VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__o21ai_1
X_11563_ _03860_ _03861_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__nand2_1
X_10514_ _02809_ _02812_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14282_ net124 net196 _06491_ VGND VGND VPWR VPWR _06523_ sky130_fd_sc_hd__mux2_1
XFILLER_6_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11494_ _03790_ _03792_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__nand2_1
X_10445_ _02742_ _02679_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__nand2_1
X_16021_ clknet_leaf_18_clk _00063_ _00269_ VGND VGND VPWR VPWR add_res\[5\] sky130_fd_sc_hd__dfrtp_1
X_13233_ _05528_ _05526_ _05527_ VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__a21boi_1
XFILLER_40_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13164_ _05461_ _05457_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__nand2_1
XFILLER_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10376_ net233 net171 VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__nand2_1
XFILLER_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12115_ _04412_ _04413_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__nand2_1
X_13095_ _05393_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__inv_2
XFILLER_2_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12046_ _04343_ _04344_ VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__nand2_1
XFILLER_38_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15805_ net283 VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__inv_2
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13997_ adder_inst.sum_raw_r\[8\] net252 _06083_ adder_inst.sum_raw_r\[7\] VGND VGND
+ VPWR VPWR _06263_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_88_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15736_ net292 VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__inv_2
XFILLER_61_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12948_ _05144_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__inv_2
X_15667_ net275 VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__inv_2
X_12879_ _05177_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__inv_2
XFILLER_18_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14618_ _06561_ _06857_ VGND VGND VPWR VPWR _06858_ sky130_fd_sc_hd__nand2_1
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15598_ net262 VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__inv_2
XFILLER_119_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14549_ _06787_ _06784_ VGND VGND VPWR VPWR _06789_ sky130_fd_sc_hd__nand2b_1
XFILLER_119_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08070_ _07838_ _07839_ _07840_ VGND VGND VPWR VPWR _07841_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_99_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08972_ _01028_ _01268_ _00995_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_110_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold29 adder_inst.i_b\[10\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 adder_inst.i_a\[12\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
X_07923_ _07391_ VGND VGND VPWR VPWR _07402_ sky130_fd_sc_hd__inv_2
XFILLER_96_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09524_ _01822_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__inv_2
XFILLER_36_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09455_ _01753_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__inv_2
XFILLER_52_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08406_ net121 net244 VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__nand2_1
XFILLER_12_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09386_ _01684_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08337_ _00632_ _00619_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08268_ _00526_ _00553_ _00566_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__a21oi_2
X_10230_ _02527_ _02528_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__nand2_1
X_08199_ _00496_ _00497_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__nand2b_1
X_10161_ _01302_ _01530_ _02459_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__nand3_1
X_10092_ _02389_ _02390_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__nand2_1
XFILLER_86_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13920_ _06078_ VGND VGND VPWR VPWR _06194_ sky130_fd_sc_hd__buf_2
XFILLER_101_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13851_ adder_inst.exp_larger_r\[6\] _06125_ VGND VGND VPWR VPWR _06126_ sky130_fd_sc_hd__nor2_1
XFILLER_19_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13782_ adder_inst.exp_larger_r\[1\] _06055_ _06048_ _06056_ adder_inst.sum_raw_r\[19\]
+ VGND VGND VPWR VPWR _06057_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_58_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12802_ _05098_ _05099_ _05100_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__nand3_1
XFILLER_15_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10994_ _03288_ _03291_ _03292_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__nand3_1
X_15521_ add_res\[21\] mul_res\[21\] net259 VGND VGND VPWR VPWR _07721_ sky130_fd_sc_hd__mux2_1
XFILLER_43_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12733_ _04856_ _05031_ VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__nand2_1
XFILLER_70_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15452_ _07620_ _07673_ _07674_ VGND VGND VPWR VPWR multiplier_inst.man_final\[15\]
+ sky130_fd_sc_hd__o21ai_1
XFILLER_42_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14403_ _06575_ _06512_ _06577_ VGND VGND VPWR VPWR _06643_ sky130_fd_sc_hd__nand3_1
X_12664_ _04960_ _04962_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__nand2_1
X_15383_ _05739_ _05680_ VGND VGND VPWR VPWR _07611_ sky130_fd_sc_hd__nand2_1
X_12595_ _04832_ net109 net193 VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__and3_1
X_11615_ _03910_ _03913_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__nand2_1
X_14334_ _06538_ _06535_ _06453_ VGND VGND VPWR VPWR _06574_ sky130_fd_sc_hd__mux2_1
XFILLER_51_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11546_ _03843_ _03844_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__nand2_1
XFILLER_116_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14265_ _06503_ _06505_ _06482_ VGND VGND VPWR VPWR _06506_ sky130_fd_sc_hd__mux2_1
X_16004_ clknet_leaf_22_clk net371 _00252_ VGND VGND VPWR VPWR adder_inst.man_b_r\[20\]
+ sky130_fd_sc_hd__dfrtp_2
X_13216_ _05514_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__inv_2
X_11477_ _03772_ _03775_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__nand2_1
X_10428_ _02725_ _02726_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__nand2_1
X_14196_ _06429_ _06437_ VGND VGND VPWR VPWR _06438_ sky130_fd_sc_hd__and2_1
XFILLER_111_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10359_ _02656_ _02657_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__nand2_1
XFILLER_97_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13147_ _05443_ _05441_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__nor2_1
XFILLER_2_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13078_ _05222_ _05214_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__nand2_1
XFILLER_38_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12029_ _04325_ _04326_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__nand2_1
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15719_ net298 VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__inv_2
XFILLER_18_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09240_ _01275_ _01272_ _01201_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__nand3_1
XFILLER_61_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09171_ _01469_ _00621_ _00628_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__nand3_1
X_08122_ _00419_ _07887_ VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__nand2_1
XFILLER_119_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08053_ _07822_ _07823_ VGND VGND VPWR VPWR _07824_ sky130_fd_sc_hd__nand2b_1
XFILLER_115_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08955_ _01241_ _01247_ _01253_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__a21boi_1
X_07906_ net182 net176 VGND VGND VPWR VPWR _07223_ sky130_fd_sc_hd__nand2_1
X_08886_ _01181_ _01184_ VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__or2_1
XFILLER_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09507_ _01541_ _01247_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_55_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09438_ _01725_ _01720_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__nor2_1
XFILLER_52_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09369_ net139 net243 VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__nand2_1
X_11400_ _03390_ _03358_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__nand2_1
X_12380_ _04678_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__inv_2
X_11331_ _03629_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__inv_2
X_14050_ _06277_ adder_inst.sum_raw_r\[7\] _06232_ adder_inst.sum_raw_r\[8\] _06310_
+ VGND VGND VPWR VPWR _06311_ sky130_fd_sc_hd__a221o_1
X_11262_ _03560_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__inv_2
X_10213_ _02510_ _02511_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__nand2_1
XFILLER_79_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11193_ _01335_ _01317_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__nand2_1
XFILLER_4_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13001_ _05297_ _05299_ VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__nand2_1
XFILLER_79_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10144_ _01701_ _01691_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_7_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10075_ _02355_ _02356_ _02371_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__nand3_1
XFILLER_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14952_ _07189_ _07192_ VGND VGND VPWR VPWR _07193_ sky130_fd_sc_hd__nand2_1
XFILLER_47_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13903_ adder_inst.exp_larger_r\[5\] _06077_ _06074_ VGND VGND VPWR VPWR _06178_
+ sky130_fd_sc_hd__o21ai_1
X_14883_ _07113_ _07120_ _07021_ VGND VGND VPWR VPWR _07121_ sky130_fd_sc_hd__mux2_1
X_13834_ _06101_ _06045_ VGND VGND VPWR VPWR _06109_ sky130_fd_sc_hd__nor2_1
XFILLER_90_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13765_ net250 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _06040_ sky130_fd_sc_hd__nor2_1
XFILLER_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10977_ _03275_ _03273_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__nand2_1
X_13696_ _05987_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[7\] sky130_fd_sc_hd__inv_2
X_15504_ _07710_ VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12716_ _05012_ _05014_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__nand2_1
X_15435_ _07647_ _05752_ _05771_ VGND VGND VPWR VPWR _07659_ sky130_fd_sc_hd__nand3_1
X_12647_ _04652_ _04945_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__nand2_1
X_15366_ _05738_ _05723_ VGND VGND VPWR VPWR _07595_ sky130_fd_sc_hd__or2_1
XFILLER_117_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12578_ _04810_ _04876_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__or2_1
X_15297_ net105 _07525_ net374 _00104_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_96_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14317_ _06550_ VGND VGND VPWR VPWR _06558_ sky130_fd_sc_hd__clkbuf_4
X_11529_ _03826_ _03827_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__nand2_1
X_14248_ _06486_ _06488_ VGND VGND VPWR VPWR _06489_ sky130_fd_sc_hd__nand2_1
X_14179_ _06408_ _06414_ _05975_ _06420_ VGND VGND VPWR VPWR _06421_ sky130_fd_sc_hd__o211a_1
XFILLER_98_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08740_ _01020_ VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__inv_2
XFILLER_38_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08671_ _00969_ _00771_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__nand2_1
XFILLER_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_105_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09223_ _01520_ _01521_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__nand2_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09154_ _01447_ _01452_ VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__or2_1
XFILLER_22_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08105_ _07875_ VGND VGND VPWR VPWR _07876_ sky130_fd_sc_hd__inv_2
X_09085_ net134 net214 VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__nand2_1
X_08036_ _07801_ _07804_ _07806_ VGND VGND VPWR VPWR _07807_ sky130_fd_sc_hd__o21ai_1
X_09987_ adder_inst.man_a_r\[8\] net171 VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__nand2_1
XFILLER_107_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08938_ _01222_ _01230_ VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08869_ _01148_ _01166_ _01167_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__a21o_1
XFILLER_29_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10900_ _03197_ _03198_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__nand2_1
X_11880_ _04177_ _04178_ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__nand2_1
X_10831_ _03127_ _03128_ _03129_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13550_ _05847_ _05669_ _05838_ VGND VGND VPWR VPWR _05848_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10762_ net138 net211 VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_80_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12501_ _04799_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__inv_2
X_13481_ _05348_ VGND VGND VPWR VPWR _05780_ sky130_fd_sc_hd__inv_2
X_15220_ _07470_ _07475_ VGND VGND VPWR VPWR _07477_ sky130_fd_sc_hd__nand2_1
X_12432_ net180 net127 VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__nand2_1
X_10693_ _02991_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__inv_2
X_15151_ _07403_ _07353_ VGND VGND VPWR VPWR _07404_ sky130_fd_sc_hd__nor2_1
X_12363_ _00623_ _04661_ _04626_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__o21ai_1
X_14102_ adder_inst.sum_raw_r\[16\] _06204_ adder_inst.sum_raw_r\[15\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06358_ sky130_fd_sc_hd__o221a_1
X_15082_ _07330_ _06573_ _07320_ VGND VGND VPWR VPWR _07331_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_10_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11314_ _03611_ _03612_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__nand2_1
X_12294_ _04576_ _04577_ _04592_ VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__nand3_1
X_14033_ _06194_ _06295_ _06284_ _06195_ VGND VGND VPWR VPWR _06296_ sky130_fd_sc_hd__o22a_1
XFILLER_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11245_ _03543_ _03537_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11176_ _03465_ _03474_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__nand2_1
X_15984_ clknet_leaf_5_clk net328 _00232_ VGND VGND VPWR VPWR adder_inst.man_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_91_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10127_ _02425_ _02145_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__nand2_1
XFILLER_94_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10058_ _02355_ _02356_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__nand2_1
X_14935_ _07152_ _07150_ _06828_ VGND VGND VPWR VPWR _07175_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14866_ _07089_ _06990_ _07102_ VGND VGND VPWR VPWR _07103_ sky130_fd_sc_hd__a21oi_1
X_13817_ adder_inst.exp_larger_r\[2\] adder_inst.exp_larger_r\[3\] VGND VGND VPWR
+ VPWR _06092_ sky130_fd_sc_hd__nand2_1
X_14797_ _07031_ _07034_ _07021_ VGND VGND VPWR VPWR _07035_ sky130_fd_sc_hd__mux2_1
X_13748_ net420 adder_inst.is_zero_a_r VGND VGND VPWR VPWR _06029_ sky130_fd_sc_hd__or2_1
XFILLER_90_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13679_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR _05971_
+ sky130_fd_sc_hd__nand2_1
X_15418_ _07640_ _07642_ VGND VGND VPWR VPWR _07643_ sky130_fd_sc_hd__nand2_1
XFILLER_117_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15349_ _02972_ _07553_ _07552_ _07561_ _07575_ VGND VGND VPWR VPWR _07576_ sky130_fd_sc_hd__a221o_1
Xhold104 mul_res\[7\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09910_ _02200_ _02208_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__or2b_1
XFILLER_98_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09841_ _02134_ _02122_ _02128_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__nand3_1
XFILLER_100_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09772_ _02069_ _02066_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_13_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08723_ _00982_ _00973_ _00975_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__a21boi_1
XFILLER_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08654_ _00757_ _00952_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__nor2_1
XFILLER_26_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08585_ _00704_ _00883_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__or2_1
XFILLER_81_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09206_ _01504_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__inv_2
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_118_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09137_ _01433_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__inv_2
X_09068_ _01363_ _01366_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__nand2_1
X_08019_ net194 net170 VGND VGND VPWR VPWR _07790_ sky130_fd_sc_hd__nand2_1
XFILLER_118_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11030_ _03327_ _03322_ _03326_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__nand3b_1
XFILLER_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12981_ _04334_ _04330_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__nand2_1
XFILLER_91_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14720_ _06959_ VGND VGND VPWR VPWR _06960_ sky130_fd_sc_hd__inv_2
XFILLER_72_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11932_ _04229_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__inv_2
XFILLER_17_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14651_ _06601_ _06547_ VGND VGND VPWR VPWR _06891_ sky130_fd_sc_hd__nand2_1
X_11863_ _04133_ _04161_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__nand2_1
XFILLER_17_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13602_ _05897_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[2\] sky130_fd_sc_hd__inv_2
XFILLER_60_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10814_ _03109_ _03110_ _03111_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__nand3_1
X_14582_ _06821_ _06755_ VGND VGND VPWR VPWR _06822_ sky130_fd_sc_hd__nand2_1
X_11794_ _04087_ _04088_ _04090_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_15_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13533_ _05681_ _05661_ VGND VGND VPWR VPWR _05832_ sky130_fd_sc_hd__nand2_1
XFILLER_9_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10745_ _01323_ _03043_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__nor2_1
X_10676_ _02781_ _02974_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__nand2_1
X_13464_ _05370_ _05755_ VGND VGND VPWR VPWR _05763_ sky130_fd_sc_hd__or2_1
XFILLER_40_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15203_ _07458_ _07173_ VGND VGND VPWR VPWR _07459_ sky130_fd_sc_hd__nand2_1
XFILLER_71_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13395_ _05687_ _04358_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__nand2_1
X_12415_ _04638_ _04636_ _04635_ VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__o21ai_1
X_15134_ _07379_ _07385_ VGND VGND VPWR VPWR adder_inst.sum_raw\[19\] sky130_fd_sc_hd__nand2_1
XFILLER_5_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12346_ _04613_ _04642_ _04614_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__nand3_1
XFILLER_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15065_ _07162_ _07306_ _07209_ VGND VGND VPWR VPWR _07313_ sky130_fd_sc_hd__and3_1
XFILLER_5_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12277_ _04567_ _04575_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__nand2_1
XFILLER_110_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14016_ _06277_ adder_inst.sum_raw_r\[4\] _06232_ adder_inst.sum_raw_r\[5\] _06279_
+ VGND VGND VPWR VPWR _06280_ sky130_fd_sc_hd__a221o_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11228_ _03525_ _03526_ _03428_ VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__nand3_1
XFILLER_68_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11159_ net116 net235 VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__nand2_1
XFILLER_95_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15967_ clknet_leaf_24_clk net320 _00215_ VGND VGND VPWR VPWR adder_inst.man_a_r\[17\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_48_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15898_ clknet_leaf_5_clk net61 _00146_ VGND VGND VPWR VPWR adder_inst.i_b\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_91_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14918_ _07150_ _07156_ VGND VGND VPWR VPWR _07157_ sky130_fd_sc_hd__xor2_1
X_14849_ _06990_ _07084_ VGND VGND VPWR VPWR _07085_ sky130_fd_sc_hd__xor2_1
XFILLER_75_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08370_ _00667_ _00668_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__nand2_1
XFILLER_36_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09824_ _01832_ _01187_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__nand2_1
XFILLER_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09755_ _02052_ _02053_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__nand2_1
XFILLER_74_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09686_ _01983_ _01984_ VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08706_ _01004_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__inv_2
X_08637_ _00934_ _00935_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__nand2_1
XFILLER_54_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08568_ net126 net241 VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__nand2_1
XFILLER_14_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08499_ _00737_ _00797_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__nand2_1
X_10530_ _02827_ _02828_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__nor2_1
XFILLER_50_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10461_ _02746_ _02751_ _02759_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__nand3_1
XFILLER_13_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12200_ _04495_ _04498_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__nand2_1
X_10392_ _02658_ _02690_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__nand2_1
XFILLER_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13180_ _05459_ _05462_ VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__and2b_1
XFILLER_108_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12131_ _04421_ _04425_ _04427_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__nand3_1
X_12062_ _04359_ _04360_ VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__nand2_1
XFILLER_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11013_ _03311_ _03302_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__nand2_1
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15821_ net305 VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__inv_2
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15752_ net293 VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__inv_2
XFILLER_58_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12964_ _05262_ VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__inv_2
XFILLER_18_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14703_ _06938_ _06553_ _06939_ VGND VGND VPWR VPWR _06943_ sky130_fd_sc_hd__nand3_1
XFILLER_73_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11915_ _04212_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__inv_2
X_15683_ net267 VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__inv_2
XFILLER_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12895_ _05193_ _05075_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__nand2_1
XFILLER_33_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14634_ _06873_ VGND VGND VPWR VPWR _06874_ sky130_fd_sc_hd__inv_2
XFILLER_60_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11846_ _03915_ _03910_ VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__nand2_1
X_14565_ _06509_ _06539_ VGND VGND VPWR VPWR _06805_ sky130_fd_sc_hd__nor2_1
X_11777_ net192 net137 VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__nand2_1
XFILLER_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13516_ _05583_ _05384_ VGND VGND VPWR VPWR _05815_ sky130_fd_sc_hd__or2b_1
XFILLER_9_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10728_ net194 net152 VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__nand2_1
X_14496_ _06553_ _04134_ VGND VGND VPWR VPWR _06736_ sky130_fd_sc_hd__nand2_1
Xclkload13 clknet_leaf_12_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__inv_12
X_10659_ _02956_ _02957_ _02888_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__nand3_1
X_13447_ _05233_ _05745_ VGND VGND VPWR VPWR _05746_ sky130_fd_sc_hd__xor2_1
X_16166_ clknet_leaf_13_clk _00019_ _00414_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_13378_ _03881_ _05672_ VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__or2_1
XFILLER_114_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16097_ clknet_leaf_14_clk multiplier_inst.exp_final\[0\] _00345_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
X_15117_ _06626_ VGND VGND VPWR VPWR _07367_ sky130_fd_sc_hd__inv_2
X_12329_ net115 net202 VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__nand2_1
X_15048_ _07293_ _07008_ VGND VGND VPWR VPWR _07294_ sky130_fd_sc_hd__xor2_1
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09540_ _01837_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__inv_2
XFILLER_55_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09471_ _01768_ _01769_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__nand2_1
XFILLER_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08422_ _00664_ _00568_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__nand2_1
XFILLER_24_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08353_ net112 net244 VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__nand2_1
X_08284_ _00581_ _00582_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__nand2_1
Xclkload7 clknet_leaf_8_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinv_8
XFILLER_117_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout211 net213 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_74_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout222 net223 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_2
Xfanout200 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout233 net234 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_4
Xfanout255 net256 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__buf_2
Xfanout244 adder_inst.man_a_r\[1\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout277 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__buf_2
Xfanout299 net306 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__clkbuf_4
X_09807_ _02101_ _02105_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__nand2_1
Xfanout266 net267 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
Xfanout288 net307 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_4
X_07999_ _07765_ _07768_ _07769_ VGND VGND VPWR VPWR _07770_ sky130_fd_sc_hd__nand3b_1
X_09738_ _02032_ _02034_ _02036_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__a21oi_2
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09669_ _01794_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__inv_2
XFILLER_61_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11700_ _03998_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__inv_2
XFILLER_15_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12680_ _04703_ _04704_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__nand2_1
XFILLER_70_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11631_ _03928_ _03923_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__nand2_1
X_14350_ _06552_ _06587_ _06589_ VGND VGND VPWR VPWR _06590_ sky130_fd_sc_hd__o21a_1
X_11562_ _03859_ _03856_ _03857_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__nand3b_1
XFILLER_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10513_ _02733_ _02811_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__nand2_1
X_13301_ net108 net184 VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__nand2_1
X_14281_ _06490_ _06517_ _06521_ VGND VGND VPWR VPWR _06522_ sky130_fd_sc_hd__nand3_1
X_11493_ _03787_ _03791_ _03788_ VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__nand3_1
X_10444_ _02742_ _02683_ _02679_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__nand3_1
XFILLER_108_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16020_ clknet_leaf_19_clk _00062_ _00268_ VGND VGND VPWR VPWR add_res\[4\] sky130_fd_sc_hd__dfrtp_1
X_13232_ _05504_ _05530_ VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__nand2_1
XFILLER_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10375_ _02671_ _02673_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__nand2_1
XFILLER_108_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13163_ _05457_ _05461_ VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__or2_1
X_12114_ _00652_ _03631_ _01454_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__o21ai_1
XFILLER_2_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13094_ net180 net118 VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__nand2_1
XFILLER_2_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12045_ _04341_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__inv_2
XFILLER_92_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15804_ net282 VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__inv_2
XFILLER_37_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13996_ adder_inst.sum_raw_r\[6\] _06052_ adder_inst.sum_raw_r\[5\] _06114_ _06155_
+ VGND VGND VPWR VPWR _06262_ sky130_fd_sc_hd__o221a_1
XFILLER_80_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15735_ net292 VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__inv_2
XFILLER_45_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12947_ _05143_ _05145_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__nand2_1
X_15666_ net274 VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__inv_2
X_12878_ _05176_ _05175_ VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__nand2_1
XFILLER_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14617_ _06852_ _06856_ VGND VGND VPWR VPWR _06857_ sky130_fd_sc_hd__nand2_1
X_11829_ _04121_ _04122_ _04125_ VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__nand3_1
X_15597_ net262 VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__inv_2
XFILLER_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14548_ _06784_ _06787_ VGND VGND VPWR VPWR _06788_ sky130_fd_sc_hd__nand2b_1
X_14479_ _06718_ VGND VGND VPWR VPWR _06719_ sky130_fd_sc_hd__inv_2
X_16149_ clknet_leaf_15_clk _00001_ _00397_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08971_ _01269_ _01028_ VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__nand2_1
XFILLER_114_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_110_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold19 adder_inst.i_a\[20\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
X_07922_ _07338_ _07360_ _07381_ VGND VGND VPWR VPWR _07391_ sky130_fd_sc_hd__a21oi_1
XFILLER_110_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09523_ _01820_ _01796_ _01821_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__a21oi_2
XFILLER_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09454_ net151 net230 VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__nand2_1
XFILLER_64_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09385_ _01651_ _01679_ _01683_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__a21oi_1
X_08405_ _00703_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__inv_2
XFILLER_51_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08336_ _00633_ _00634_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__nand2_1
XFILLER_51_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08267_ _00525_ _00524_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08198_ _00483_ _00486_ _00481_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__a21oi_2
XFILLER_106_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10160_ _02457_ _02458_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__nor2_1
X_10091_ _02356_ _02371_ _02355_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__a21boi_1
XFILLER_87_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13850_ _06124_ _06091_ VGND VGND VPWR VPWR _06125_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_58_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13781_ adder_inst.sum_raw_r\[17\] net257 VGND VGND VPWR VPWR _06056_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_58_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12801_ _04276_ _04273_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__nand2_1
X_10993_ _03264_ _03260_ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__nand2_1
X_15520_ _07719_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12732_ _04789_ _04786_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__nand2_1
X_15451_ _07668_ _07620_ VGND VGND VPWR VPWR _07674_ sky130_fd_sc_hd__nand2_1
XFILLER_43_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14402_ _06639_ _06641_ VGND VGND VPWR VPWR _06642_ sky130_fd_sc_hd__nand2_1
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12663_ _01042_ _04552_ _04659_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__o21ai_1
X_15382_ _05680_ _05739_ VGND VGND VPWR VPWR _07610_ sky130_fd_sc_hd__nor2_1
X_12594_ _04892_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__inv_2
XFILLER_11_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11614_ _00623_ _03911_ _03912_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14333_ _06570_ _06572_ VGND VGND VPWR VPWR _06573_ sky130_fd_sc_hd__nand2_1
XFILLER_51_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11545_ _03838_ _03841_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__nand2_1
X_14264_ _06504_ VGND VGND VPWR VPWR _06505_ sky130_fd_sc_hd__inv_2
X_11476_ _03773_ _03774_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__nand2_1
X_10427_ _02724_ _02720_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__nand2_1
X_16003_ clknet_leaf_22_clk net369 _00251_ VGND VGND VPWR VPWR adder_inst.man_b_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_13215_ _05439_ _05513_ VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__nand2_1
X_14195_ _06434_ _06436_ VGND VGND VPWR VPWR _06437_ sky130_fd_sc_hd__nand2_1
XFILLER_112_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10358_ _02540_ _02564_ _02562_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__nand3b_1
X_13146_ _05390_ _05387_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__nand2_1
XFILLER_112_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10289_ _02587_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__inv_2
XFILLER_2_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13077_ _05223_ _05375_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__nand2b_1
XFILLER_111_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12028_ _04270_ _04325_ _04326_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__nand3_2
XFILLER_65_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13979_ _06184_ _06246_ VGND VGND VPWR VPWR _06247_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_69_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15718_ net296 VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__inv_2
XFILLER_18_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15649_ net265 VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_60_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09170_ _01466_ _01467_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__nand2_1
X_08121_ _07887_ _00419_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_78_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08052_ _07803_ _07806_ _07801_ VGND VGND VPWR VPWR _07823_ sky130_fd_sc_hd__a21oi_1
XFILLER_115_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08954_ _01250_ _01252_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_71_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07905_ net185 net170 VGND VGND VPWR VPWR _07212_ sky130_fd_sc_hd__nand2_1
XFILLER_111_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08885_ _01183_ _01072_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__nand2_1
XFILLER_84_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09506_ _01767_ _01800_ _01804_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__a21oi_1
XFILLER_71_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09437_ _01734_ _01735_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__nand2_1
XFILLER_24_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09368_ net133 net244 VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__nand2_1
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09299_ _01586_ _01587_ _01597_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__nand3_1
X_08319_ net116 net241 VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__nand2_1
X_11330_ net106 net244 VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__nand2_1
XFILLER_115_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11261_ _03329_ _03326_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__nand2_1
XFILLER_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10212_ _02499_ _02500_ _02508_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__nand3_1
X_11192_ _03488_ _03490_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__nand2_1
X_13000_ _05298_ _05188_ _05295_ VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__nand3_1
XFILLER_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10143_ _02183_ _02181_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_7_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10074_ _02357_ _02372_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__nand2_1
X_14951_ _07191_ _06722_ VGND VGND VPWR VPWR _07192_ sky130_fd_sc_hd__nand2_1
X_13902_ _06095_ _06176_ _06078_ VGND VGND VPWR VPWR _06177_ sky130_fd_sc_hd__a21oi_1
X_14882_ _07112_ _07119_ VGND VGND VPWR VPWR _07120_ sky130_fd_sc_hd__xor2_1
XFILLER_47_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13833_ net257 VGND VGND VPWR VPWR _06108_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_85_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13764_ _06039_ VGND VGND VPWR VPWR adder_inst.is_nan_a sky130_fd_sc_hd__inv_2
X_15503_ add_res\[12\] mul_res\[12\] net259 VGND VGND VPWR VPWR _07710_ sky130_fd_sc_hd__mux2_1
XFILLER_16_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10976_ _03271_ _03273_ _03274_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__nand3b_1
X_13695_ _05985_ _05986_ VGND VGND VPWR VPWR _05987_ sky130_fd_sc_hd__nand2_1
XFILLER_15_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12715_ _05013_ _04930_ _04728_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__nand3_1
XFILLER_62_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15434_ _07655_ _05770_ VGND VGND VPWR VPWR _07658_ sky130_fd_sc_hd__nand2_1
X_12646_ net181 net141 net179 net143 VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__a22o_1
X_15365_ _07593_ _05722_ _05723_ VGND VGND VPWR VPWR _07594_ sky130_fd_sc_hd__a21o_1
XFILLER_30_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14316_ _06522_ _06548_ _06554_ VGND VGND VPWR VPWR _06557_ sky130_fd_sc_hd__nand3_1
X_12577_ _04874_ _04875_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__nand2b_1
XFILLER_7_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15296_ _07527_ VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_96_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11528_ _03231_ _03228_ _03226_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__a21boi_1
X_14247_ _06487_ VGND VGND VPWR VPWR _06488_ sky130_fd_sc_hd__buf_2
X_11459_ _03755_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__inv_2
X_14178_ _06419_ _05952_ _05948_ _06413_ VGND VGND VPWR VPWR _06420_ sky130_fd_sc_hd__a211o_1
XFILLER_97_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13129_ _05426_ _05427_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__nand2_1
XFILLER_112_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08670_ _00774_ _00777_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__nand2_1
XFILLER_66_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09222_ _00914_ _00910_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_86_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09153_ _00649_ _01448_ _00652_ _01451_ VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__o31a_1
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08104_ net140 net218 VGND VGND VPWR VPWR _07875_ sky130_fd_sc_hd__nand2_1
XFILLER_107_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09084_ net132 net221 VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__nand2_1
XFILLER_107_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08035_ _07805_ VGND VGND VPWR VPWR _07806_ sky130_fd_sc_hd__inv_2
XFILLER_101_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09986_ _02283_ _02284_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__nand2_1
XFILLER_103_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_95_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08937_ _01233_ _01235_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08868_ _01147_ _01124_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__nor2_1
XFILLER_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08799_ _01097_ _01037_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__nand2_1
X_10830_ net181 net161 VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__nand2_1
XFILLER_25_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10761_ net132 net214 VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__nand2_1
XFILLER_25_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13480_ _05664_ _05776_ VGND VGND VPWR VPWR _05779_ sky130_fd_sc_hd__nand2_1
X_12500_ _04797_ _04798_ VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__nand2_1
XFILLER_40_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10692_ net134 net208 VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__nand2_1
X_12431_ net187 net124 VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__nand2_1
XFILLER_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15150_ _06626_ _06610_ VGND VGND VPWR VPWR _07403_ sky130_fd_sc_hd__nand2_1
X_12362_ net203 VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__inv_2
XFILLER_32_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14101_ _06277_ adder_inst.sum_raw_r\[12\] _06232_ adder_inst.sum_raw_r\[13\] _06356_
+ VGND VGND VPWR VPWR _06357_ sky130_fd_sc_hd__a221o_1
X_15081_ _07008_ _07293_ VGND VGND VPWR VPWR _07330_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11313_ _03477_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__inv_2
X_12293_ _04590_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__inv_2
X_14032_ adder_inst.sum_raw_r\[13\] VGND VGND VPWR VPWR _06295_ sky130_fd_sc_hd__inv_2
XFILLER_4_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11244_ _03486_ _03537_ _03542_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__nand3_1
XFILLER_106_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11175_ _03473_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__inv_2
X_15983_ clknet_leaf_12_clk _00033_ _00231_ VGND VGND VPWR VPWR adder_inst.is_inf_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_94_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10126_ _02418_ _02420_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__nand2_1
XFILLER_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10057_ _02343_ _02351_ _02353_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__nand3_1
X_14934_ _07172_ _07173_ VGND VGND VPWR VPWR _07174_ sky130_fd_sc_hd__nand2_1
XFILLER_57_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14865_ _06988_ VGND VGND VPWR VPWR _07102_ sky130_fd_sc_hd__inv_2
X_13816_ adder_inst.exp_larger_r\[5\] VGND VGND VPWR VPWR _06091_ sky130_fd_sc_hd__inv_2
X_14796_ _06908_ _07033_ VGND VGND VPWR VPWR _07034_ sky130_fd_sc_hd__xnor2_1
X_13747_ _06028_ VGND VGND VPWR VPWR adder_inst.is_inf_a sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_18_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10959_ net129 net221 VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__nand2_1
XFILLER_71_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13678_ _05970_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[6\] sky130_fd_sc_hd__inv_2
X_15417_ _07633_ _07641_ VGND VGND VPWR VPWR _07642_ sky130_fd_sc_hd__nand2_1
XFILLER_31_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12629_ _04786_ _04789_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__xor2_1
X_15348_ _07554_ _07562_ _07574_ VGND VGND VPWR VPWR _07575_ sky130_fd_sc_hd__a21o_1
Xhold105 _07704_ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
X_15279_ _07507_ multiplier_inst.man_final_r\[16\] _07508_ VGND VGND VPWR VPWR _07516_
+ sky130_fd_sc_hd__and3_1
XFILLER_104_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09840_ _02137_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__nand2_1
XFILLER_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09771_ _02066_ _02069_ VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__nand2b_1
X_08722_ _01019_ _00816_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__nand2_1
XFILLER_39_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08653_ net210 net164 VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_37_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08584_ _00705_ _00632_ _00702_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__o21a_1
XFILLER_42_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09205_ _01501_ _01503_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_118_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09136_ _00578_ _00575_ VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__nand2_1
X_09067_ _01364_ _01365_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__nand2_1
X_08018_ _07787_ _07788_ VGND VGND VPWR VPWR _07789_ sky130_fd_sc_hd__nand2_1
XFILLER_89_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09969_ adder_inst.man_a_r\[8\] net167 VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__nand2_1
XFILLER_89_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12980_ _05276_ _05278_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__nand2_1
XFILLER_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11931_ _04228_ _04229_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__nand2_1
X_14650_ _06889_ _06521_ VGND VGND VPWR VPWR _06890_ sky130_fd_sc_hd__nand2_1
X_11862_ _04160_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__inv_2
XFILLER_27_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13601_ _05893_ _05896_ VGND VGND VPWR VPWR _05897_ sky130_fd_sc_hd__nand2_1
X_14581_ _06738_ _06756_ VGND VGND VPWR VPWR _06821_ sky130_fd_sc_hd__nand2_1
XFILLER_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10813_ _03109_ _03110_ _03111_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__a21o_1
X_13532_ _05827_ _05664_ VGND VGND VPWR VPWR _05831_ sky130_fd_sc_hd__nand2_1
XFILLER_53_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11793_ _04089_ _04091_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10744_ net185 net161 VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__nand2_1
X_10675_ _02973_ _02777_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__nand2_1
X_13463_ _05681_ _05761_ VGND VGND VPWR VPWR _05762_ sky130_fd_sc_hd__nand2_1
XFILLER_40_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15202_ _07456_ _07457_ VGND VGND VPWR VPWR _07458_ sky130_fd_sc_hd__nand2_1
X_13394_ _05680_ _05692_ VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__nor2_1
X_12414_ _04712_ _04657_ VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__nand2_1
X_15133_ _07384_ _07042_ VGND VGND VPWR VPWR _07385_ sky130_fd_sc_hd__nand2_1
X_12345_ _04615_ _04643_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15064_ _07218_ _07306_ _07311_ VGND VGND VPWR VPWR _07312_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12276_ _04570_ _04572_ _04574_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__a21oi_1
X_14015_ _06231_ _06278_ VGND VGND VPWR VPWR _06279_ sky130_fd_sc_hd__nand2_1
X_11227_ _03409_ _03082_ _03418_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__nand3_1
XFILLER_68_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11158_ _01461_ _03311_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__nand2_1
X_10109_ _02407_ _02140_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__nand2_1
X_15966_ clknet_leaf_24_clk net335 _00214_ VGND VGND VPWR VPWR adder_inst.man_a_r\[16\]
+ sky130_fd_sc_hd__dfrtp_4
X_11089_ _03387_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__inv_2
X_15897_ clknet_leaf_5_clk net60 _00145_ VGND VGND VPWR VPWR adder_inst.i_b\[5\] sky130_fd_sc_hd__dfrtp_1
X_14917_ _07154_ _06816_ _07155_ VGND VGND VPWR VPWR _07156_ sky130_fd_sc_hd__nand3_1
XFILLER_75_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14848_ _06913_ _07083_ _06995_ VGND VGND VPWR VPWR _07084_ sky130_fd_sc_hd__a21o_1
XFILLER_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14779_ _07018_ _07013_ _07006_ VGND VGND VPWR VPWR _07019_ sky130_fd_sc_hd__nand3_2
XFILLER_51_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09823_ _02024_ _02121_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__nand2_1
XFILLER_59_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09754_ _02050_ _02027_ _01991_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__nand3_1
XFILLER_94_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09685_ net148 net236 VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08705_ net142 net229 VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__nand2_1
XFILLER_82_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08636_ _00763_ _00761_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__nand2_1
XFILLER_82_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08567_ net122 net244 VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__nand2_1
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08498_ _00770_ _00792_ _00796_ VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__a21oi_1
X_10460_ _02758_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_79_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09119_ _01416_ _01417_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__nand2_1
X_10391_ _02689_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__inv_2
XFILLER_89_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12130_ _04426_ _04428_ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__nand2_1
XFILLER_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12061_ _04048_ _04041_ _04042_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__a21boi_1
XFILLER_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11012_ _03310_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__inv_2
X_15820_ net304 VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__inv_2
XFILLER_89_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15751_ net291 VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__inv_2
X_12963_ _04318_ _04291_ VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__nand2_1
XFILLER_18_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15682_ net267 VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__inv_2
X_14702_ _06940_ _06941_ VGND VGND VPWR VPWR _06942_ sky130_fd_sc_hd__nand2_1
XFILLER_73_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11914_ _04210_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__nand2_1
X_14633_ _06871_ _06872_ VGND VGND VPWR VPWR _06873_ sky130_fd_sc_hd__nand2_1
X_12894_ _05086_ _05078_ VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__or2_1
XFILLER_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11845_ _04141_ _04143_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__nand2_1
XFILLER_60_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14564_ _06505_ _06482_ VGND VGND VPWR VPWR _06804_ sky130_fd_sc_hd__nor2_1
X_11776_ net198 net131 VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__nand2_1
X_14495_ _06730_ _06550_ VGND VGND VPWR VPWR _06735_ sky130_fd_sc_hd__nand2_1
X_13515_ _05561_ VGND VGND VPWR VPWR _05814_ sky130_fd_sc_hd__inv_2
XFILLER_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10727_ _03023_ _03025_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__nand2_1
X_13446_ _05744_ _05224_ _05376_ VGND VGND VPWR VPWR _05745_ sky130_fd_sc_hd__a21bo_1
XFILLER_9_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload14 clknet_leaf_13_clk VGND VGND VPWR VPWR clkload14/X sky130_fd_sc_hd__clkbuf_4
X_10658_ _02856_ _02841_ _02887_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__a21o_1
XFILLER_62_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10589_ _02856_ _02841_ _02887_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__nand3_2
X_16165_ clknet_leaf_14_clk _00018_ _00413_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_13377_ _05671_ _05675_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__nand2_1
X_16096_ clknet_leaf_12_clk multiplier_inst.man_final\[22\] _00344_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[22\] sky130_fd_sc_hd__dfrtp_1
X_15116_ _06607_ _07347_ _06609_ VGND VGND VPWR VPWR _07366_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12328_ _00623_ _04619_ _04626_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__or3_1
X_15047_ _07010_ VGND VGND VPWR VPWR _07293_ sky130_fd_sc_hd__inv_2
X_12259_ _04551_ _04555_ _04557_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__o21ba_1
XFILLER_95_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15949_ clknet_leaf_18_clk adder_inst.sum_raw\[24\] _00197_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[24\]
+ sky130_fd_sc_hd__dfrtp_1
X_09470_ _01620_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_47_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08421_ _00663_ _00665_ _00719_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__nand3_1
XFILLER_17_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08352_ net248 VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__clkinv_4
X_08283_ _00569_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__inv_2
Xclkload8 clknet_leaf_22_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_12
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout223 adder_inst.man_a_r\[9\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_74_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout201 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_4
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_4
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_4
Xfanout234 adder_inst.man_a_r\[5\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_4
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout278 net279 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_4
Xfanout289 net295 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_4
X_09806_ _02104_ _01949_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__nand2_1
Xfanout267 net268 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_2
XFILLER_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07998_ _07766_ _07749_ VGND VGND VPWR VPWR _07769_ sky130_fd_sc_hd__nand2_1
X_09737_ _02035_ _01903_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__nor2_1
XFILLER_75_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09668_ _01789_ _01791_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__nand2_1
XFILLER_55_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09599_ _01897_ _01881_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__nand2_1
X_08619_ _00908_ _00917_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11630_ _03923_ _03928_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__or2_1
X_11561_ _03858_ _03859_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__nand2_1
X_10512_ _02810_ _00624_ _02732_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__o21ai_1
X_13300_ _05596_ _05597_ _05598_ VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__o21ai_1
XFILLER_10_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14280_ _06520_ VGND VGND VPWR VPWR _06521_ sky130_fd_sc_hd__clkbuf_4
X_11492_ _03234_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__inv_2
X_10443_ _02684_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__inv_2
X_13231_ _05529_ _05527_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__nand2_1
XFILLER_108_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10374_ _02672_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__inv_2
X_13162_ _05459_ _05460_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__or2b_1
XFILLER_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12113_ _04408_ _04411_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__nand2_1
X_13093_ _05390_ _05391_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__nand2_1
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12044_ _04337_ _04340_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__nand2_1
X_15803_ net282 VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__inv_2
XFILLER_65_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15734_ net289 VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__inv_2
X_13995_ _06056_ adder_inst.sum_raw_r\[2\] _06055_ adder_inst.sum_raw_r\[3\] _06260_
+ VGND VGND VPWR VPWR _06261_ sky130_fd_sc_hd__a221o_1
XFILLER_92_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12946_ _05243_ _05244_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__nand2_1
X_15665_ net276 VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__inv_2
XFILLER_73_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12877_ _05167_ _05174_ _05175_ VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__nand3_1
X_14616_ _06855_ VGND VGND VPWR VPWR _06856_ sky130_fd_sc_hd__inv_2
XFILLER_60_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15596_ net262 VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__inv_2
X_11828_ _04123_ _04126_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__nand2_1
XFILLER_33_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14547_ _06785_ _06786_ VGND VGND VPWR VPWR _06787_ sky130_fd_sc_hd__nand2_1
X_11759_ _04012_ _03949_ _04011_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__o21ai_1
X_14478_ _06716_ _06568_ _06717_ VGND VGND VPWR VPWR _06718_ sky130_fd_sc_hd__a21bo_1
X_13429_ _05663_ _05727_ VGND VGND VPWR VPWR _05728_ sky130_fd_sc_hd__nand2_1
X_16148_ clknet_leaf_19_clk _00031_ _00396_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
XFILLER_5_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16079_ clknet_leaf_20_clk multiplier_inst.man_final\[5\] _00327_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_08970_ _01268_ _00995_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_110_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07921_ _07370_ _07212_ VGND VGND VPWR VPWR _07381_ sky130_fd_sc_hd__nor2_1
Xinput1 i_a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_83_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09522_ _01775_ _01771_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__nor2_1
XFILLER_64_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09453_ _01751_ net156 net225 VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__nand3_1
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09384_ _01641_ _01682_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__nor2_1
X_08404_ net116 net248 VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__nand2_1
XFILLER_52_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08335_ _00619_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08266_ _00563_ _00564_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__nand2_1
X_08197_ _00495_ _07834_ VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10090_ _02388_ _02132_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__nand2_1
XFILLER_101_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12800_ _05092_ _05093_ _05096_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__nand3_1
X_13780_ net257 _06054_ VGND VGND VPWR VPWR _06055_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_87_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10992_ _03289_ _03290_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__nand2_1
XFILLER_27_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12731_ _05026_ _05012_ _05014_ VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_106_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15450_ _07670_ _07671_ VGND VGND VPWR VPWR _07673_ sky130_fd_sc_hd__nand2_1
X_12662_ net115 net209 VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__nand2_1
XFILLER_35_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14401_ _06640_ _06635_ VGND VGND VPWR VPWR _06641_ sky130_fd_sc_hd__nand2_1
XFILLER_43_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11613_ net119 net216 VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__nand2_1
X_15381_ _07609_ VGND VGND VPWR VPWR multiplier_inst.man_final\[2\] sky130_fd_sc_hd__clkbuf_1
X_12593_ net107 net198 VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__nand2_1
XFILLER_23_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14332_ _06563_ _06567_ _06571_ VGND VGND VPWR VPWR _06572_ sky130_fd_sc_hd__o21ai_1
X_11544_ _03768_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__inv_2
X_14263_ net146 net221 _06491_ VGND VGND VPWR VPWR _06504_ sky130_fd_sc_hd__mux2_1
X_11475_ net181 net155 VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__nand2_1
X_10426_ _02720_ _02724_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__or2_1
X_16002_ clknet_leaf_22_clk net368 _00250_ VGND VGND VPWR VPWR adder_inst.man_b_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_13214_ _05438_ _05421_ VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_115_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14194_ _05912_ _06435_ VGND VGND VPWR VPWR _06436_ sky130_fd_sc_hd__xor2_1
X_10357_ _02655_ _02540_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__nand2_1
X_13145_ _05441_ _05443_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__and2_1
X_10288_ _02585_ _02586_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__nor2_1
X_13076_ _05351_ _05350_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__nand2_1
XFILLER_111_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12027_ _04322_ _04323_ _04324_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__nand3_2
XFILLER_38_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13978_ _06243_ _06244_ _06245_ VGND VGND VPWR VPWR _06246_ sky130_fd_sc_hd__o21ba_1
XFILLER_65_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15717_ net297 VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__inv_2
XFILLER_80_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12929_ _05226_ _05227_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__nand2_1
XFILLER_33_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15648_ net265 VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__inv_2
XFILLER_61_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15579_ net274 VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_60_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08120_ _07877_ _07888_ _07890_ VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__o21ai_1
X_08051_ _07821_ _07770_ VGND VGND VPWR VPWR _07822_ sky130_fd_sc_hd__nand2_1
XFILLER_115_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08953_ _01251_ _01239_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_71_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07904_ _07180_ _07190_ VGND VGND VPWR VPWR _07201_ sky130_fd_sc_hd__nor2_1
XFILLER_96_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08884_ _01182_ _01065_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__nand2_1
XFILLER_29_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09505_ _01762_ _01803_ VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_55_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09436_ _01728_ _01732_ _01730_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__nand3b_1
XFILLER_64_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_82_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09367_ _01664_ _01665_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_35_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09298_ _01595_ VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__inv_2
XFILLER_20_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08318_ _00594_ _00614_ _00595_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__nand3_1
X_08249_ _00545_ _07853_ VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__nand2_1
XFILLER_21_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11260_ _03557_ _03558_ VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__nand2_1
X_10211_ _02501_ _02509_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__nand2_1
X_11191_ _03489_ _03152_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__nand2_1
XFILLER_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10142_ _02439_ _02440_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__nand2_1
X_10073_ _02371_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__inv_2
X_14950_ _06698_ _06724_ VGND VGND VPWR VPWR _07191_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_7_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13901_ _06094_ _06091_ VGND VGND VPWR VPWR _06176_ sky130_fd_sc_hd__nand2_1
XFILLER_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14881_ _07114_ _07118_ VGND VGND VPWR VPWR _07119_ sky130_fd_sc_hd__nand2_2
XFILLER_47_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13832_ _06106_ _06104_ _06054_ VGND VGND VPWR VPWR _06107_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13763_ _06016_ _06027_ VGND VGND VPWR VPWR _06039_ sky130_fd_sc_hd__nand2_1
XFILLER_90_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15502_ _07709_ VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10975_ _01425_ _03258_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__nand2_1
X_12714_ _05011_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__inv_2
X_13694_ _05848_ _05979_ VGND VGND VPWR VPWR _05986_ sky130_fd_sc_hd__nand2_1
XFILLER_43_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15433_ _07620_ _07656_ _07657_ VGND VGND VPWR VPWR multiplier_inst.man_final\[11\]
+ sky130_fd_sc_hd__o21ai_1
X_12645_ _04225_ _04939_ _04943_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__o21a_1
XFILLER_31_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15364_ _07590_ _07591_ _07592_ _05718_ VGND VGND VPWR VPWR _07593_ sky130_fd_sc_hd__a31o_1
X_12576_ _04873_ _04872_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__nand2_1
X_14315_ _06549_ _06552_ _06555_ VGND VGND VPWR VPWR _06556_ sky130_fd_sc_hd__a21boi_1
X_11527_ _03824_ _03822_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__nand2_1
XFILLER_11_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15295_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r _07526_ net104 VGND VGND
+ VPWR VPWR _07527_ sky130_fd_sc_hd__o31a_1
X_14246_ _06460_ VGND VGND VPWR VPWR _06487_ sky130_fd_sc_hd__buf_2
X_11458_ _03724_ _03727_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__nand2_1
X_14177_ _06418_ VGND VGND VPWR VPWR _06419_ sky130_fd_sc_hd__inv_2
X_10409_ _02706_ _02707_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__nand2_1
X_11389_ _03564_ _03545_ _03550_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__nand3_1
X_13128_ _05425_ _05422_ VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__nand2_1
XFILLER_87_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13059_ _05356_ _05357_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__nand2_1
XFILLER_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09221_ _01518_ _01519_ VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__nand2_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09152_ _00649_ _01449_ _01450_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08103_ _07873_ VGND VGND VPWR VPWR _07874_ sky130_fd_sc_hd__inv_2
X_09083_ _01380_ _01381_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__nand2_1
X_08034_ net201 net158 VGND VGND VPWR VPWR _07805_ sky130_fd_sc_hd__nand2_1
XFILLER_107_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09985_ _02282_ _02269_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__nand2_1
XFILLER_103_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08936_ _01234_ _01139_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08867_ _01165_ _01160_ VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__nand2_1
XFILLER_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08798_ _01082_ _01083_ _01080_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__a21o_1
XFILLER_44_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10760_ _03058_ _03023_ _03025_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__nand3_1
X_09419_ _01714_ _01716_ _01717_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__nand3_1
X_10691_ net131 net212 VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__nand2_1
XFILLER_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12430_ _04728_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__inv_2
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14100_ _06231_ _06355_ VGND VGND VPWR VPWR _06356_ sky130_fd_sc_hd__nand2_1
XFILLER_20_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12361_ _00623_ _04629_ _04659_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__or3_1
X_15080_ _07327_ _07173_ VGND VGND VPWR VPWR _07329_ sky130_fd_sc_hd__nand2_1
X_11312_ _03454_ _03478_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__nand2_1
X_12292_ _04578_ _04590_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__nand2_1
X_14031_ _06291_ _06292_ _06293_ VGND VGND VPWR VPWR _06294_ sky130_fd_sc_hd__a21oi_1
X_11243_ _03539_ _03541_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__nand2_1
XFILLER_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11174_ _03471_ _03472_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__nand2_1
X_15982_ clknet_leaf_7_clk net361 _00230_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_94_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10125_ _02422_ _02423_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__nand2_1
XFILLER_48_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10056_ _02344_ _02354_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__nand2_1
X_14933_ _07020_ VGND VGND VPWR VPWR _07173_ sky130_fd_sc_hd__buf_4
XFILLER_75_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14864_ _06970_ _07100_ VGND VGND VPWR VPWR _07101_ sky130_fd_sc_hd__xor2_1
X_13815_ adder_inst.exp_larger_r\[6\] VGND VGND VPWR VPWR _06090_ sky130_fd_sc_hd__inv_2
X_14795_ _07032_ _06857_ VGND VGND VPWR VPWR _07033_ sky130_fd_sc_hd__nand2_1
XFILLER_51_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13746_ _06016_ _06027_ VGND VGND VPWR VPWR _06028_ sky130_fd_sc_hd__and2b_1
X_10958_ net122 net224 VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__nand2_1
X_13677_ _05968_ _05969_ VGND VGND VPWR VPWR _05970_ sky130_fd_sc_hd__nand2_1
XFILLER_92_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15416_ _05800_ VGND VGND VPWR VPWR _07641_ sky130_fd_sc_hd__inv_2
X_12628_ _04926_ VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__inv_2
X_10889_ _03186_ _03187_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__nand2_1
X_15347_ _02945_ _07563_ _07572_ _07573_ VGND VGND VPWR VPWR _07574_ sky130_fd_sc_hd__a22o_1
X_12559_ _04718_ _04853_ _04857_ VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__nand3b_1
Xhold106 mul_res\[18\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
X_15278_ _07515_ VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14229_ _06454_ _06464_ _06466_ _06469_ VGND VGND VPWR VPWR _06470_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09770_ _02068_ _01986_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__nand2_1
XFILLER_100_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08721_ _01016_ _00816_ _01019_ VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__nand3_2
XFILLER_39_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08652_ _00942_ _00949_ _00950_ VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__nand3_1
XFILLER_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08583_ _00880_ _00881_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__nand2_1
XFILLER_34_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09204_ _00665_ _00718_ _01502_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__a21oi_1
XFILLER_10_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_118_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09135_ _01432_ _01433_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__nand2b_1
X_09066_ _07847_ _07746_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__nand2_1
X_08017_ _07785_ _07663_ _07654_ VGND VGND VPWR VPWR _07788_ sky130_fd_sc_hd__nand3_1
XFILLER_89_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09968_ _02266_ _02086_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__nand2_1
X_08919_ _01217_ _01206_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__nand2_1
X_09899_ _02196_ _02197_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__nand2_1
X_11930_ net186 net141 VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__nand2_1
XFILLER_27_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11861_ _04158_ _04159_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__nand2_1
XFILLER_33_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13600_ _05837_ _05838_ _05895_ VGND VGND VPWR VPWR _05896_ sky130_fd_sc_hd__nand3_1
X_14580_ _06792_ _06819_ VGND VGND VPWR VPWR _06820_ sky130_fd_sc_hd__nor2_1
XFILLER_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11792_ _04090_ VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__inv_2
X_10812_ _03037_ _03031_ VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__nand2_1
X_13531_ _05828_ _05829_ VGND VGND VPWR VPWR _05830_ sky130_fd_sc_hd__nand2_1
X_10743_ _03041_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__inv_2
XFILLER_25_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10674_ _02780_ _02709_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__nand2_1
X_15201_ _07452_ _07448_ _07453_ VGND VGND VPWR VPWR _07457_ sky130_fd_sc_hd__nand3_1
X_13462_ _05760_ VGND VGND VPWR VPWR _05761_ sky130_fd_sc_hd__inv_4
X_13393_ _05689_ _05691_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__nand2_1
X_12413_ _04656_ _04657_ _04711_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__nand3_2
X_15132_ _06626_ _07383_ VGND VGND VPWR VPWR _07384_ sky130_fd_sc_hd__xor2_1
X_12344_ _04642_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__inv_2
XFILLER_114_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15063_ _07308_ _07310_ VGND VGND VPWR VPWR _07311_ sky130_fd_sc_hd__nand2_1
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14014_ adder_inst.sum_raw_r\[6\] net255 VGND VGND VPWR VPWR _06278_ sky130_fd_sc_hd__nand2_1
X_12275_ _04573_ net179 net137 VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__and3_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11226_ _03410_ _03521_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__nand2_1
X_11157_ _03317_ _03455_ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__nand2_1
X_10108_ _02400_ _02402_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__nand2_1
X_15965_ clknet_leaf_25_clk net339 _00213_ VGND VGND VPWR VPWR adder_inst.man_a_r\[15\]
+ sky130_fd_sc_hd__dfrtp_4
X_11088_ _03385_ _03386_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__nand2_1
XFILLER_36_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15896_ clknet_leaf_6_clk net59 _00144_ VGND VGND VPWR VPWR adder_inst.i_b\[4\] sky130_fd_sc_hd__dfrtp_1
X_10039_ _02257_ _02302_ _02305_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__a21boi_1
X_14916_ _07001_ _06817_ VGND VGND VPWR VPWR _07155_ sky130_fd_sc_hd__nand2_1
XFILLER_63_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14847_ _06950_ VGND VGND VPWR VPWR _07083_ sky130_fd_sc_hd__inv_2
XFILLER_24_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14778_ _06992_ _06909_ _07017_ VGND VGND VPWR VPWR _07018_ sky130_fd_sc_hd__and3_1
X_13729_ _06010_ _06015_ VGND VGND VPWR VPWR _06016_ sky130_fd_sc_hd__or2_2
XFILLER_31_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09822_ _02078_ _02117_ _02120_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__a21boi_1
XFILLER_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09753_ _02028_ _02051_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__nand2_1
XFILLER_58_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08704_ _01000_ _01002_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__nand2_1
X_09684_ net145 net239 VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08635_ _00756_ _00759_ _00760_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__o21ai_1
XFILLER_81_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08566_ _00856_ _00864_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08497_ _00795_ VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__inv_2
XFILLER_89_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09118_ _01414_ _01407_ _01411_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__nand3_1
X_10390_ _02662_ _02687_ _02688_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09049_ _01346_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__inv_2
XFILLER_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12060_ _04357_ _04354_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__nand2_1
XFILLER_104_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11011_ net121 net231 VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__nand2_1
XFILLER_89_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15750_ net275 VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__inv_2
XFILLER_73_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12962_ _05259_ _05260_ VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__nand2_1
XFILLER_38_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15681_ net270 VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__inv_2
X_14701_ net234 _06550_ VGND VGND VPWR VPWR _06941_ sky130_fd_sc_hd__or2_1
X_12893_ _05180_ _05150_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__nand2_1
X_11913_ _04211_ _04148_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__nand2_1
X_14632_ _06660_ _03128_ VGND VGND VPWR VPWR _06872_ sky130_fd_sc_hd__nand2_1
XFILLER_45_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11844_ _04135_ _04142_ _04138_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__nand3_1
X_14563_ _06578_ _06584_ _06516_ VGND VGND VPWR VPWR _06803_ sky130_fd_sc_hd__nand3_1
XFILLER_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11775_ _04072_ _04073_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__nand2_1
XFILLER_13_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14494_ _06733_ VGND VGND VPWR VPWR _06734_ sky130_fd_sc_hd__inv_2
X_13514_ _05811_ _05812_ VGND VGND VPWR VPWR _05813_ sky130_fd_sc_hd__nand2_1
XFILLER_41_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10726_ _03024_ _02998_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__nand2_1
X_10657_ _02912_ _02940_ _02955_ VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__a21oi_1
X_13445_ _05742_ _05743_ VGND VGND VPWR VPWR _05744_ sky130_fd_sc_hd__nand2_1
Xclkload15 clknet_leaf_14_clk VGND VGND VPWR VPWR clkload15/Y sky130_fd_sc_hd__clkinv_8
XFILLER_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10588_ _02860_ _02886_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__nor2_1
X_16164_ clknet_leaf_14_clk _00017_ _00412_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_13376_ _04055_ _05674_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__xnor2_2
X_16095_ clknet_leaf_18_clk multiplier_inst.man_final\[21\] _00343_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[21\] sky130_fd_sc_hd__dfrtp_1
X_15115_ _07364_ _06609_ _06626_ VGND VGND VPWR VPWR _07365_ sky130_fd_sc_hd__nand3_1
X_12327_ net119 net198 VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__nand2_1
XFILLER_107_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15046_ _07287_ _07292_ VGND VGND VPWR VPWR adder_inst.sum_raw\[15\] sky130_fd_sc_hd__nand2_1
X_12258_ _04556_ net109 net205 VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__and3_1
XFILLER_96_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11209_ _03506_ _03416_ _03507_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__nand3_1
XFILLER_68_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12189_ _04486_ _04487_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__nand2_1
XFILLER_56_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15948_ clknet_leaf_12_clk adder_inst.sum_raw\[23\] _00196_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[23\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_47_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15879_ clknet_leaf_24_clk net11 _00127_ VGND VGND VPWR VPWR adder_inst.i_a\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_47_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08420_ _00718_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_63_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08351_ _00649_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__buf_6
XFILLER_20_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08282_ _00570_ _00577_ VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__xnor2_1
Xclkload9 clknet_leaf_24_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__clkinv_2
XFILLER_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout213 adder_inst.man_a_r\[12\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_8
Xfanout202 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout246 adder_inst.man_a_r\[1\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout235 net237 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_4
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout279 net307 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__buf_2
X_09805_ _02102_ _02103_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__nand2_1
Xfanout257 adder_inst.sum_raw_r\[18\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_4
Xfanout268 net307 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
X_07997_ _07767_ _07750_ VGND VGND VPWR VPWR _07768_ sky130_fd_sc_hd__nand2_1
X_09736_ adder_inst.man_a_r\[8\] net165 VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__nand2_1
XFILLER_39_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09667_ _01965_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__inv_2
XFILLER_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08618_ _00915_ _00916_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__nand2_1
XFILLER_15_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09598_ _01895_ _01896_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08549_ _00823_ _00821_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__nor2_1
X_11560_ _03381_ _03378_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__nand2_1
XFILLER_24_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10511_ net169 VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__inv_2
XFILLER_109_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13230_ _05526_ _05527_ _05528_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__nand3_1
X_11491_ _03789_ _03234_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__nand2_1
X_10442_ _02727_ _02739_ _02740_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10373_ net234 net174 VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__nand2_1
X_13161_ _03323_ _04560_ _05386_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__o21ai_1
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13092_ _05389_ _05385_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__nand2_1
X_12112_ _04409_ _04410_ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__nand2_1
XFILLER_78_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12043_ _04337_ _04340_ _04341_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__nand3_1
XFILLER_77_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15802_ net285 VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__inv_2
X_15733_ net293 VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__inv_2
X_13994_ _06066_ _06259_ VGND VGND VPWR VPWR _06260_ sky130_fd_sc_hd__nand2_1
XFILLER_46_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12945_ _05242_ _05238_ _05239_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__nand3b_1
X_15664_ net276 VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__inv_2
XFILLER_45_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12876_ _05172_ _05170_ _05101_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__nand3_1
X_14615_ _06853_ _06854_ VGND VGND VPWR VPWR _06855_ sky130_fd_sc_hd__nand2_1
X_15595_ net264 VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__inv_2
X_11827_ _04125_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__inv_2
XFILLER_33_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14546_ _06550_ _06497_ VGND VGND VPWR VPWR _06786_ sky130_fd_sc_hd__nand2_1
X_11758_ _04056_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__inv_2
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10709_ _03007_ _03003_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__nand2_1
X_14477_ _06550_ _04651_ VGND VGND VPWR VPWR _06717_ sky130_fd_sc_hd__nand2_1
X_11689_ _03984_ _03987_ VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__nand2_1
X_13428_ _05725_ _05726_ VGND VGND VPWR VPWR _05727_ sky130_fd_sc_hd__nand2_1
X_16147_ clknet_leaf_19_clk _00030_ _00395_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
X_13359_ _05623_ _05657_ VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__xnor2_1
XFILLER_114_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16078_ clknet_leaf_20_clk multiplier_inst.man_final\[4\] _00326_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_07920_ net188 net176 VGND VGND VPWR VPWR _07370_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_110_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15029_ _06777_ VGND VGND VPWR VPWR _07274_ sky130_fd_sc_hd__inv_2
XFILLER_83_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput2 i_a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
X_09521_ _01771_ _01775_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__nand2_1
XFILLER_52_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09452_ _01750_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__inv_2
X_09383_ _01680_ _01681_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__nand2_1
X_08403_ _00700_ _00701_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__nand2_1
XFILLER_52_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08334_ _00632_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_22_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08265_ _00561_ _00447_ _00451_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__nand3_1
XFILLER_118_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08196_ _00494_ _07829_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09719_ _02001_ _02006_ _02017_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_58_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10991_ _03287_ _03285_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__nand2_1
XFILLER_43_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12730_ _04928_ _05028_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__nand2_1
XFILLER_82_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12661_ _01042_ _04661_ _04959_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__or3_1
XFILLER_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14400_ _06638_ VGND VGND VPWR VPWR _06640_ sky130_fd_sc_hd__inv_2
X_11612_ net220 VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__inv_2
X_15380_ _07607_ _07603_ _07604_ VGND VGND VPWR VPWR _07609_ sky130_fd_sc_hd__mux2_1
X_12592_ _04889_ _04890_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__nand2_1
XFILLER_30_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14331_ _06563_ net127 VGND VGND VPWR VPWR _06571_ sky130_fd_sc_hd__nand2_1
XFILLER_7_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11543_ _03768_ _03838_ _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__nand3_1
X_14262_ _04097_ _01422_ _06448_ VGND VGND VPWR VPWR _06503_ sky130_fd_sc_hd__mux2_1
X_11474_ net184 net152 VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__nand2_1
X_10425_ _02722_ _02723_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__nand2_1
XFILLER_109_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14193_ _06417_ _06402_ _06413_ VGND VGND VPWR VPWR _06435_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16001_ clknet_1_0__leaf_clk adder_inst.i_b\[17\] _00249_ VGND VGND VPWR VPWR adder_inst.man_b_r\[17\]
+ sky130_fd_sc_hd__dfrtp_2
X_13213_ _05511_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__inv_2
XFILLER_109_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13144_ _05442_ VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__inv_2
X_10356_ _02564_ _02562_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__nand2_1
X_10287_ _02511_ _02500_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__and2_1
X_13075_ _05372_ _05373_ VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__nor2_1
XFILLER_111_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12026_ _04322_ _04323_ _04324_ VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__a21o_1
XFILLER_93_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13977_ adder_inst.sum_raw_r\[6\] net252 _06083_ adder_inst.sum_raw_r\[5\] VGND VGND
+ VPWR VPWR _06245_ sky130_fd_sc_hd__a22o_1
X_15716_ net298 VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__inv_2
XFILLER_46_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12928_ _05034_ VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__inv_2
XFILLER_19_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15647_ net266 VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__inv_2
XFILLER_61_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12859_ net107 net222 VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__nand2_1
XFILLER_33_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15578_ net271 VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_60_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14529_ _06764_ _06768_ VGND VGND VPWR VPWR _06769_ sky130_fd_sc_hd__nand2_1
X_08050_ _07820_ _07765_ VGND VGND VPWR VPWR _07821_ sky130_fd_sc_hd__nand2_1
X_08952_ _01239_ _01231_ _01236_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_71_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08883_ _01068_ _01071_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__nand2_1
X_07903_ net182 net170 VGND VGND VPWR VPWR _07190_ sky130_fd_sc_hd__nand2_2
XFILLER_69_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09504_ _01801_ _01802_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_55_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09435_ _01728_ _01731_ _01733_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__o21ai_1
XFILLER_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09366_ _01188_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_35_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09297_ _01588_ _01595_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__nand2_1
X_08317_ _00596_ _00615_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__nand2_1
X_08248_ _00546_ _07854_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__nand2_1
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10210_ _02508_ VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__inv_2
X_08179_ _00477_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__inv_2
XFILLER_106_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11190_ _03172_ _03173_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__nand2_1
X_10141_ _02424_ _02432_ _02435_ VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__nand3_1
X_10072_ _02369_ _02370_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_7_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13900_ _06123_ adder_inst.exp_larger_r\[5\] VGND VGND VPWR VPWR _06175_ sky130_fd_sc_hd__nand2_1
XFILLER_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14880_ _06996_ _07088_ _07116_ VGND VGND VPWR VPWR _07118_ sky130_fd_sc_hd__a21oi_1
X_13831_ adder_inst.exp_larger_r\[1\] adder_inst.exp_larger_r\[2\] VGND VGND VPWR
+ VPWR _06106_ sky130_fd_sc_hd__nand2_1
XFILLER_101_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13762_ _06038_ VGND VGND VPWR VPWR adder_inst.is_nan_b sky130_fd_sc_hd__inv_2
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10974_ _01426_ _03272_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__nand2_1
XFILLER_90_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15501_ net388 mul_res\[11\] net259 VGND VGND VPWR VPWR _07709_ sky130_fd_sc_hd__mux2_1
XFILLER_43_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12713_ _04931_ _05011_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__nand2_1
X_13693_ _05984_ _05940_ VGND VGND VPWR VPWR _05985_ sky130_fd_sc_hd__nand2_1
XFILLER_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15432_ _07651_ _07620_ VGND VGND VPWR VPWR _07657_ sky130_fd_sc_hd__nand2_1
X_12644_ _04940_ _04942_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__nand2_1
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15363_ _05711_ _05664_ VGND VGND VPWR VPWR _07592_ sky130_fd_sc_hd__or2_1
X_12575_ _04872_ _04873_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__nor2_1
X_14314_ _06554_ _00651_ VGND VGND VPWR VPWR _06555_ sky130_fd_sc_hd__nand2_1
XFILLER_7_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11526_ _03800_ _03822_ _03824_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__nand3_1
XFILLER_116_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15294_ _07525_ multiplier_inst.overflow_calc_r VGND VGND VPWR VPWR _07526_ sky130_fd_sc_hd__and2_1
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14245_ _06466_ _06478_ _06485_ VGND VGND VPWR VPWR _06486_ sky130_fd_sc_hd__o21ai_1
X_11457_ _03724_ _03727_ _03755_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__nand3_1
X_14176_ _05911_ _05904_ _06417_ _06405_ _05903_ VGND VGND VPWR VPWR _06418_ sky130_fd_sc_hd__a221oi_1
X_10408_ _02573_ _02601_ _02598_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__a21boi_1
X_11388_ _03551_ _03568_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__nand2_1
X_10339_ _02535_ _02530_ VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__nand2_1
XFILLER_98_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13127_ _05422_ _05425_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__or2_1
XFILLER_98_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13058_ _05334_ _05339_ _05337_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__a21boi_1
XFILLER_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12009_ net112 net220 VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__nand2_1
XFILLER_38_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09220_ _01516_ _01512_ _01513_ VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__nand3_1
XFILLER_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09151_ net112 net241 VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__nand2_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09082_ _01379_ _01369_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__nand2_1
X_08102_ _07864_ _07872_ VGND VGND VPWR VPWR _07873_ sky130_fd_sc_hd__nor2_1
X_08033_ _07803_ VGND VGND VPWR VPWR _07804_ sky130_fd_sc_hd__inv_2
Xinput60 i_b[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_89_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09984_ _02269_ _02282_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__or2_1
XFILLER_88_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08935_ _01142_ _01232_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08866_ _01160_ _01162_ _01164_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__nand3_1
X_08797_ _01087_ _01092_ _01095_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_84_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09418_ _01711_ _01559_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__nand2_1
XFILLER_80_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10690_ _02462_ _02988_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__nand2_2
XFILLER_9_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09349_ _01647_ _01263_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__nand2_1
XFILLER_40_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12360_ net119 net202 VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__nand2_1
X_11311_ _03609_ _03589_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__nand2_1
X_12291_ _04581_ _04589_ VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_95_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14030_ adder_inst.sum_raw_r\[11\] net251 _06200_ adder_inst.sum_raw_r\[10\] VGND
+ VGND VPWR VPWR _06293_ sky130_fd_sc_hd__a22o_1
X_11242_ _03520_ _03528_ _03540_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__a21oi_1
X_11173_ _03470_ _03466_ _03469_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__nand3b_1
XFILLER_106_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10124_ _02415_ _02406_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__nand2_1
XFILLER_0_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15981_ clknet_leaf_7_clk net348 _00229_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10055_ _02351_ _02353_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__nand2_1
X_14932_ _06725_ _07171_ VGND VGND VPWR VPWR _07172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14863_ _07084_ _06988_ _06983_ VGND VGND VPWR VPWR _07100_ sky130_fd_sc_hd__a21bo_1
XFILLER_75_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13814_ _06080_ _06088_ VGND VGND VPWR VPWR _06089_ sky130_fd_sc_hd__nand2_1
X_14794_ _06566_ _06859_ VGND VGND VPWR VPWR _07032_ sky130_fd_sc_hd__nand2_1
XFILLER_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13745_ _06025_ _06026_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] VGND VGND VPWR
+ VPWR _06027_ sky130_fd_sc_hd__and4b_1
XFILLER_16_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10957_ _03252_ _03255_ _03253_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__o21ai_1
X_13676_ _05848_ _05964_ VGND VGND VPWR VPWR _05969_ sky130_fd_sc_hd__nand2_1
X_15415_ _07634_ _05800_ VGND VGND VPWR VPWR _07640_ sky130_fd_sc_hd__nand2_1
X_12627_ _04925_ _04858_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__nand2_1
X_10888_ _03185_ _03181_ VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__nand2_1
XFILLER_31_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15346_ _07571_ _02959_ VGND VGND VPWR VPWR _07573_ sky130_fd_sc_hd__nand2_1
X_12558_ _04856_ _04851_ _04784_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__nand3_1
XFILLER_8_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold107 _07717_ VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
X_15277_ _07507_ multiplier_inst.man_final_r\[15\] _07508_ VGND VGND VPWR VPWR _07515_
+ sky130_fd_sc_hd__and3_1
X_11509_ _03801_ _03807_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12489_ _04787_ _04558_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__nand2_1
X_14228_ _06467_ _06468_ _06454_ VGND VGND VPWR VPWR _06469_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14159_ _05865_ _05857_ _06399_ _06400_ VGND VGND VPWR VPWR _06401_ sky130_fd_sc_hd__o31a_1
XFILLER_85_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08720_ _01017_ _01018_ VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__nand2_1
XFILLER_39_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08651_ _00940_ _00748_ _00747_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__nand3_1
XFILLER_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08582_ _00877_ _00878_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__nand2_1
XFILLER_81_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ _00567_ _00664_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__nor2_1
X_09134_ _00428_ _00433_ _00431_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_118_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09065_ _01360_ _01362_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__nand2_1
X_08016_ _07786_ _07672_ VGND VGND VPWR VPWR _07787_ sky130_fd_sc_hd__nand2_1
XFILLER_103_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09967_ net223 net171 VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__nand2_1
XFILLER_103_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08918_ _01213_ _01216_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__nand2_1
X_09898_ net151 net239 VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__nand2_1
XFILLER_84_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08849_ _01124_ _01147_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__nand2_1
XFILLER_17_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11860_ _04156_ _04147_ _04148_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__nand3_1
X_11791_ _03991_ _03979_ VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__nand2_1
X_10811_ _03098_ _03107_ _03100_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__nand3_1
X_13530_ _05690_ _05820_ VGND VGND VPWR VPWR _05829_ sky130_fd_sc_hd__nand2_1
X_10742_ net191 net158 VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__nand2_1
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10673_ _02714_ _02784_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__nand2_1
X_15200_ _07454_ _06671_ VGND VGND VPWR VPWR _07456_ sky130_fd_sc_hd__nand2_1
X_13461_ _05758_ _05759_ VGND VGND VPWR VPWR _05760_ sky130_fd_sc_hd__nand2_1
XFILLER_43_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13392_ _05690_ _05675_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__nand2_1
X_12412_ _04710_ _04709_ VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__nand2_1
X_15131_ _07380_ _07382_ VGND VGND VPWR VPWR _07383_ sky130_fd_sc_hd__nand2_1
X_12343_ _04640_ _04641_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__nand2_1
X_15062_ _07289_ _07274_ _07309_ VGND VGND VPWR VPWR _07310_ sky130_fd_sc_hd__o21a_1
X_12274_ _04569_ VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__inv_2
XFILLER_107_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14013_ _06056_ VGND VGND VPWR VPWR _06277_ sky130_fd_sc_hd__buf_2
X_11225_ _03419_ _03522_ _03523_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__nand3_1
X_11156_ _03316_ _03309_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__nand2_1
XFILLER_95_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10107_ _02404_ _02405_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__nand2_1
XFILLER_67_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15964_ clknet_leaf_24_clk net354 _00212_ VGND VGND VPWR VPWR adder_inst.man_a_r\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_11087_ _03371_ _03383_ _03373_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__nand3_1
X_10038_ _02335_ VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__inv_2
X_14915_ _07119_ _07004_ VGND VGND VPWR VPWR _07154_ sky130_fd_sc_hd__nand2_1
XFILLER_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15895_ clknet_leaf_5_clk net58 _00143_ VGND VGND VPWR VPWR adder_inst.i_b\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14846_ _07077_ _07082_ VGND VGND VPWR VPWR adder_inst.sum_raw\[5\] sky130_fd_sc_hd__nand2_1
XFILLER_91_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14777_ _07016_ adder_inst.sum_raw\[0\] VGND VGND VPWR VPWR _07017_ sky130_fd_sc_hd__nor2_1
XFILLER_63_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_102_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13728_ _06011_ _06012_ _06013_ _06014_ VGND VGND VPWR VPWR _06015_ sky130_fd_sc_hd__or4_1
X_11989_ _04128_ _04122_ VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__nand2_1
XFILLER_16_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13659_ _05951_ VGND VGND VPWR VPWR _05952_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_42_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15329_ _02907_ _02968_ VGND VGND VPWR VPWR _07554_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_113_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09821_ _02118_ _02119_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__nand2_1
X_09752_ _02050_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__inv_2
XFILLER_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08703_ _01001_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__inv_2
XFILLER_100_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09683_ _01981_ _01783_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08634_ _00768_ _00754_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__nand2_1
X_08565_ _00863_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__inv_2
XFILLER_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08496_ _00794_ _00517_ _00740_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__nand3_2
XFILLER_10_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09117_ _01412_ _01415_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__nand2_1
XFILLER_108_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09048_ _01345_ _01346_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__nand2_1
XFILLER_2_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11010_ net116 net232 VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__nand2_1
XFILLER_104_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12961_ _05255_ _05176_ _05257_ VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__nand3_1
XFILLER_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15680_ net270 VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__inv_2
X_14700_ _06938_ _06551_ _06939_ VGND VGND VPWR VPWR _06940_ sky130_fd_sc_hd__nand3_1
X_12892_ _05190_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__inv_2
X_11912_ _04156_ _04149_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__or2_1
XFILLER_73_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14631_ _06869_ _06870_ _06568_ VGND VGND VPWR VPWR _06871_ sky130_fd_sc_hd__nand3_1
XFILLER_45_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11843_ _04140_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__inv_2
XFILLER_33_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14562_ _06660_ VGND VGND VPWR VPWR _06802_ sky130_fd_sc_hd__buf_2
XFILLER_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11774_ _04071_ _04066_ _04067_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__nand3b_1
X_14493_ _06731_ _06732_ VGND VGND VPWR VPWR _06733_ sky130_fd_sc_hd__nand2_1
X_13513_ _05690_ _05792_ VGND VGND VPWR VPWR _05812_ sky130_fd_sc_hd__nand2_1
XFILLER_9_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10725_ _03022_ _03019_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__nand2_1
XFILLER_13_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10656_ _02952_ _02954_ _02940_ VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__nand3_1
X_13444_ _05369_ VGND VGND VPWR VPWR _05743_ sky130_fd_sc_hd__inv_2
X_16163_ clknet_leaf_14_clk _00016_ _00411_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
Xclkload16 clknet_leaf_15_clk VGND VGND VPWR VPWR clkload16/X sky130_fd_sc_hd__clkbuf_4
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10587_ _02884_ _02877_ _02885_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__a21oi_1
X_15114_ _07347_ _06608_ VGND VGND VPWR VPWR _07364_ sky130_fd_sc_hd__or2b_1
X_13375_ _05673_ _03879_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__nand2_1
X_16094_ clknet_leaf_20_clk multiplier_inst.man_final\[20\] _00342_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[20\] sky130_fd_sc_hd__dfrtp_1
X_12326_ _04623_ _04624_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__nand2_1
X_15045_ _07291_ _07042_ VGND VGND VPWR VPWR _07292_ sky130_fd_sc_hd__nand2_1
X_12257_ _04553_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__inv_2
X_12188_ _04475_ _04484_ _04481_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__nand3_1
X_11208_ _03413_ _03505_ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__nand2_1
XFILLER_95_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11139_ _03267_ _03270_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__nand2_1
X_15947_ clknet_leaf_18_clk adder_inst.sum_raw\[22\] _00195_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15878_ clknet_leaf_24_clk net10 _00126_ VGND VGND VPWR VPWR adder_inst.i_a\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_48_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14829_ _07062_ _07064_ VGND VGND VPWR VPWR _07065_ sky130_fd_sc_hd__nand2_1
XFILLER_63_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08350_ _00648_ VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_63_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08281_ _00569_ _00578_ _00579_ VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__nand3_1
XFILLER_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout203 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_2
Xfanout214 net217 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
Xfanout236 net237 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__buf_2
XFILLER_113_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout247 net248 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_4
X_09804_ _01899_ _01906_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__xor2_1
Xfanout225 adder_inst.man_a_r\[8\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_74_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout269 net279 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_4
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_4
X_07996_ _07766_ VGND VGND VPWR VPWR _07767_ sky130_fd_sc_hd__inv_2
X_09735_ _02033_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__inv_2
X_09666_ _01945_ _01939_ _01964_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__a21oi_2
XFILLER_67_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08617_ _00914_ _00911_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__nand2_1
X_09597_ _01736_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__inv_2
XFILLER_42_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08548_ _00846_ _00717_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__nand2_1
X_08479_ _00771_ _00774_ _00777_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__nand3b_1
XFILLER_23_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10510_ net168 _02807_ net242 _02808_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__a31oi_1
X_11490_ _03787_ _03788_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__nand2_1
X_10441_ _02738_ _02734_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__nand2_1
XFILLER_10_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10372_ _02547_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__inv_2
X_13160_ _03323_ _04582_ _05458_ VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__nor3_1
X_13091_ _05385_ _05389_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__or2_1
X_12111_ _04407_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__inv_2
X_12042_ _04196_ _04189_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__nand2_1
XFILLER_104_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13993_ adder_inst.sum_raw_r\[4\] net256 VGND VGND VPWR VPWR _06259_ sky130_fd_sc_hd__nand2_1
XFILLER_77_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15801_ net284 VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__inv_2
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15732_ net300 VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__inv_2
X_12944_ _05240_ _05242_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__nand2_1
X_15663_ net276 VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__inv_2
XFILLER_46_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12875_ _05171_ _05173_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__nand2_1
X_14614_ _06568_ _01449_ VGND VGND VPWR VPWR _06854_ sky130_fd_sc_hd__nand2_1
X_15594_ net262 VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__inv_2
X_11826_ _03891_ net124 net213 _04124_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__a31o_1
XFILLER_81_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14545_ _06781_ _06553_ VGND VGND VPWR VPWR _06785_ sky130_fd_sc_hd__nand2_1
X_11757_ _03881_ _04055_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__nand2_1
X_10708_ _03003_ _03005_ _03006_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__nand3_1
X_14476_ _06700_ _06617_ _06715_ VGND VGND VPWR VPWR _06716_ sky130_fd_sc_hd__o21bai_1
X_11688_ _03985_ _03986_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__nand2_1
X_10639_ _02917_ _02937_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__nor2_1
X_13427_ _04528_ _05724_ VGND VGND VPWR VPWR _05726_ sky130_fd_sc_hd__or2b_1
X_16146_ clknet_leaf_19_clk _00029_ _00394_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
X_13358_ _05656_ _05627_ VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__nand2_1
X_16077_ clknet_leaf_20_clk multiplier_inst.man_final\[3\] _00325_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12309_ _04605_ _04606_ _04607_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__a21oi_1
X_15028_ _07272_ _06777_ VGND VGND VPWR VPWR _07273_ sky130_fd_sc_hd__nand2_1
X_13289_ _05562_ _05587_ _05575_ VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_110_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09520_ _01818_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__inv_2
Xinput3 i_a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09451_ adder_inst.man_b_r\[7\] net228 VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__nand2_1
X_09382_ _01646_ _01255_ _01263_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__nand3_1
X_08402_ net121 net241 VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08333_ net117 net241 VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__nand2_1
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08264_ _00452_ _00562_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__nand2_1
X_08195_ _07828_ _07833_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__nand2_1
XFILLER_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09718_ _02015_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__inv_2
XFILLER_74_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07979_ _07749_ VGND VGND VPWR VPWR _07750_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_87_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10990_ _03279_ VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__inv_2
XFILLER_28_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09649_ _01947_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__inv_2
XFILLER_55_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12660_ net120 net206 VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__nand2_1
X_11611_ _03731_ net117 net216 VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__nand3_1
XFILLER_35_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14330_ _06567_ _04629_ _06569_ VGND VGND VPWR VPWR _06570_ sky130_fd_sc_hd__mux2_1
X_12591_ _04888_ _04880_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__nand2_1
XFILLER_11_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11542_ _03839_ _03840_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__nand2_1
X_14261_ _06484_ _06495_ _06487_ _06501_ VGND VGND VPWR VPWR _06502_ sky130_fd_sc_hd__o211ai_1
XFILLER_7_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11473_ _03220_ _03771_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__nand2_1
X_10424_ _02680_ _02721_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_98_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14192_ _06433_ VGND VGND VPWR VPWR _06434_ sky130_fd_sc_hd__inv_2
X_16000_ clknet_leaf_25_clk net350 _00248_ VGND VGND VPWR VPWR adder_inst.man_b_r\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_13212_ _05436_ _05434_ VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13143_ _05411_ _05409_ VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__nand2_1
X_10355_ _02653_ _02578_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__nand2_1
XFILLER_105_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10286_ _02247_ _02584_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__nand2_1
X_13074_ _05224_ _05233_ VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__nand2_1
XFILLER_104_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12025_ _04163_ _04132_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_29_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13976_ _06221_ net253 _06113_ _06216_ _06065_ VGND VGND VPWR VPWR _06244_ sky130_fd_sc_hd__a221o_1
XFILLER_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15715_ net296 VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__inv_2
X_12927_ _05029_ _05033_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__nand2_1
X_15646_ net266 VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__inv_2
XFILLER_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12858_ _05155_ _05156_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__nand2_1
X_11809_ _04105_ _04107_ VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_1_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15577_ net290 VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_60_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12789_ _05078_ _05087_ VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__nand2_1
XFILLER_119_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14528_ _06766_ _06767_ VGND VGND VPWR VPWR _06768_ sky130_fd_sc_hd__nand2_1
X_14459_ _06693_ _06698_ VGND VGND VPWR VPWR _06699_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16129_ clknet_leaf_12_clk _00086_ _00377_ VGND VGND VPWR VPWR mul_res\[22\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08951_ _01248_ _01249_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__nand2_1
XFILLER_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08882_ _01175_ _01178_ _01180_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__o21a_1
X_07902_ net185 net176 VGND VGND VPWR VPWR _07180_ sky130_fd_sc_hd__nand2_1
XFILLER_111_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09503_ _01605_ _01580_ _01599_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__nand3_1
X_09434_ _01732_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_56_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09365_ _01663_ _00651_ _01066_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__o21ai_1
XFILLER_40_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09296_ _01590_ _01592_ _01594_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__a21oi_1
X_08316_ _00614_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08247_ _00545_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_65_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08178_ _00472_ _00474_ _00476_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__a21o_1
XFILLER_97_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10140_ _02429_ _02438_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__nand2_1
XFILLER_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10071_ _02364_ _02365_ _02367_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_7_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13830_ _06103_ _06104_ VGND VGND VPWR VPWR _06105_ sky130_fd_sc_hd__nand2_1
XFILLER_90_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13761_ _06008_ _06023_ VGND VGND VPWR VPWR _06038_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_74_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10973_ _03258_ VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__inv_2
X_15500_ _07707_ VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12712_ _05006_ _05009_ _05010_ VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__nand3_2
X_13692_ _05983_ VGND VGND VPWR VPWR _05984_ sky130_fd_sc_hd__inv_2
X_15431_ _07653_ _07655_ VGND VGND VPWR VPWR _07656_ sky130_fd_sc_hd__nand2_1
XFILLER_62_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12643_ _04941_ VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__inv_2
X_15362_ _02805_ _00651_ _05681_ VGND VGND VPWR VPWR _07591_ sky130_fd_sc_hd__or3_1
X_12574_ _04807_ _04804_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__and2_1
XFILLER_30_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15293_ multiplier_inst.is_zero_r VGND VGND VPWR VPWR _07525_ sky130_fd_sc_hd__clkinv_4
X_14313_ _06553_ VGND VGND VPWR VPWR _06554_ sky130_fd_sc_hd__clkbuf_4
XFILLER_7_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11525_ _03823_ _03808_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__nand2_1
X_14244_ _06483_ _06484_ VGND VGND VPWR VPWR _06485_ sky130_fd_sc_hd__nand2_1
XFILLER_7_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11456_ _03753_ _03754_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__nand2_1
X_14175_ _06416_ _06400_ VGND VGND VPWR VPWR _06417_ sky130_fd_sc_hd__and2b_1
X_10407_ _02614_ _02612_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__nand2_1
X_11387_ _03570_ _03685_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__nand2_1
X_10338_ _02633_ _02630_ _02636_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__a21oi_1
X_13126_ _05423_ _05424_ VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__nand2_1
XFILLER_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13057_ _05354_ _05351_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__nand2_1
X_10269_ _02565_ _02513_ _02515_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__nand3_1
XFILLER_78_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12008_ _00650_ _03911_ _04153_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__or3_1
XFILLER_66_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13959_ _06189_ VGND VGND VPWR VPWR _06229_ sky130_fd_sc_hd__inv_2
XFILLER_81_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15629_ net288 VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__inv_2
XFILLER_61_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09150_ net244 VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_32_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09081_ _01369_ _01379_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__or2_1
X_08101_ net143 net211 VGND VGND VPWR VPWR _07872_ sky130_fd_sc_hd__nand2_1
X_08032_ _07802_ _07720_ VGND VGND VPWR VPWR _07803_ sky130_fd_sc_hd__nand2_1
Xinput50 i_b[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
Xinput61 i_b[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_09983_ _02270_ _02082_ _02267_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__o21ai_1
XFILLER_103_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08934_ _01142_ _01232_ _01140_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08865_ _01163_ _01156_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__nand2_1
XFILLER_57_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08796_ _01090_ _00843_ _01094_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__nand3_1
XFILLER_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09417_ _01715_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__inv_2
XFILLER_25_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09348_ _01646_ _01255_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__nand2_1
XFILLER_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09279_ _01575_ _01576_ _01577_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__nand3_2
X_11310_ _03589_ _03591_ _03592_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__nand3_1
XFILLER_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12290_ _04588_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_95_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11241_ _03519_ _03517_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__nor2_1
XFILLER_4_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11172_ _03466_ _03469_ _03470_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__a21bo_1
X_10123_ _02419_ _02421_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__nand2_1
X_15980_ clknet_leaf_7_clk net359 _00228_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_10054_ _02349_ _02352_ _02106_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__nand3_1
X_14931_ _07170_ _06698_ VGND VGND VPWR VPWR _07171_ sky130_fd_sc_hd__nand2_1
X_14862_ _07092_ _07099_ VGND VGND VPWR VPWR adder_inst.sum_raw\[6\] sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_82_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13813_ _06074_ _06086_ _06087_ VGND VGND VPWR VPWR _06088_ sky130_fd_sc_hd__and3_1
XFILLER_75_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14793_ _06908_ _06860_ VGND VGND VPWR VPWR _07031_ sky130_fd_sc_hd__xnor2_1
XFILLER_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13744_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _06026_ sky130_fd_sc_hd__and4_1
X_10956_ _03253_ _03254_ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__nand2_1
X_13675_ _05940_ _05967_ VGND VGND VPWR VPWR _05968_ sky130_fd_sc_hd__nand2_1
X_10887_ _03181_ _03185_ VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__or2_1
X_15414_ _07639_ VGND VGND VPWR VPWR multiplier_inst.man_final\[8\] sky130_fd_sc_hd__clkbuf_1
X_12626_ _04924_ _04718_ VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__nand2_1
X_15345_ _02962_ _07565_ _07569_ _07571_ VGND VGND VPWR VPWR _07572_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_91_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12557_ _04854_ _04855_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__nand2_1
XFILLER_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold108 adder_inst.is_nan_a_r VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
X_15276_ _07514_ VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__buf_1
X_11508_ _03805_ _03806_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__nand2_1
X_12488_ _04715_ _04716_ VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__nand2_1
X_14227_ _06448_ _00651_ VGND VGND VPWR VPWR _06468_ sky130_fd_sc_hd__nand2_1
X_11439_ _03736_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__inv_2
X_14158_ _05863_ _05857_ _05854_ VGND VGND VPWR VPWR _06400_ sky130_fd_sc_hd__o21a_1
XFILLER_112_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13109_ _05400_ _05407_ VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__or2_1
X_14089_ adder_inst.sum_raw_r\[13\] net255 VGND VGND VPWR VPWR _06346_ sky130_fd_sc_hd__nand2_1
XFILLER_79_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08650_ _00944_ _00946_ _00948_ VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__a21oi_1
XFILLER_39_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08581_ _00875_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__inv_2
XFILLER_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09202_ _01500_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__inv_2
X_09133_ _01430_ _01431_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_118_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09064_ _01303_ _01360_ _01362_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__nand3_1
X_08015_ _07785_ _07654_ VGND VGND VPWR VPWR _07786_ sky130_fd_sc_hd__nand2_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09966_ _02264_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__inv_2
XFILLER_103_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09897_ _02192_ _02195_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08917_ _01214_ _01215_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__nand2_1
XFILLER_57_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08848_ _01133_ _01144_ _01146_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__a21boi_1
XFILLER_84_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08779_ _01044_ _01075_ _01077_ VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__nand3b_1
X_11790_ _04087_ _04088_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__nand2_1
X_10810_ _03101_ _03108_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__nand2_1
X_10741_ _01321_ _03039_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__nand2_1
X_13460_ _05756_ _05371_ _05037_ VGND VGND VPWR VPWR _05759_ sky130_fd_sc_hd__nand3_1
XFILLER_40_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10672_ _02792_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__inv_2
X_12411_ _04682_ _04708_ _04709_ VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__nand3_1
Xclkbuf_leaf_20_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
X_13391_ _05663_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__buf_6
X_15130_ _06605_ _06604_ VGND VGND VPWR VPWR _07382_ sky130_fd_sc_hd__or2_1
X_12342_ _04633_ _04635_ _04638_ VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__nand3_1
X_15061_ _06764_ _06775_ VGND VGND VPWR VPWR _07309_ sky130_fd_sc_hd__nand2_1
X_12273_ _04571_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__inv_2
XFILLER_107_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14012_ _06276_ VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11224_ _03428_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__inv_2
X_11155_ _03441_ _03453_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__nand2_1
XFILLER_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10106_ _02397_ _02387_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__nand2_1
X_15963_ clknet_leaf_0_clk net313 _00211_ VGND VGND VPWR VPWR adder_inst.man_a_r\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_11086_ _03374_ _03384_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__nand2_1
X_10037_ _02307_ _02335_ VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__nand2_1
X_14914_ _07150_ _07152_ VGND VGND VPWR VPWR _07153_ sky130_fd_sc_hd__xor2_1
XFILLER_76_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15894_ clknet_leaf_6_clk net55 _00142_ VGND VGND VPWR VPWR adder_inst.i_b\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_75_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14845_ _07080_ _07081_ _06019_ VGND VGND VPWR VPWR _07082_ sky130_fd_sc_hd__a21o_1
XFILLER_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14776_ _06857_ _06859_ VGND VGND VPWR VPWR _07016_ sky130_fd_sc_hd__nand2_2
X_11988_ _04285_ _04286_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_102_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13727_ adder_inst.i_a\[9\] adder_inst.i_a\[8\] adder_inst.i_a\[11\] adder_inst.i_a\[10\]
+ VGND VGND VPWR VPWR _06014_ sky130_fd_sc_hd__or4_1
X_10939_ _03236_ _03230_ _03232_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__nand3b_2
XFILLER_16_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13658_ _05949_ _05950_ VGND VGND VPWR VPWR _05951_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_42_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_13589_ _07159_ _05876_ _05841_ VGND VGND VPWR VPWR _05886_ sky130_fd_sc_hd__nor3_1
X_12609_ _04906_ _04907_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__and2b_1
X_15328_ _07552_ _02781_ VGND VGND VPWR VPWR _07553_ sky130_fd_sc_hd__nand2_1
XFILLER_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15259_ _07492_ multiplier_inst.man_final_r\[7\] _07494_ VGND VGND VPWR VPWR _07503_
+ sky130_fd_sc_hd__and3_1
XFILLER_98_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09820_ _02106_ _02111_ _02112_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__a21o_1
X_09751_ _02038_ _02046_ _02049_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__a21oi_2
XFILLER_86_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08702_ net145 net226 VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__nand2_1
X_09682_ _01980_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_68_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08633_ _00930_ _00931_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__nand2_1
X_08564_ _00857_ _00860_ _00862_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__o21ai_1
XFILLER_35_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08495_ _00793_ _00768_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__nand2_1
XFILLER_22_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09116_ _01414_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__inv_2
X_09047_ net201 net149 VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_92_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09949_ _02241_ _02247_ VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__nand2_1
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12960_ _05256_ _05258_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__nand2_1
XFILLER_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12891_ _05186_ _05189_ VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__nand2_1
X_11911_ _04173_ _04168_ VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__nand2_1
X_14630_ _06617_ _06700_ _06547_ VGND VGND VPWR VPWR _06870_ sky130_fd_sc_hd__nand3_1
X_11842_ _04139_ _04140_ VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__nand2_1
X_14561_ _06797_ _06800_ VGND VGND VPWR VPWR _06801_ sky130_fd_sc_hd__nand2_1
XFILLER_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13512_ _05681_ _05810_ VGND VGND VPWR VPWR _05811_ sky130_fd_sc_hd__nand2_1
XFILLER_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11773_ _04068_ _04071_ VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__nand2_1
X_14492_ _06550_ _04568_ VGND VGND VPWR VPWR _06732_ sky130_fd_sc_hd__nand2_1
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10724_ _02998_ _03019_ _03022_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__nand3b_1
XFILLER_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10655_ _02953_ _02949_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_11_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13443_ _04550_ _05741_ VGND VGND VPWR VPWR _05742_ sky130_fd_sc_hd__nand2_1
X_16162_ clknet_leaf_13_clk _00015_ _00410_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
Xclkload17 clknet_leaf_16_clk VGND VGND VPWR VPWR clkload17/Y sky130_fd_sc_hd__inv_12
XFILLER_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13374_ _05672_ _03881_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__nand2_1
X_10586_ _02883_ _02864_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__nor2_1
X_15113_ _07352_ _07363_ VGND VGND VPWR VPWR adder_inst.sum_raw\[18\] sky130_fd_sc_hd__nand2_1
X_12325_ _04622_ _04616_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__nand2_1
XFILLER_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16093_ clknet_leaf_20_clk multiplier_inst.man_final\[19\] _00341_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[19\] sky130_fd_sc_hd__dfrtp_1
X_15044_ _06777_ _07290_ VGND VGND VPWR VPWR _07291_ sky130_fd_sc_hd__xor2_1
X_12256_ _04554_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__inv_2
X_12187_ _04482_ _04485_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__nand2_1
X_11207_ _03505_ _03413_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__or2_1
XFILLER_95_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11138_ _03436_ _03430_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__nand2_1
X_15946_ clknet_leaf_18_clk adder_inst.sum_raw\[21\] _00194_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[21\]
+ sky130_fd_sc_hd__dfrtp_2
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_49_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11069_ _03363_ _03367_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__or2_1
XFILLER_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15877_ clknet_leaf_24_clk net9 _00125_ VGND VGND VPWR VPWR adder_inst.i_a\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14828_ _06877_ _06873_ _07063_ VGND VGND VPWR VPWR _07064_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_47_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14759_ _06995_ _06996_ _06998_ VGND VGND VPWR VPWR _06999_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_63_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08280_ _00577_ _00570_ VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__nand2_1
XFILLER_32_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout204 net206 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_4
Xfanout237 adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_4
XFILLER_115_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09803_ _01921_ _01919_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_74_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout215 net217 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout226 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_4
Xfanout248 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_4
Xfanout259 net261 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07995_ net204 net152 VGND VGND VPWR VPWR _07766_ sky130_fd_sc_hd__nand2_1
X_09734_ net228 net159 VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__nand2_1
XFILLER_86_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09665_ _01928_ _01926_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__nor2_1
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08616_ _00911_ _00914_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__or2_1
XFILLER_82_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09596_ _01880_ _01726_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__nand2_1
XFILLER_55_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08547_ _00844_ _00845_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__nand2_1
X_08478_ _00775_ _00776_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10440_ _02734_ _02738_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__nor2_1
XFILLER_109_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10371_ net167 net236 VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__nand2_1
XFILLER_108_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13090_ _05387_ _05388_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__nand2_1
X_12110_ _01483_ _01480_ _01482_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__a21boi_1
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12041_ _04338_ _04339_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__nand2_1
XFILLER_104_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13992_ _06258_ VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_77_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15800_ net284 VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__inv_2
XFILLER_65_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15731_ net293 VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__inv_2
XFILLER_105_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12943_ _04305_ _05241_ _04307_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__o21a_1
X_15662_ net276 VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__inv_2
XFILLER_65_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12874_ _05172_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__inv_2
XFILLER_33_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15593_ net266 VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__inv_2
X_14613_ _06846_ _06847_ _06551_ VGND VGND VPWR VPWR _06853_ sky130_fd_sc_hd__nand3_1
XFILLER_60_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11825_ _03710_ _03889_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__nor2_1
XFILLER_14_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14544_ _06782_ _06783_ VGND VGND VPWR VPWR _06784_ sky130_fd_sc_hd__nand2_1
XFILLER_41_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11756_ _04052_ _04054_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__nand2_1
XFILLER_14_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14475_ _06713_ _06714_ VGND VGND VPWR VPWR _06715_ sky130_fd_sc_hd__nand2_1
X_10707_ _02999_ _03001_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__nand2_1
XFILLER_14_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13426_ _05724_ _04528_ VGND VGND VPWR VPWR _05725_ sky130_fd_sc_hd__or2b_1
X_11687_ net195 net137 VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__nand2_1
X_10638_ _02936_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__inv_2
X_10569_ _02865_ _02867_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__or2_1
X_16145_ clknet_leaf_19_clk _00028_ _00393_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
X_13357_ _05585_ _05591_ _05629_ VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__a21o_1
XFILLER_114_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16076_ clknet_leaf_20_clk multiplier_inst.man_final\[2\] _00324_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
X_13288_ _05582_ _05586_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__nand2_1
X_12308_ _04580_ net192 net125 VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__and3_1
X_15027_ _07271_ _06788_ VGND VGND VPWR VPWR _07272_ sky130_fd_sc_hd__nand2_1
X_12239_ _04345_ _04348_ _04342_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_110_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15929_ clknet_leaf_8_clk adder_inst.sum_raw\[4\] _00177_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[4\]
+ sky130_fd_sc_hd__dfrtp_4
Xinput4 i_a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_09450_ _01746_ _01748_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__nand2_1
X_08401_ net117 net244 VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__nand2_1
XFILLER_52_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09381_ _01647_ _01649_ VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__nand2_1
XFILLER_51_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08332_ net116 net244 VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08263_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__inv_2
X_08194_ _00464_ _00492_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07978_ net201 net155 VGND VGND VPWR VPWR _07749_ sky130_fd_sc_hd__nand2_1
X_09717_ _02007_ _02015_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__nand2_1
XFILLER_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_87_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09648_ _01943_ _01946_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__nand2_1
XFILLER_55_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09579_ _01876_ _01877_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__nand2_1
XFILLER_43_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12590_ _04880_ _04888_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__or2_1
X_11610_ net115 net222 VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__nand2_1
XFILLER_30_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11541_ _03215_ _03242_ _03239_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__a21boi_1
XFILLER_23_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14260_ _06446_ _06500_ VGND VGND VPWR VPWR _06501_ sky130_fd_sc_hd__or2_1
XFILLER_51_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11472_ _03770_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__inv_2
X_10423_ _02680_ _02721_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__or2_1
X_14191_ _05858_ _06432_ VGND VGND VPWR VPWR _06433_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_98_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13211_ _05441_ _05509_ VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__nand2_1
X_10354_ _02652_ _02576_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__nand2_1
X_13142_ _05416_ _05440_ VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__nand2b_1
X_10285_ _02246_ _02244_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__nand2_1
X_13073_ _05370_ _05371_ VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__nand2_1
XFILLER_104_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12024_ _04320_ _04317_ _04318_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__nand3_2
XFILLER_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13975_ _06196_ _06062_ _06066_ _06241_ _06242_ VGND VGND VPWR VPWR _06243_ sky130_fd_sc_hd__o2111a_1
X_15714_ net296 VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_57_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12926_ _05219_ _05217_ _05214_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__a21boi_1
XFILLER_34_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15645_ net266 VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__inv_2
XFILLER_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12857_ _05154_ _05072_ _05152_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__nand3b_1
XFILLER_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11808_ _04092_ _04093_ _04106_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__nand3_1
X_15576_ net273 VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_60_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12788_ _05086_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__inv_2
X_14527_ _06637_ _04661_ VGND VGND VPWR VPWR _06767_ sky130_fd_sc_hd__nand2_1
XFILLER_41_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11739_ _04022_ _04037_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__nand2_1
X_14458_ _06695_ _06697_ VGND VGND VPWR VPWR _06698_ sky130_fd_sc_hd__nand2_1
X_13409_ _02986_ _05707_ _02454_ VGND VGND VPWR VPWR _05708_ sky130_fd_sc_hd__o21ai_1
X_14389_ _06607_ _06625_ _06623_ VGND VGND VPWR VPWR _06629_ sky130_fd_sc_hd__a21oi_1
X_16128_ clknet_leaf_18_clk _00085_ _00376_ VGND VGND VPWR VPWR mul_res\[21\] sky130_fd_sc_hd__dfrtp_1
X_16059_ clknet_leaf_8_clk net365 _00307_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_102_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08950_ _00966_ _00951_ _01216_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__nand3_1
X_07901_ _07159_ VGND VGND VPWR VPWR _07169_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_71_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08881_ _01179_ _01052_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__or2_1
XFILLER_111_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09502_ _01763_ _01765_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__nand2_1
XFILLER_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09433_ net223 net159 VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_111_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09364_ net126 VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_82_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08315_ _00603_ _00611_ _00613_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__a21oi_1
X_09295_ _01593_ _01129_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__nor2_1
XFILLER_20_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08246_ net134 net226 VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__nand2_1
X_08177_ _00475_ _07790_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__nor2_1
X_10070_ _02366_ _02368_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_7_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13760_ _06033_ _06036_ _06037_ VGND VGND VPWR VPWR multiplier_inst.overflow_calc
+ sky130_fd_sc_hd__o21bai_1
XFILLER_55_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10972_ net122 net226 VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__nand2_1
X_13691_ _05981_ _05982_ VGND VGND VPWR VPWR _05983_ sky130_fd_sc_hd__nand2_1
XFILLER_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12711_ _04954_ _04955_ _05004_ VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__nand3_2
X_15430_ _07647_ _05752_ VGND VGND VPWR VPWR _07655_ sky130_fd_sc_hd__nand2_1
XFILLER_43_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12642_ net184 net141 VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__nand2_1
XFILLER_15_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15361_ _07542_ _07589_ VGND VGND VPWR VPWR _07590_ sky130_fd_sc_hd__nor2_1
X_12573_ _04870_ _04871_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__nand2_1
X_15292_ multiplier_inst.is_nan_r _07524_ net104 VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__o21a_1
X_14312_ _06414_ VGND VGND VPWR VPWR _06553_ sky130_fd_sc_hd__buf_2
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11524_ _03820_ _03821_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__nand2_1
X_14243_ _06465_ VGND VGND VPWR VPWR _06484_ sky130_fd_sc_hd__buf_2
XFILLER_7_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11455_ _03751_ _03741_ _03742_ VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__nand3_1
X_10406_ _02701_ _02704_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__nor2_1
X_14174_ _06415_ _05864_ _05856_ VGND VGND VPWR VPWR _06416_ sky130_fd_sc_hd__and3_1
X_11386_ _03684_ _03664_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__nand2_1
XFILLER_97_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10337_ _02634_ _02635_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__nand2_1
X_13125_ net111 net193 net114 net190 VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__a22o_1
XFILLER_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10268_ _02516_ _02566_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__nand2_1
X_13056_ _05349_ _05351_ _05354_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__nand3_1
X_12007_ _04305_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__inv_2
X_10199_ _02497_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__inv_2
XFILLER_38_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13958_ adder_inst.sum_raw_r\[5\] VGND VGND VPWR VPWR _06228_ sky130_fd_sc_hd__inv_2
XFILLER_81_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12909_ _05132_ _05207_ VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__nand2_1
XFILLER_34_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13889_ adder_inst.exp_larger_r\[7\] _06077_ _06074_ VGND VGND VPWR VPWR _06164_
+ sky130_fd_sc_hd__o21ai_1
X_15628_ net295 VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__inv_2
XFILLER_61_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15559_ net265 VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_32_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09080_ _01377_ _01378_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__nand2_1
X_08100_ _07865_ _07867_ _07870_ VGND VGND VPWR VPWR _07871_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_661 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput40 i_b[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
X_08031_ net200 net161 VGND VGND VPWR VPWR _07802_ sky130_fd_sc_hd__nand2_1
Xinput51 i_b[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
Xinput62 i_b[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09982_ _02279_ _02280_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__nand2_1
XFILLER_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08933_ _01138_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__inv_2
XFILLER_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08864_ _01159_ _01007_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__nand2_1
XFILLER_84_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08795_ _00912_ _01093_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_84_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09416_ net215 net168 VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__nand2_1
XFILLER_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09347_ _01644_ _01645_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__nand2_1
XFILLER_52_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09278_ _01553_ _01225_ VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__nand2_1
XFILLER_21_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08229_ _00527_ _07885_ _00523_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__nand3_1
XFILLER_106_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11240_ _03538_ _03178_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__nand2_1
X_11171_ net106 net241 VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__nand2_1
X_10122_ _02136_ _02142_ _02420_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__nand3_1
XFILLER_79_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10053_ _02111_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__inv_2
XFILLER_88_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14930_ _07156_ _07150_ VGND VGND VPWR VPWR _07170_ sky130_fd_sc_hd__nand2_1
XFILLER_75_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14861_ _07096_ _07098_ _06019_ VGND VGND VPWR VPWR _07099_ sky130_fd_sc_hd__a21o_1
XFILLER_48_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13812_ adder_inst.exp_larger_r\[0\] _06085_ VGND VGND VPWR VPWR _06087_ sky130_fd_sc_hd__or2_1
XFILLER_75_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14792_ _07026_ _07030_ VGND VGND VPWR VPWR adder_inst.sum_raw\[1\] sky130_fd_sc_hd__nand2_1
XFILLER_63_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13743_ adder_inst.exp_a\[3\] adder_inst.exp_a\[2\] VGND VGND VPWR VPWR _06025_ sky130_fd_sc_hd__nand2_1
XFILLER_90_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10955_ _01384_ _03061_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__nand2_1
X_13674_ _05965_ _05966_ VGND VGND VPWR VPWR _05967_ sky130_fd_sc_hd__nand2_1
XFILLER_73_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10886_ _03012_ _03182_ _03184_ VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15413_ _07638_ _07631_ _07604_ VGND VGND VPWR VPWR _07639_ sky130_fd_sc_hd__mux2_1
X_12625_ _04853_ _04857_ VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__nand2_1
XFILLER_31_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15344_ _07570_ VGND VGND VPWR VPWR _07571_ sky130_fd_sc_hd__inv_2
X_12556_ _04786_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__inv_2
XFILLER_8_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11507_ _03194_ _03803_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__nand2_1
XFILLER_11_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15275_ _07507_ multiplier_inst.man_final_r\[14\] _07508_ VGND VGND VPWR VPWR _07514_
+ sky130_fd_sc_hd__and3_1
XFILLER_7_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12487_ _04784_ _04785_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__nand2_1
Xhold109 add_res\[15\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
X_14226_ _06414_ _02805_ VGND VGND VPWR VPWR _06467_ sky130_fd_sc_hd__nand2_1
X_11438_ _03735_ _03736_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__nand2_1
X_14157_ _05650_ _07128_ _07097_ VGND VGND VPWR VPWR _06399_ sky130_fd_sc_hd__o21a_1
X_11369_ _03650_ _03655_ _03667_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13108_ _05406_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__inv_2
X_14088_ _06345_ VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13039_ _05334_ _05337_ VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__nand2_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08580_ _00875_ _00877_ _00878_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_37_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09201_ _00654_ _00643_ _00642_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09132_ _01429_ _01424_ _01427_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_118_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09063_ _01361_ _01333_ _01338_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__nand3_1
XFILLER_118_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08014_ _07784_ _07577_ VGND VGND VPWR VPWR _07785_ sky130_fd_sc_hd__nand2_1
XFILLER_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09965_ _02262_ _02263_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nor2b_1
XFILLER_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09896_ _02193_ _02194_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08916_ _00960_ _00958_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__nand2_1
XFILLER_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08847_ _01145_ _00981_ _01135_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__nand3_1
XFILLER_18_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08778_ _01076_ _01048_ _01047_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__nand3_1
XFILLER_25_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10740_ net185 net164 VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__nand2_1
X_10671_ _02899_ _02969_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__nand2_1
XFILLER_40_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12410_ _04683_ _04706_ _04610_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__nand3_1
X_13390_ _05681_ _05688_ VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__nand2_1
X_12341_ _04636_ _04639_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__nand2_1
X_15060_ _07264_ _06790_ _06777_ VGND VGND VPWR VPWR _07308_ sky130_fd_sc_hd__nand3_1
X_12272_ net183 net131 VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__nand2_1
XFILLER_107_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14011_ _06192_ _06193_ _06275_ VGND VGND VPWR VPWR _06276_ sky130_fd_sc_hd__and3_1
XFILLER_4_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11223_ _03521_ _03409_ _03082_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__nand3_1
XFILLER_4_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11154_ _03452_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__inv_2
X_10105_ _02401_ _02403_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__nand2_1
X_15962_ clknet_leaf_0_clk net325 _00210_ VGND VGND VPWR VPWR adder_inst.man_a_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_68_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11085_ _03383_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__inv_2
XFILLER_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10036_ _02332_ _02334_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__nand2_1
X_14913_ _07151_ _06819_ VGND VGND VPWR VPWR _07152_ sky130_fd_sc_hd__nand2_1
X_15893_ clknet_leaf_6_clk net44 _00141_ VGND VGND VPWR VPWR adder_inst.i_b\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_48_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14844_ _07079_ _06949_ VGND VGND VPWR VPWR _07081_ sky130_fd_sc_hd__nand2_1
XFILLER_84_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14775_ _06679_ _07014_ VGND VGND VPWR VPWR _07015_ sky130_fd_sc_hd__nand2_1
X_11987_ _04284_ _04281_ _04282_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__nand3b_1
XFILLER_90_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13726_ adder_inst.i_a\[13\] adder_inst.i_a\[12\] adder_inst.i_a\[15\] adder_inst.i_a\[14\]
+ VGND VGND VPWR VPWR _06013_ sky130_fd_sc_hd__or4_1
X_10938_ _03233_ _03236_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__nand2_1
XFILLER_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13657_ _05947_ adder_inst.exp_b_r\[6\] VGND VGND VPWR VPWR _05950_ sky130_fd_sc_hd__nand2_1
X_10869_ _03117_ _03104_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__nand2_1
X_13588_ _05848_ _05884_ VGND VGND VPWR VPWR _05885_ sky130_fd_sc_hd__nand2_1
X_12608_ _04905_ _04868_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_42_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15327_ _02975_ _07551_ VGND VGND VPWR VPWR _07552_ sky130_fd_sc_hd__or2_1
X_12539_ _04825_ _04835_ _04826_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__nand3_1
X_15258_ _07502_ VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__clkbuf_1
X_14209_ net165 net240 _06448_ VGND VGND VPWR VPWR _06450_ sky130_fd_sc_hd__mux2_1
X_15189_ _07390_ _06651_ VGND VGND VPWR VPWR _07443_ sky130_fd_sc_hd__nand2_1
XFILLER_113_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09750_ _02048_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__inv_2
X_09681_ net148 net239 VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__nand2_1
X_08701_ _00808_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__inv_2
XFILLER_39_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08632_ _00927_ _00798_ _00831_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__nand3_1
XFILLER_94_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08563_ _00861_ _00679_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__nand2_1
XFILLER_23_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08494_ _00768_ _00754_ _00765_ VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__nand3_1
XFILLER_35_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09115_ _07850_ _00446_ _01413_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_79_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09046_ _01343_ _01344_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_92_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09948_ _02244_ _02246_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__or2_1
XFILLER_77_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09879_ _02175_ _02177_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__nand2_1
X_12890_ _05187_ _05188_ VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__nand2_1
X_11910_ _04200_ _04181_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__nand2_1
X_11841_ net115 net220 VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__nand2_1
X_14560_ _06798_ _06799_ VGND VGND VPWR VPWR _06800_ sky130_fd_sc_hd__nand2_1
X_11772_ _03970_ _04069_ _04070_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13511_ _05809_ VGND VGND VPWR VPWR _05810_ sky130_fd_sc_hd__inv_2
X_10723_ _03020_ _03021_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__nand2_1
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14491_ _06730_ _06553_ VGND VGND VPWR VPWR _06731_ sky130_fd_sc_hd__nand2_1
X_10654_ _02915_ _02939_ VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__nand2_1
XFILLER_41_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13442_ _05361_ VGND VGND VPWR VPWR _05741_ sky130_fd_sc_hd__inv_2
X_16161_ clknet_leaf_13_clk _00014_ _00409_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
X_10585_ _02864_ _02883_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__nand2_1
XFILLER_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13373_ _02989_ _04529_ _04492_ _04536_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__a31o_1
Xclkload18 clknet_leaf_17_clk VGND VGND VPWR VPWR clkload18/Y sky130_fd_sc_hd__inv_12
X_15112_ _07361_ _07362_ _06000_ VGND VGND VPWR VPWR _07363_ sky130_fd_sc_hd__a21o_1
X_12324_ _04616_ _04622_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__or2_1
X_16092_ clknet_leaf_20_clk multiplier_inst.man_final\[18\] _00340_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15043_ _07288_ _07289_ VGND VGND VPWR VPWR _07290_ sky130_fd_sc_hd__nand2_1
X_12255_ _00649_ _04552_ _04553_ VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__o21ai_1
XFILLER_107_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12186_ _04484_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__inv_2
X_11206_ _03414_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__inv_2
XFILLER_110_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11137_ _03434_ _03338_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__nand2_1
XFILLER_110_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15945_ clknet_leaf_18_clk adder_inst.sum_raw\[20\] _00193_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11068_ _03364_ _03366_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__nand2_1
X_10019_ _02264_ _02277_ _02275_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__a21boi_1
XFILLER_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15876_ clknet_leaf_24_clk net8 _00124_ VGND VGND VPWR VPWR adder_inst.i_a\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_19_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14827_ _06881_ _07051_ VGND VGND VPWR VPWR _07063_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_47_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14758_ _06983_ _06997_ _06963_ VGND VGND VPWR VPWR _06998_ sky130_fd_sc_hd__o21ai_1
XFILLER_63_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13709_ adder_inst.sign_b_r adder_inst.sign_a_r VGND VGND VPWR VPWR _05998_ sky130_fd_sc_hd__xnor2_2
X_14689_ _06569_ net237 VGND VGND VPWR VPWR _06929_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout205 net206 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__clkbuf_4
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09802_ _02090_ _02095_ _02100_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__a21boi_1
XFILLER_86_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout238 net240 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_4
Xfanout227 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_2
Xfanout216 net217 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout249 adder_inst.sum_raw_r\[24\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_4
X_07994_ net207 net149 VGND VGND VPWR VPWR _07765_ sky130_fd_sc_hd__nand2_1
X_09733_ _02031_ _01901_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__nand2_1
X_09664_ _01959_ _01962_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__nand2_1
XFILLER_55_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09595_ _01891_ _01893_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__nand2_1
X_08615_ _00912_ _00913_ VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__nand2_1
XFILLER_27_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08546_ _00715_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__inv_2
XFILLER_23_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08477_ net211 net157 VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__nand2_1
XFILLER_10_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10370_ _02667_ _02668_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__nand2_1
XFILLER_109_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09029_ _01318_ _01327_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__nand2_1
XFILLER_2_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12040_ _04199_ _04184_ _04181_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__a21boi_1
XFILLER_77_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13991_ _06192_ _06193_ _06257_ VGND VGND VPWR VPWR _06258_ sky130_fd_sc_hd__and3_1
X_15730_ net300 VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__inv_2
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12942_ _04309_ VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__inv_2
X_15661_ net278 VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__inv_2
XFILLER_73_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14612_ _06851_ VGND VGND VPWR VPWR _06852_ sky130_fd_sc_hd__inv_2
XFILLER_45_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12873_ _04286_ _04282_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__nand2_1
XFILLER_33_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15592_ net265 VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__inv_2
XFILLER_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11824_ _04121_ _04122_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__nand2_1
X_14543_ _06553_ _04552_ VGND VGND VPWR VPWR _06783_ sky130_fd_sc_hd__nand2_1
X_11755_ _04053_ _04047_ _04049_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__nand3_1
X_14474_ _06520_ VGND VGND VPWR VPWR _06714_ sky130_fd_sc_hd__clkbuf_4
X_10706_ _03004_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__inv_2
X_13425_ _04489_ _04533_ _02989_ _04492_ VGND VGND VPWR VPWR _05724_ sky130_fd_sc_hd__a22o_1
X_11686_ net198 net135 VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__nand2_1
X_10637_ _02935_ _02934_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13356_ _05653_ _05654_ VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__nand2_1
X_10568_ _02866_ _02807_ VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__nand2_1
X_16144_ clknet_leaf_19_clk _00027_ _00392_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
X_10499_ _02719_ _02715_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__nand2_1
X_16075_ clknet_leaf_18_clk multiplier_inst.man_final\[1\] _00323_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_13287_ _05574_ VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__inv_2
X_12307_ _04241_ _01663_ _04579_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__o21ai_1
X_15026_ _07253_ _07248_ VGND VGND VPWR VPWR _07271_ sky130_fd_sc_hd__nand2_1
X_12238_ _04347_ _04208_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_110_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12169_ _04463_ _04456_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__nand2_1
XFILLER_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15928_ clknet_1_0__leaf_clk adder_inst.sum_raw\[3\] _00176_ VGND VGND VPWR VPWR
+ adder_inst.sum_raw_r\[3\] sky130_fd_sc_hd__dfrtp_4
XFILLER_83_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput5 i_a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_37_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15859_ clknet_leaf_13_clk net65 _00107_ VGND VGND VPWR VPWR adder_inst.i_vld sky130_fd_sc_hd__dfrtp_1
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08400_ _00698_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__inv_2
X_09380_ _01677_ _01678_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__nand2_1
XFILLER_64_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08331_ _00628_ _00629_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__nand2_1
XFILLER_20_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08262_ _00521_ _00559_ _00560_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08193_ _00479_ _00490_ _00491_ VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_76_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07977_ net204 net149 VGND VGND VPWR VPWR _07748_ sky130_fd_sc_hd__nand2_1
X_09716_ _02013_ _02014_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__nand2_1
XFILLER_28_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09647_ _01944_ _01939_ _01945_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__nand3_1
XFILLER_70_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09578_ _01524_ _01526_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__nand2_1
XFILLER_35_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08529_ _00822_ _00823_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__nand2_1
X_11540_ _03836_ _03837_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__nand2_1
XFILLER_23_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11471_ net181 net152 VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__nand2_1
X_10422_ net162 net243 VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__nand2_1
X_14190_ _06430_ _06431_ _06413_ VGND VGND VPWR VPWR _06432_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13210_ _05440_ _05416_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__nand2b_1
X_10353_ _02567_ _02568_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__nand2_1
X_13141_ _05439_ _05419_ VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__nand2_1
X_13072_ _04923_ VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__inv_2
X_10284_ _02580_ _02306_ _02582_ VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__nand3_1
XFILLER_97_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12023_ _04319_ _04321_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__nand2_1
XFILLER_2_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13974_ adder_inst.sum_raw_r\[2\] net257 VGND VGND VPWR VPWR _06242_ sky130_fd_sc_hd__nand2_1
X_15713_ net296 VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__inv_2
XFILLER_18_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12925_ _05211_ _05223_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__xor2_2
XFILLER_92_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15644_ net269 VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__inv_2
X_12856_ _05153_ _05154_ VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__nand2_1
XFILLER_33_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15575_ net274 VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11807_ _04104_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__inv_2
XFILLER_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14526_ _06765_ _06558_ VGND VGND VPWR VPWR _06766_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12787_ _05079_ _05085_ VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__xor2_1
XFILLER_41_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11738_ _04036_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__inv_2
X_14457_ _06569_ _06688_ _06696_ VGND VGND VPWR VPWR _06697_ sky130_fd_sc_hd__o21ai_1
X_11669_ net186 net144 VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__nand2_1
X_13408_ _02978_ VGND VGND VPWR VPWR _05707_ sky130_fd_sc_hd__inv_2
X_14388_ _06594_ _06627_ VGND VGND VPWR VPWR _06628_ sky130_fd_sc_hd__nand2_1
X_16127_ clknet_leaf_15_clk _00084_ _00375_ VGND VGND VPWR VPWR mul_res\[20\] sky130_fd_sc_hd__dfrtp_1
X_13339_ _05636_ _05637_ VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__or2_1
X_16058_ clknet_leaf_11_clk net353 _00306_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07900_ _07138_ _07149_ VGND VGND VPWR VPWR _07159_ sky130_fd_sc_hd__nand2_2
X_15009_ _07249_ _07250_ _07252_ VGND VGND VPWR VPWR _07253_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_71_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08880_ net139 net238 VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__nand2_1
XFILLER_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09501_ _01798_ _01799_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__nand2_1
XFILLER_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09432_ _01730_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__inv_2
X_09363_ _01185_ _01186_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__nand2_1
XFILLER_52_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08314_ _00612_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_82_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09294_ net157 net225 VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__nand2_1
XANTENNA_10 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08245_ net132 net229 VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__nand2_1
X_08176_ net197 net176 VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__nand2_1
XFILLER_87_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10971_ _03268_ _03269_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__nand2_1
X_13690_ _05978_ _05934_ _05963_ VGND VGND VPWR VPWR _05982_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_54_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12710_ _05008_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__inv_2
XFILLER_70_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12641_ _04225_ _04939_ VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__xor2_1
XFILLER_15_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15360_ _07549_ _07586_ _07587_ VGND VGND VPWR VPWR _07589_ sky130_fd_sc_hd__nand3b_1
X_12572_ net180 net124 net178 net127 VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__a22o_1
X_15291_ multiplier_inst.is_inf_r _07493_ multiplier_inst.man_final_r\[22\] VGND VGND
+ VPWR VPWR _07524_ sky130_fd_sc_hd__and3b_1
X_14311_ _06551_ VGND VGND VPWR VPWR _06552_ sky130_fd_sc_hd__clkbuf_4
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11523_ _03808_ _03820_ _03821_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__nand3b_1
X_14242_ _06479_ _06481_ _06482_ VGND VGND VPWR VPWR _06483_ sky130_fd_sc_hd__mux2_1
X_11454_ _03743_ _03752_ VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__nand2_1
X_10405_ _02703_ _02602_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__nand2_1
XFILLER_7_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14173_ _05649_ _07128_ _07117_ VGND VGND VPWR VPWR _06415_ sky130_fd_sc_hd__o21a_1
X_11385_ _03664_ _03669_ _03683_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__nand3_1
X_10336_ _02399_ _02414_ _02415_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__nand3b_1
X_13124_ _00649_ _04239_ _04895_ VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__or3_1
X_10267_ _02565_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__inv_2
XFILLER_105_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13055_ _05352_ _05353_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__nand2_1
XFILLER_78_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12006_ net106 net225 VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__nand2_1
X_10198_ _02485_ _02478_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__nand2_1
XFILLER_19_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13957_ adder_inst.sum_raw_r\[6\] VGND VGND VPWR VPWR _06227_ sky130_fd_sc_hd__inv_2
X_12908_ _05206_ VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__inv_2
X_13888_ adder_inst.exp_larger_r\[7\] _06096_ VGND VGND VPWR VPWR _06163_ sky130_fd_sc_hd__or2_1
X_15627_ net288 VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__inv_2
XFILLER_61_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12839_ _05109_ _05137_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__nand2_1
XFILLER_15_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15558_ net265 VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_32_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15489_ add_res\[5\] mul_res\[5\] net258 VGND VGND VPWR VPWR _07701_ sky130_fd_sc_hd__mux2_1
X_14509_ _06748_ _06660_ VGND VGND VPWR VPWR _06749_ sky130_fd_sc_hd__nand2_1
XFILLER_30_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 i_a[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
X_08030_ _07800_ _07732_ VGND VGND VPWR VPWR _07801_ sky130_fd_sc_hd__nor2_1
Xinput52 i_b[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
Xinput63 i_b[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
XFILLER_116_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput41 i_b[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
X_09981_ _02264_ _02275_ _02277_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__nand3_1
XFILLER_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08932_ _01222_ _01229_ _01230_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_4_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08863_ _01050_ _01161_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__xor2_1
X_08794_ _00851_ _00852_ _00896_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__nand3_1
XFILLER_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09415_ _01712_ _01713_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__nand2_1
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09346_ _01543_ _01253_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__nand2_1
X_09277_ _01552_ _01226_ _01224_ VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__nand3_1
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_695 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08228_ _00525_ VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__inv_2
XFILLER_119_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08159_ _00457_ _07843_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__nand2_1
X_11170_ _03468_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__inv_2
X_10121_ _02144_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__inv_2
X_10052_ _02350_ _02111_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__nand2_1
XFILLER_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14860_ _07095_ _06990_ VGND VGND VPWR VPWR _07098_ sky130_fd_sc_hd__nand2_1
XFILLER_75_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13811_ _06085_ adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR _06086_ sky130_fd_sc_hd__nand2_1
X_14791_ _07028_ _07029_ _06019_ VGND VGND VPWR VPWR _07030_ sky130_fd_sc_hd__a21o_1
XFILLER_75_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13742_ _06024_ VGND VGND VPWR VPWR adder_inst.is_inf_b sky130_fd_sc_hd__clkbuf_1
XFILLER_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10954_ _01385_ _03062_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__nand2_1
X_13673_ _05934_ _05963_ VGND VGND VPWR VPWR _05966_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10885_ _03009_ _03183_ VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__nand2_1
X_15412_ _07637_ VGND VGND VPWR VPWR _07638_ sky130_fd_sc_hd__inv_2
X_12624_ _04920_ _04922_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__nand2_1
XFILLER_12_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15343_ _02964_ _02962_ VGND VGND VPWR VPWR _07570_ sky130_fd_sc_hd__xnor2_1
X_12555_ _04789_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__inv_2
XFILLER_11_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11506_ _03802_ _03804_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__nand2_1
X_15274_ _07513_ VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__clkbuf_1
X_12486_ _04728_ _04782_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__nand2_1
X_14225_ _06465_ VGND VGND VPWR VPWR _06466_ sky130_fd_sc_hd__buf_2
XFILLER_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11437_ net116 net224 VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__nand2_1
X_14156_ _06398_ VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__inv_2
X_11368_ _03608_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__inv_2
X_10319_ _02379_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__inv_2
X_13107_ _05404_ _05405_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__nand2_1
XFILLER_3_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14087_ _06183_ _06190_ _06344_ VGND VGND VPWR VPWR _06345_ sky130_fd_sc_hd__and3_1
XFILLER_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11299_ _03594_ _03597_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__nand2_1
XFILLER_112_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13038_ _05335_ _05336_ VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__nand2_1
XFILLER_94_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14989_ _07231_ _07178_ VGND VGND VPWR VPWR _07232_ sky130_fd_sc_hd__nand2_1
XFILLER_19_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09200_ _01497_ _01498_ VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__nand2_1
XFILLER_22_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09131_ _01428_ _01429_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__nand2_1
X_09062_ _01359_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_118_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08013_ _07681_ VGND VGND VPWR VPWR _07784_ sky130_fd_sc_hd__inv_2
XFILLER_1_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09964_ _02261_ _02259_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__nand2_1
X_09895_ net156 net233 VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08915_ _00953_ _00956_ _00957_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__o21ai_1
XFILLER_57_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08846_ _01143_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__inv_2
XFILLER_85_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08777_ _01074_ _01061_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__nand2_1
XFILLER_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10670_ _02903_ _02907_ _02968_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__nand3_1
X_09329_ _01155_ _01153_ _01151_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__nand3b_1
XFILLER_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12340_ _04638_ VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__inv_2
XFILLER_119_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12271_ _03954_ _04568_ _04569_ VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__o21ai_1
X_14010_ net249 adder_inst.sum_raw_r\[11\] adder_inst.sum_raw_r\[10\] _06076_ _06274_
+ VGND VGND VPWR VPWR _06275_ sky130_fd_sc_hd__a221o_1
XFILLER_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11222_ _03418_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__inv_2
XFILLER_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11153_ _03451_ _03449_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__nand2_1
X_10104_ _02134_ _02122_ _02402_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__nand3_1
X_15961_ clknet_leaf_0_clk net340 _00209_ VGND VGND VPWR VPWR adder_inst.man_a_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_68_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11084_ _03381_ _03382_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__nand2_1
XFILLER_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15892_ clknet_leaf_5_clk net33 _00140_ VGND VGND VPWR VPWR adder_inst.i_b\[0\] sky130_fd_sc_hd__dfrtp_1
X_10035_ _02314_ _02333_ _02319_ VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__nand3_1
XFILLER_88_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14912_ _07000_ _07004_ VGND VGND VPWR VPWR _07151_ sky130_fd_sc_hd__nand2_1
X_14843_ _06949_ _07079_ VGND VGND VPWR VPWR _07080_ sky130_fd_sc_hd__or2_1
XFILLER_75_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14774_ _07008_ _07013_ VGND VGND VPWR VPWR _07014_ sky130_fd_sc_hd__nand2_1
XFILLER_63_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11986_ _04283_ _04284_ VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__nand2_1
XFILLER_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13725_ adder_inst.i_a\[1\] adder_inst.i_a\[2\] adder_inst.i_a\[4\] adder_inst.i_a\[7\]
+ VGND VGND VPWR VPWR _06012_ sky130_fd_sc_hd__or4_2
XFILLER_90_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10937_ _03129_ _03234_ _03235_ VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__o21ai_1
X_13656_ _05948_ VGND VGND VPWR VPWR _05949_ sky130_fd_sc_hd__inv_2
XFILLER_31_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12607_ _04868_ _04905_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__nor2_1
X_10868_ _03106_ _03115_ _03105_ VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_14_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13587_ _05883_ VGND VGND VPWR VPWR _05884_ sky130_fd_sc_hd__inv_2
XFILLER_83_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10799_ _03096_ _03097_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__nand2_1
X_15326_ _02970_ VGND VGND VPWR VPWR _07551_ sky130_fd_sc_hd__inv_2
X_12538_ _04827_ _04836_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__nand2_1
X_15257_ _07492_ multiplier_inst.man_final_r\[6\] _07494_ VGND VGND VPWR VPWR _07502_
+ sky130_fd_sc_hd__and3_1
X_12469_ _04761_ _04767_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__nand2_1
X_14208_ _02810_ _01448_ _06448_ VGND VGND VPWR VPWR _06449_ sky130_fd_sc_hd__mux2_1
X_15188_ _07441_ _07042_ VGND VGND VPWR VPWR _07442_ sky130_fd_sc_hd__nand2_1
X_14139_ _06389_ VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__inv_2
XFILLER_98_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09680_ net142 net242 VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__nand2_1
X_08700_ _00996_ _00998_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__nand2_1
XFILLER_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08631_ _00928_ _00929_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__nand2_1
XFILLER_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08562_ _00858_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__inv_2
X_08493_ _00791_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__inv_2
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09114_ _07845_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_79_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09045_ _07751_ _01341_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_92_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09947_ _02226_ _02245_ VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__xor2_1
XFILLER_77_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09878_ _02176_ _02156_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__nand2_1
XFILLER_72_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08829_ _01127_ _00978_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__nand2_1
XFILLER_57_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11840_ _04135_ _04138_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__nand2_1
XFILLER_60_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11771_ _03811_ _03968_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__nor2_1
X_13510_ _05577_ _05808_ VGND VGND VPWR VPWR _05809_ sky130_fd_sc_hd__xor2_1
X_10722_ _03008_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__inv_2
X_14490_ _06473_ _06631_ _06714_ _06729_ VGND VGND VPWR VPWR _06730_ sky130_fd_sc_hd__o211ai_2
XFILLER_41_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10653_ _02947_ _02951_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__nor2_1
X_13441_ _05706_ _05739_ VGND VGND VPWR VPWR _05740_ sky130_fd_sc_hd__nor2_1
X_10584_ _02874_ _02881_ _02882_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__a21oi_1
X_16160_ clknet_leaf_15_clk _00013_ _00408_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
X_13372_ _05662_ VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__inv_2
Xclkload19 clknet_leaf_18_clk VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__bufinv_16
X_15111_ _07359_ _07341_ VGND VGND VPWR VPWR _07362_ sky130_fd_sc_hd__nand2_1
X_16091_ clknet_leaf_20_clk multiplier_inst.man_final\[17\] _00339_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[17\] sky130_fd_sc_hd__dfrtp_1
X_12323_ _04618_ _04621_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__nand2_1
X_15042_ _06784_ _06787_ VGND VGND VPWR VPWR _07289_ sky130_fd_sc_hd__or2_1
XFILLER_107_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12254_ net113 net203 VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__nand2_1
X_12185_ _04483_ _04408_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__nand2_1
X_11205_ _03500_ _03503_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__nand2_1
X_11136_ _03431_ _03338_ _03434_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__nand3_1
XFILLER_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15944_ clknet_leaf_9_clk adder_inst.sum_raw\[19\] _00192_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[19\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_48_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11067_ _00623_ _01422_ _03365_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__o21ai_1
X_10018_ _02315_ _02316_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__nand2_1
X_15875_ clknet_leaf_0_clk net7 _00123_ VGND VGND VPWR VPWR adder_inst.i_a\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_64_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14826_ _07040_ _06908_ _06881_ VGND VGND VPWR VPWR _07062_ sky130_fd_sc_hd__nand3_1
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14757_ _06968_ VGND VGND VPWR VPWR _06997_ sky130_fd_sc_hd__inv_2
XFILLER_51_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13708_ _05997_ VGND VGND VPWR VPWR adder_inst.man_a\[23\] sky130_fd_sc_hd__buf_1
X_11969_ _04107_ _04264_ _04265_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__nand3b_1
X_14688_ _06927_ _06802_ VGND VGND VPWR VPWR _06928_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13639_ _05921_ _05932_ VGND VGND VPWR VPWR _05934_ sky130_fd_sc_hd__nor2_1
X_15309_ _02984_ _05707_ _02441_ VGND VGND VPWR VPWR _07532_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout228 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_4
X_09801_ _02096_ _02099_ VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__nand2_1
XFILLER_87_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout217 adder_inst.man_a_r\[11\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_74_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout206 adder_inst.man_a_r\[14\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__buf_4
XFILLER_5_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09732_ net225 net162 VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__nand2_1
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_4
X_07993_ _07758_ _07759_ _07763_ VGND VGND VPWR VPWR _07764_ sky130_fd_sc_hd__nand3_1
XFILLER_94_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09663_ _01960_ _01961_ VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__nand2_1
XFILLER_67_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09594_ _01889_ _01892_ _01767_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__nand3_1
X_08614_ _00849_ _00847_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__or2_1
XFILLER_27_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08545_ _00696_ _00716_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__nand2_1
X_08476_ net214 net153 VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__nand2_1
XFILLER_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09028_ _01320_ _01326_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__xor2_1
XFILLER_78_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13990_ net249 adder_inst.sum_raw_r\[9\] adder_inst.sum_raw_r\[8\] _06076_ _06256_
+ VGND VGND VPWR VPWR _06257_ sky130_fd_sc_hd__a221o_1
XFILLER_65_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12941_ _05238_ _05239_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__nand2_1
X_15660_ net293 VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__inv_2
XFILLER_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12872_ _05170_ _05101_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__nand2_1
X_14611_ _06849_ _06850_ VGND VGND VPWR VPWR _06851_ sky130_fd_sc_hd__nand2_1
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11823_ _04119_ _04116_ _04117_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__nand3_1
X_15591_ net266 VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__inv_2
X_14542_ _06781_ _06550_ VGND VGND VPWR VPWR _06782_ sky130_fd_sc_hd__nand2_1
X_11754_ _03873_ _03870_ _03869_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__a21boi_1
XFILLER_81_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14473_ _06707_ _06712_ _06473_ VGND VGND VPWR VPWR _06713_ sky130_fd_sc_hd__nand3_1
X_11685_ _03804_ _03983_ VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__nand2_1
X_10705_ net206 net140 VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10636_ _02933_ _02876_ _02934_ VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__nand3_1
X_13424_ _05718_ _05722_ VGND VGND VPWR VPWR _05723_ sky130_fd_sc_hd__nor2_1
X_16143_ clknet_leaf_19_clk _00026_ _00391_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
X_13355_ _05652_ _07159_ VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__nand2_1
X_10567_ _02808_ VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__inv_2
X_10498_ _02796_ _02777_ VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__nand2_1
X_16074_ clknet_leaf_18_clk multiplier_inst.man_final\[0\] _00322_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
X_13286_ _05384_ _05584_ VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__nand2_1
X_12306_ _04604_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__inv_2
XFILLER_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15025_ _07258_ _07270_ VGND VGND VPWR VPWR adder_inst.sum_raw\[14\] sky130_fd_sc_hd__nand2_1
X_12237_ _04534_ _04535_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_110_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12168_ _04454_ _04464_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__nand2_1
XFILLER_96_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11119_ _03415_ _03416_ _03417_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__a21oi_2
X_12099_ _04395_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__inv_2
XFILLER_110_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15927_ clknet_leaf_9_clk adder_inst.sum_raw\[2\] _00175_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
Xinput6 i_a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_64_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15858_ clknet_leaf_13_clk _00032_ _00106_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
X_15789_ net300 VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__inv_2
X_14809_ _07033_ _06900_ _06907_ VGND VGND VPWR VPWR _07046_ sky130_fd_sc_hd__a21bo_1
X_08330_ _00627_ _00618_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__nand2_1
X_08261_ _00520_ _00458_ VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__nor2_1
XFILLER_32_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08192_ _00477_ _00469_ _00468_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_76_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_535 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07976_ _07745_ _07746_ VGND VGND VPWR VPWR _07747_ sky130_fd_sc_hd__nand2_1
X_09715_ _02011_ _02009_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__nand2_1
XFILLER_27_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09646_ _01926_ _01928_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_87_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09577_ _01526_ _01524_ _01300_ VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__o21ai_1
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08528_ _00817_ _00825_ _00826_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__nand3b_1
XFILLER_11_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08459_ _00757_ _00480_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__nand2_1
XFILLER_11_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11470_ _03243_ _03239_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__nand2_1
X_10421_ net159 net245 VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__nand2_1
X_10352_ _02242_ _02650_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_98_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13140_ _05421_ _05438_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__or2_1
X_13071_ _05040_ VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__inv_2
X_10283_ _02581_ _02256_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__nand2_1
X_12022_ _04320_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13973_ _06232_ adder_inst.sum_raw_r\[1\] VGND VGND VPWR VPWR _06241_ sky130_fd_sc_hd__nand2_1
XFILLER_65_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15712_ net296 VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__inv_2
XFILLER_19_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12924_ _05221_ _05222_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_57_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15643_ net272 VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__inv_2
XFILLER_46_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12855_ _04294_ _04295_ _04299_ VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__o21a_1
XFILLER_33_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15574_ net273 VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11806_ _04094_ _04104_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__nand2_1
X_12786_ _05082_ _05084_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14525_ _06761_ _06762_ VGND VGND VPWR VPWR _06765_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11737_ _04034_ _04035_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__nand2_1
X_14456_ _06569_ adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR _06696_ sky130_fd_sc_hd__nand2_1
X_11668_ net192 net140 VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__nand2_1
X_10619_ net168 net247 VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__nand2_1
X_14387_ _06610_ _06626_ VGND VGND VPWR VPWR _06627_ sky130_fd_sc_hd__nor2_1
X_13407_ _05693_ _05705_ VGND VGND VPWR VPWR _05706_ sky130_fd_sc_hd__nand2_1
X_11599_ _03895_ _03897_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__nand2_1
X_16126_ clknet_leaf_15_clk _00082_ _00374_ VGND VGND VPWR VPWR mul_res\[19\] sky130_fd_sc_hd__dfrtp_1
X_13338_ _05595_ _05613_ _05611_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__o21ba_1
X_16057_ clknet_leaf_8_clk net367 _00305_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_15008_ _06740_ _07251_ _06755_ VGND VGND VPWR VPWR _07252_ sky130_fd_sc_hd__o21ai_1
X_13269_ _05567_ _04910_ VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__nand2_1
XFILLER_44_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09500_ _01774_ _01776_ _01796_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__nand3_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09431_ _01729_ _01564_ VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09362_ _01659_ _01660_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__nand2_1
XFILLER_52_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08313_ _00598_ _00592_ _00601_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_35_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09293_ _01591_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__inv_2
XANTENNA_11 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08244_ _00534_ _00542_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__nand2_1
XFILLER_21_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08175_ _00473_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__inv_2
XFILLER_118_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07959_ _07617_ _07708_ _07626_ VGND VGND VPWR VPWR _07714_ sky130_fd_sc_hd__nand3_1
XFILLER_16_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10970_ _03266_ _03264_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__nand2_1
X_09629_ _01904_ _01900_ _01902_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__a21oi_2
XFILLER_83_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12640_ net179 net147 VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__nand2_1
XFILLER_70_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14310_ _06550_ VGND VGND VPWR VPWR _06551_ sky130_fd_sc_hd__clkbuf_4
XFILLER_62_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12571_ _03954_ _04869_ _04731_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__or3_1
XFILLER_23_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15290_ _07522_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__clkbuf_1
X_11522_ _03819_ _03814_ _03815_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__nand3b_1
XFILLER_109_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14241_ _06453_ VGND VGND VPWR VPWR _06482_ sky130_fd_sc_hd__buf_4
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11453_ _03751_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__inv_2
X_10404_ _02702_ _02574_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__nand2_1
X_14172_ _06413_ VGND VGND VPWR VPWR _06414_ sky130_fd_sc_hd__inv_2
XFILLER_109_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13123_ adder_inst.man_b_r\[23\] net196 VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__nand2_1
X_11384_ _03681_ _03682_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__nand2_1
X_10335_ _02416_ _02399_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__nand2_1
X_10266_ _02540_ _02563_ _02564_ VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__o21ai_1
XFILLER_87_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13054_ _05209_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__inv_2
XFILLER_105_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12005_ _04301_ _04303_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__nand2_1
X_10197_ _02217_ _02495_ VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__nand2_1
XFILLER_78_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13956_ _06221_ net251 _06223_ _06224_ _06225_ VGND VGND VPWR VPWR _06226_ sky130_fd_sc_hd__a221o_1
XFILLER_81_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13887_ _06096_ adder_inst.exp_larger_r\[7\] VGND VGND VPWR VPWR _06162_ sky130_fd_sc_hd__nand2_1
XFILLER_74_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12907_ _05205_ _05186_ VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__nand2_1
X_15626_ net288 VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_61_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12838_ _05135_ _05136_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__nand2_1
XFILLER_34_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15557_ net266 VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__inv_2
X_12769_ _01042_ _04552_ _04295_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__or3_1
X_15488_ _07700_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__clkbuf_1
X_14508_ _06516_ _06746_ _06714_ _06747_ VGND VGND VPWR VPWR _06748_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_32_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput20 i_a[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 i_a[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_14439_ _06630_ _06674_ _06678_ VGND VGND VPWR VPWR _06679_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput53 i_b[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
Xinput64 i_b[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
Xinput42 i_b[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09980_ _02265_ _02278_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__nand2_1
X_16109_ clknet_leaf_18_clk _00094_ _00357_ VGND VGND VPWR VPWR mul_res\[2\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_70_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08931_ _01220_ _00945_ _00944_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__nand3_1
XFILLER_69_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08862_ _01057_ _01053_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08793_ _01091_ _00899_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__nand2_1
XFILLER_84_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09414_ _01559_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_51_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09345_ _01642_ _01643_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__nand2_1
XFILLER_33_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09276_ _01556_ _01558_ _01560_ VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__a21o_1
XFILLER_21_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08227_ _00524_ _00525_ VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__nand2_1
XFILLER_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08158_ _00453_ _00456_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__nand2_1
XFILLER_106_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08089_ _07858_ _07859_ VGND VGND VPWR VPWR _07860_ sky130_fd_sc_hd__nand2_1
XFILLER_106_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10120_ _02418_ _02144_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__nand2_1
X_10051_ _02349_ _02106_ VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__nand2_1
XFILLER_88_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13810_ _06082_ _06075_ _06084_ net250 VGND VGND VPWR VPWR _06085_ sky130_fd_sc_hd__a31o_1
XFILLER_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14790_ _07016_ _07027_ VGND VGND VPWR VPWR _07029_ sky130_fd_sc_hd__nand2_1
X_13741_ _06008_ _06023_ VGND VGND VPWR VPWR _06024_ sky130_fd_sc_hd__and2b_1
XFILLER_73_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10953_ net132 net218 VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__nand2_1
XFILLER_113_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13672_ _05935_ _05964_ VGND VGND VPWR VPWR _05965_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10884_ net192 net147 VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__nand2_1
X_15411_ _07634_ _07636_ VGND VGND VPWR VPWR _07637_ sky130_fd_sc_hd__nand2_1
X_12623_ _04921_ _04853_ _04858_ VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__nand3_1
X_15342_ _02940_ _02954_ _07568_ VGND VGND VPWR VPWR _07569_ sky130_fd_sc_hd__a21bo_1
X_12554_ _04790_ _04852_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__nand2_1
XFILLER_8_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15273_ _07507_ multiplier_inst.man_final_r\[13\] _07508_ VGND VGND VPWR VPWR _07513_
+ sky130_fd_sc_hd__and3_1
XFILLER_8_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11505_ _03803_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__inv_2
XFILLER_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14224_ _06445_ VGND VGND VPWR VPWR _06465_ sky130_fd_sc_hd__buf_4
XFILLER_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12485_ _04729_ _04783_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__nand2_1
X_11436_ _03733_ _03734_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__nand2_1
X_14155_ adder_inst.is_nan_r _06394_ adder_inst.sign_sum_r VGND VGND VPWR VPWR _06398_
+ sky130_fd_sc_hd__or3b_1
XFILLER_98_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11367_ _03543_ _03665_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14086_ net249 net257 adder_inst.sum_raw_r\[17\] _06076_ _06343_ VGND VGND VPWR VPWR
+ _06344_ sky130_fd_sc_hd__a221o_1
X_10318_ _02377_ _02378_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__nand2_1
X_13106_ _04560_ _04881_ _05403_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__o21ai_1
X_11298_ _03595_ _03596_ _03592_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__nand3_1
X_13037_ _05314_ _05299_ VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__nand2_1
X_10249_ _02466_ _02547_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__nand2_1
XFILLER_79_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14988_ _07226_ _07230_ VGND VGND VPWR VPWR _07231_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_37_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13939_ _06206_ _06208_ _06210_ _06042_ VGND VGND VPWR VPWR _06211_ sky130_fd_sc_hd__a31o_1
XFILLER_62_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15609_ net290 VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_66_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_09130_ net122 net229 VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__nand2_1
X_09061_ _01339_ _01359_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__nand2_1
X_08012_ _07778_ _07782_ VGND VGND VPWR VPWR _07783_ sky130_fd_sc_hd__nand2_1
XFILLER_89_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09963_ _02259_ _02261_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08914_ _00966_ _00951_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__nand2_1
X_09894_ net154 net236 VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08845_ _01136_ _01143_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__nand2_1
X_08776_ _01049_ _01061_ _01074_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__nand3_1
XFILLER_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09328_ _01622_ _01624_ _01626_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09259_ _01557_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__inv_2
XFILLER_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12270_ net180 net135 VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__nand2_1
X_11221_ _03517_ _03519_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__nand2_1
XFILLER_4_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11152_ _03448_ _03449_ _03450_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__nand3_1
XFILLER_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10103_ _02128_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__inv_2
X_15960_ clknet_leaf_0_clk net319 _00208_ VGND VGND VPWR VPWR adder_inst.man_a_r\[10\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_68_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11083_ _03380_ _03375_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__nand2_1
X_15891_ clknet_leaf_11_clk net25 _00139_ VGND VGND VPWR VPWR adder_inst.i_a\[31\]
+ sky130_fd_sc_hd__dfrtp_1
X_10034_ _02331_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__inv_2
X_14911_ _06699_ VGND VGND VPWR VPWR _07150_ sky130_fd_sc_hd__inv_2
X_14842_ _07065_ _06932_ _07078_ VGND VGND VPWR VPWR _07079_ sky130_fd_sc_hd__a21bo_1
XFILLER_75_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14773_ _06673_ _07012_ VGND VGND VPWR VPWR _07013_ sky130_fd_sc_hd__nor2_1
XFILLER_56_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11985_ _03890_ _04112_ _04111_ _04115_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__o22a_1
XFILLER_29_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13724_ adder_inst.i_a\[0\] adder_inst.i_a\[3\] adder_inst.i_a\[5\] adder_inst.i_a\[6\]
+ VGND VGND VPWR VPWR _06011_ sky130_fd_sc_hd__or4_1
X_10936_ net181 net158 net177 net161 VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__a22o_1
X_13655_ adder_inst.exp_b_r\[6\] _05947_ VGND VGND VPWR VPWR _05948_ sky130_fd_sc_hd__nor2_1
X_10867_ _03165_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__inv_2
X_12606_ _04902_ _04904_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13586_ _05879_ _05882_ VGND VGND VPWR VPWR _05883_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_42_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10798_ net194 net150 VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__nand2_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15325_ _07538_ _05708_ VGND VGND VPWR VPWR _07550_ sky130_fd_sc_hd__or2_1
X_12537_ _04835_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__inv_2
X_15256_ _07501_ VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__clkbuf_1
X_12468_ _04762_ _04766_ VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__xor2_1
XFILLER_8_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15187_ _06671_ _07440_ VGND VGND VPWR VPWR _07441_ sky130_fd_sc_hd__xor2_1
X_14207_ _06440_ VGND VGND VPWR VPWR _06448_ sky130_fd_sc_hd__clkbuf_4
X_11419_ _03283_ _03342_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__nor2_1
XFILLER_113_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14138_ _06186_ net103 _06088_ _00068_ VGND VGND VPWR VPWR _06389_ sky130_fd_sc_hd__a31oi_2
X_12399_ _04697_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__inv_2
XFILLER_4_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_3_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_14069_ _06231_ _06327_ VGND VGND VPWR VPWR _06328_ sky130_fd_sc_hd__nand2_1
XFILLER_100_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08630_ _00831_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__inv_2
XFILLER_82_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08561_ _00859_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__inv_2
XFILLER_35_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08492_ _00787_ _00790_ VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__nand2_1
XFILLER_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09113_ _01407_ _01411_ VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_79_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09044_ _07752_ _01342_ VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_92_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09946_ _02227_ _02060_ _02224_ VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__o21ai_1
XFILLER_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09877_ _02156_ _02162_ _02012_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08828_ _01126_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__inv_2
X_08759_ _01050_ _01054_ _01057_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__o21ai_1
XFILLER_57_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11770_ _03967_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__inv_2
XFILLER_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10721_ _03016_ _03018_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_101_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13440_ _05723_ _05736_ _05738_ VGND VGND VPWR VPWR _05739_ sky130_fd_sc_hd__nand3_1
X_10652_ _02949_ _02950_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__nand2_1
X_10583_ _02873_ _02870_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__nor2_1
X_13371_ _05669_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15110_ _07341_ _07359_ VGND VGND VPWR VPWR _07361_ sky130_fd_sc_hd__or2_1
X_16090_ clknet_leaf_20_clk multiplier_inst.man_final\[16\] _00338_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[16\] sky130_fd_sc_hd__dfrtp_1
X_12322_ _00623_ _04619_ _04620_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__o21ai_1
X_15041_ _07267_ _06790_ VGND VGND VPWR VPWR _07288_ sky130_fd_sc_hd__nand2_1
X_12253_ net205 VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__inv_2
XFILLER_107_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11204_ _03501_ _03502_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__nand2_1
XFILLER_5_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12184_ _04408_ _04411_ _04413_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_112_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11135_ _03432_ _03433_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__nand2_1
XFILLER_95_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15943_ clknet_leaf_17_clk adder_inst.sum_raw\[18\] _00191_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11066_ net121 net222 VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__nand2_1
XFILLER_103_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10017_ _02095_ _02100_ _02090_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15874_ clknet_leaf_25_clk net6 _00122_ VGND VGND VPWR VPWR adder_inst.i_a\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_48_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14825_ _07060_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07061_ sky130_fd_sc_hd__nand2_1
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14756_ _06989_ _06969_ VGND VGND VPWR VPWR _06996_ sky130_fd_sc_hd__nor2_1
X_13707_ adder_inst.exp_a\[3\] adder_inst.exp_a\[2\] _05995_ _05996_ VGND VGND VPWR
+ VPWR _05997_ sky130_fd_sc_hd__or4_1
XFILLER_91_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11968_ _04266_ _04107_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__nand2_1
XFILLER_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14687_ _06914_ _06919_ VGND VGND VPWR VPWR _06927_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10919_ net189 net150 VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_27_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11899_ _04185_ _04197_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__nand2_1
X_13638_ _05930_ _05932_ VGND VGND VPWR VPWR _05933_ sky130_fd_sc_hd__nand2_1
XFILLER_32_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13569_ _05865_ VGND VGND VPWR VPWR _05866_ sky130_fd_sc_hd__inv_2
XFILLER_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15308_ _02185_ _02451_ VGND VGND VPWR VPWR _07531_ sky130_fd_sc_hd__nand2_1
XFILLER_8_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15239_ adder_inst.exp_a_r\[7\] adder_inst.exp_b_r\[7\] _06563_ VGND VGND VPWR VPWR
+ _07489_ sky130_fd_sc_hd__mux2_1
XFILLER_99_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09800_ _02098_ _02097_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__nand2_1
XFILLER_99_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout207 net210 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__clkbuf_4
Xfanout218 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_4
Xfanout229 net231 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_4
X_07992_ _07761_ VGND VGND VPWR VPWR _07763_ sky130_fd_sc_hd__inv_2
X_09731_ _02029_ _01938_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__nand2_1
XFILLER_86_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09662_ _01954_ _01886_ _01739_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__nand3_1
XFILLER_67_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09593_ _01800_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__inv_2
XFILLER_55_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08613_ _00853_ _00895_ VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__nand2_1
XFILLER_39_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08544_ _00833_ _00840_ _00842_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__nand3_2
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08475_ _00773_ _00502_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__nand2_1
XFILLER_10_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09027_ _01322_ _01325_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__nor2_1
XFILLER_2_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09929_ _02227_ _02060_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__nor2_1
XFILLER_105_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12940_ _04326_ _04323_ _05237_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__nand3_1
XFILLER_100_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12871_ _05168_ _05169_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__nand2_1
X_14610_ _06551_ net173 VGND VGND VPWR VPWR _06850_ sky130_fd_sc_hd__nand2_1
XFILLER_73_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11822_ _04118_ _04120_ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__nand2_1
X_15590_ net266 VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__inv_2
XFILLER_81_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14541_ _06473_ _06661_ _06714_ _06780_ VGND VGND VPWR VPWR _06781_ sky130_fd_sc_hd__o211ai_2
X_11753_ _04050_ _04051_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__nand2_1
XFILLER_81_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14472_ _06711_ _06487_ VGND VGND VPWR VPWR _06712_ sky130_fd_sc_hd__nand2_1
X_10704_ _03000_ _03002_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__nand2_1
X_11684_ _03982_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__inv_2
XFILLER_14_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10635_ _02932_ _02926_ VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__nand2_1
X_13423_ _05720_ _05663_ _05721_ VGND VGND VPWR VPWR _05722_ sky130_fd_sc_hd__o21ai_1
XFILLER_41_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13354_ _07159_ _05652_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__or2_1
X_16142_ clknet_leaf_19_clk _00025_ _00390_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
X_10566_ net167 net242 VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__nand2_1
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12305_ net123 net195 VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__nand2_1
X_16073_ clknet_leaf_13_clk multiplier_inst.overflow_calc _00321_ VGND VGND VPWR VPWR
+ multiplier_inst.overflow_calc_r sky130_fd_sc_hd__dfrtp_1
X_10497_ _02795_ _02774_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__nand2_1
X_13285_ _05563_ _05583_ VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__nor2_1
X_15024_ _07268_ _07269_ _06000_ VGND VGND VPWR VPWR _07270_ sky130_fd_sc_hd__a21o_1
X_12236_ _04526_ _04517_ _04513_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__o21a_1
X_12167_ _04457_ _04462_ _04465_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__nand3_1
XFILLER_96_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11118_ _03414_ _03413_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__nor2_1
XFILLER_1_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12098_ _04374_ _04380_ VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__nand2_1
X_15926_ clknet_leaf_9_clk adder_inst.sum_raw\[1\] _00174_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[1\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_76_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput7 i_a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_11049_ _03346_ _03347_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__nand2_1
X_15857_ clknet_leaf_13_clk net311 _00105_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
XFILLER_76_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14808_ _06881_ _07044_ VGND VGND VPWR VPWR _07045_ sky130_fd_sc_hd__xor2_1
XFILLER_52_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15788_ net300 VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__inv_2
XFILLER_52_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14739_ _06977_ _06978_ VGND VGND VPWR VPWR _06979_ sky130_fd_sc_hd__nand2_1
XFILLER_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08260_ _00555_ _00558_ VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__nand2_1
X_08191_ _00487_ _00489_ VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_89_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07975_ _07743_ _07555_ _07533_ VGND VGND VPWR VPWR _07746_ sky130_fd_sc_hd__nand3_2
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09714_ _02012_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__inv_2
X_09645_ _01927_ _01941_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_87_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09576_ _01302_ _01530_ _01874_ VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__nand3_1
XFILLER_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08527_ _00821_ _00823_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__nand2_1
XFILLER_51_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08458_ net204 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_21_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10420_ _02718_ _02692_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__nand2_1
X_08389_ net126 net238 VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__nand2_1
XFILLER_11_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10351_ _02649_ _02647_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_98_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10282_ _02302_ _02305_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__nand2_1
X_13070_ _05366_ _05368_ VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__nand2_1
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12021_ _04093_ _04088_ VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__nand2_1
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13972_ _06131_ _06238_ _06240_ _06181_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__a211oi_1
XFILLER_93_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15711_ net296 VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_29_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12923_ _05214_ _05217_ _05219_ VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_57_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15642_ net269 VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__inv_2
X_12854_ _05072_ _05152_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__nand2_1
XFILLER_34_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15573_ net273 VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11805_ _04102_ _04103_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__nand2_1
X_12785_ _05083_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__inv_2
X_14524_ _00588_ _06637_ _06763_ VGND VGND VPWR VPWR _06764_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_60_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11736_ _04026_ _04029_ _04032_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__nand3_1
X_14455_ net145 _06569_ _06694_ VGND VGND VPWR VPWR _06695_ sky130_fd_sc_hd__o21ai_1
X_11667_ _03964_ _03965_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__nor2b_1
X_10618_ _02881_ _02916_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__xor2_1
X_14386_ _06624_ _06625_ VGND VGND VPWR VPWR _06626_ sky130_fd_sc_hd__nand2_2
X_13406_ _05698_ _05704_ VGND VGND VPWR VPWR _05705_ sky130_fd_sc_hd__nor2_1
XFILLER_10_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11598_ _03896_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__inv_2
X_10549_ _02846_ _02847_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__nand2_1
X_16125_ clknet_leaf_15_clk _00081_ _00373_ VGND VGND VPWR VPWR mul_res\[18\] sky130_fd_sc_hd__dfrtp_1
X_13337_ _05635_ _05604_ VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__xor2_1
X_16056_ clknet_leaf_10_clk adder_inst.is_inf_a _00304_ VGND VGND VPWR VPWR adder_inst.is_inf_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_15007_ _06756_ VGND VGND VPWR VPWR _07251_ sky130_fd_sc_hd__inv_2
X_13268_ _05566_ _05552_ VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__nand2_1
X_13199_ _05496_ _05497_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__nand2_1
X_12219_ _04500_ _04505_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__nand2_1
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15909_ clknet_leaf_24_clk net41 _00157_ VGND VGND VPWR VPWR adder_inst.i_b\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_92_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09430_ net219 net162 VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__nand2_1
XFILLER_80_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09361_ _01653_ _01194_ _01657_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__nand3_1
XFILLER_52_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09292_ net151 net228 VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__nand2_1
X_08312_ _00610_ _00607_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_12 net221 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08243_ _00541_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__inv_2
XFILLER_20_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08174_ net200 net169 VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__nand2_1
XFILLER_102_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07958_ _07654_ _07672_ _07689_ VGND VGND VPWR VPWR _07708_ sky130_fd_sc_hd__a21oi_1
XFILLER_55_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09628_ _01926_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__inv_2
XFILLER_83_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09559_ _01857_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12570_ net124 VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__inv_2
XFILLER_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11521_ _03816_ _03819_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__nand2_1
X_14240_ _06480_ VGND VGND VPWR VPWR _06481_ sky130_fd_sc_hd__inv_2
X_11452_ _03745_ _03750_ VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__xor2_1
X_14171_ _06410_ _06412_ VGND VGND VPWR VPWR _06413_ sky130_fd_sc_hd__nand2_2
X_10403_ _02598_ _02601_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__nand2_1
X_11383_ _03675_ _03677_ _03679_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__nand3_1
XFILLER_109_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10334_ _02625_ _02630_ _02632_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__nand3_1
X_13122_ _05420_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__inv_2
X_10265_ _02561_ _02557_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__nand2b_1
X_13053_ _05208_ _05350_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__nand2_1
X_10196_ _02216_ _02211_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__nand2_1
XFILLER_87_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12004_ _04302_ _04135_ _04143_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__nand3_1
XFILLER_78_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_109_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13955_ adder_inst.sum_raw_r\[3\] _06084_ VGND VGND VPWR VPWR _06225_ sky130_fd_sc_hd__nor2_1
XFILLER_62_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13886_ _06089_ _06129_ _06144_ _06160_ VGND VGND VPWR VPWR _06161_ sky130_fd_sc_hd__and4b_1
XFILLER_61_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12906_ _05191_ _05204_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__nand2_1
X_15625_ net288 VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__inv_2
X_12837_ _05107_ _05108_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__nand2_1
XFILLER_61_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15556_ net265 VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__inv_2
X_12768_ net115 net212 VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__nand2_1
X_15487_ net410 mul_res\[4\] net258 VGND VGND VPWR VPWR _07700_ sky130_fd_sc_hd__mux2_1
X_14507_ _06643_ _06516_ VGND VGND VPWR VPWR _06747_ sky130_fd_sc_hd__nand2_1
X_12699_ _04997_ VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__inv_2
X_11719_ _03842_ _03838_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput21 i_a[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
X_14438_ _06675_ _06672_ _06648_ _06677_ VGND VGND VPWR VPWR _06678_ sky130_fd_sc_hd__a31o_1
Xinput10 i_a[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XFILLER_30_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput54 i_b[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput32 i_a[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xinput43 i_b[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput65 i_vld VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16108_ clknet_leaf_18_clk _00083_ _00356_ VGND VGND VPWR VPWR mul_res\[1\] sky130_fd_sc_hd__dfrtp_1
X_14369_ _06606_ _06604_ VGND VGND VPWR VPWR _06609_ sky130_fd_sc_hd__nand2_2
X_16039_ clknet_leaf_13_clk _00051_ _00287_ VGND VGND VPWR VPWR add_res\[23\] sky130_fd_sc_hd__dfrtp_1
X_08930_ _01224_ _01226_ _01228_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__a21oi_1
XFILLER_97_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08861_ _01157_ _01007_ _01159_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__nand3_1
XFILLER_69_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08792_ _01090_ _00843_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__nand2_1
XFILLER_84_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09413_ _01711_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__inv_2
XFILLER_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09344_ _01208_ _00968_ _00988_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__nand3_1
XFILLER_40_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09275_ _01571_ _01573_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__nand2_1
XFILLER_21_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08226_ _00511_ _00506_ _00508_ VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__a21oi_2
XFILLER_119_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08157_ _00454_ _00455_ VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_95_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08088_ net138 net221 VGND VGND VPWR VPWR _07859_ sky130_fd_sc_hd__nand2_1
XFILLER_0_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10050_ _02345_ _02348_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__nand2_1
XFILLER_88_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13740_ _06021_ _06022_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] VGND VGND VPWR
+ VPWR _06023_ sky130_fd_sc_hd__and4b_1
XFILLER_56_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10952_ _03247_ _03250_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__nand2_1
XFILLER_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13671_ _05963_ VGND VGND VPWR VPWR _05964_ sky130_fd_sc_hd__inv_2
X_15410_ _07630_ _05786_ VGND VGND VPWR VPWR _07636_ sky130_fd_sc_hd__nand2_1
XFILLER_43_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10883_ net192 net144 VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12622_ _04919_ _04917_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__nand2_1
X_15341_ _02951_ _07567_ _02945_ VGND VGND VPWR VPWR _07568_ sky130_fd_sc_hd__and3_1
X_12553_ _04851_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__inv_2
X_15272_ _07512_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__clkbuf_1
X_11504_ net199 net137 VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__nand2_1
X_14223_ net170 _06448_ _06463_ VGND VGND VPWR VPWR _06464_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12484_ _04782_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__inv_2
XFILLER_22_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11435_ _01042_ _03261_ _03730_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__o21ai_1
X_14154_ _06169_ _06186_ net103 _06387_ VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__a31o_1
X_11366_ _03661_ _03659_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__nand2_1
X_10317_ _02611_ _02587_ _02609_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__a21o_1
X_14085_ _06042_ _06342_ VGND VGND VPWR VPWR _06343_ sky130_fd_sc_hd__nor2_1
X_13105_ _04560_ _04881_ _05403_ VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__or3_1
X_11297_ _03588_ _03427_ _03585_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_115_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10248_ net230 net171 VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__nand2_1
XFILLER_112_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13036_ _05333_ VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__inv_2
XFILLER_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10179_ _02204_ _02477_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__or2_1
XFILLER_94_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14987_ _07202_ _06740_ _06738_ VGND VGND VPWR VPWR _07230_ sky130_fd_sc_hd__a21bo_1
X_13938_ _06209_ net251 VGND VGND VPWR VPWR _06210_ sky130_fd_sc_hd__nand2_1
XFILLER_81_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13869_ _06142_ _06074_ _06143_ VGND VGND VPWR VPWR _06144_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_66_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15608_ net275 VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_66_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15539_ add_res\[30\] mul_res\[30\] net261 VGND VGND VPWR VPWR _07731_ sky130_fd_sc_hd__mux2_1
X_09060_ _01356_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__nand2_1
XFILLER_30_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08011_ _07745_ _07746_ _07781_ VGND VGND VPWR VPWR _07782_ sky130_fd_sc_hd__nand3_1
XFILLER_118_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09962_ _02205_ _02031_ _02260_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__o21a_1
X_08913_ _01210_ _01211_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__nand2_1
X_09893_ _02191_ _02039_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_90_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08844_ _01138_ _01140_ _01142_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__a21oi_1
X_08775_ _01064_ _01061_ _01073_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__nand3_1
XFILLER_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09327_ _01625_ _01149_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__nor2_1
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09258_ net213 net168 VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__nand2_1
XFILLER_21_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08209_ _00497_ _00496_ VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__nor2_1
X_09189_ _01485_ _01486_ _01487_ VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__nand3_1
XFILLER_119_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11220_ _03518_ _03174_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__nand2_1
X_11151_ _01431_ _01427_ VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__nand2_1
XFILLER_107_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10102_ _02400_ _02128_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__nand2_1
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11082_ _03375_ _03380_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__or2_1
X_15890_ clknet_leaf_6_clk net24 _00138_ VGND VGND VPWR VPWR adder_inst.exp_a\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_10033_ _02320_ _02331_ VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__nand2_1
X_14910_ _07142_ _07148_ VGND VGND VPWR VPWR adder_inst.sum_raw\[9\] sky130_fd_sc_hd__nand2_1
XFILLER_68_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14841_ _06923_ _06930_ VGND VGND VPWR VPWR _07078_ sky130_fd_sc_hd__nand2_1
XFILLER_76_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14772_ _07011_ _06627_ VGND VGND VPWR VPWR _07012_ sky130_fd_sc_hd__nand2_1
XFILLER_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11984_ _04281_ _04282_ VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__nand2_1
XFILLER_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13723_ adder_inst.i_a\[21\] adder_inst.i_a\[20\] adder_inst.i_a\[22\] _06009_ VGND
+ VGND VPWR VPWR _06010_ sky130_fd_sc_hd__or4_1
XFILLER_44_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10935_ net177 net158 VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__nand2_1
XFILLER_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13654_ adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR _05947_ sky130_fd_sc_hd__inv_2
X_10866_ _03157_ _03163_ _03164_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__a21oi_1
XFILLER_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12605_ _04903_ _04877_ _04878_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_14_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13585_ _05880_ _05881_ VGND VGND VPWR VPWR _05882_ sky130_fd_sc_hd__nor2_1
X_15324_ _07546_ _07547_ _07548_ _07534_ VGND VGND VPWR VPWR _07549_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_42_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10797_ _03092_ _03095_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__nand2_1
X_12536_ _04828_ _04834_ VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__xor2_1
XFILLER_8_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15255_ _07492_ multiplier_inst.man_final_r\[5\] _07494_ VGND VGND VPWR VPWR _07501_
+ sky130_fd_sc_hd__and3_1
XFILLER_69_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12467_ _04763_ _04765_ VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__nor2_1
XFILLER_8_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15186_ _07437_ _07439_ VGND VGND VPWR VPWR _07440_ sky130_fd_sc_hd__nand2_1
X_14206_ _06446_ VGND VGND VPWR VPWR _06447_ sky130_fd_sc_hd__buf_4
X_11418_ _03703_ _03713_ _03714_ VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__nand3_1
X_14137_ _06388_ VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__clkbuf_2
X_12398_ net184 net137 net186 net134 VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__a22o_1
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11349_ _03615_ _03610_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__nand2_1
X_14068_ adder_inst.sum_raw_r\[11\] net255 VGND VGND VPWR VPWR _06327_ sky130_fd_sc_hd__nand2_1
XFILLER_67_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13019_ _05317_ VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__inv_2
XFILLER_81_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08560_ _00858_ _00678_ VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__nand2_1
XFILLER_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08491_ _00788_ _00789_ _00779_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__nand3_1
XFILLER_22_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09112_ _01410_ _01363_ _01366_ VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_79_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09043_ _01341_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09945_ _02243_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__inv_2
XFILLER_77_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09876_ _02173_ _02174_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__nand2_1
XFILLER_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08827_ net223 net156 VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__nand2_1
XFILLER_58_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08758_ _00861_ _01056_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__nand2_1
X_08689_ _00983_ _00987_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__nand2_1
XFILLER_54_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10720_ _03008_ _03016_ _03018_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__nand3_1
XFILLER_26_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_109_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10651_ _02937_ _02917_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__nand2_1
XFILLER_70_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10582_ _02878_ _02880_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__and2_1
X_13370_ _05665_ _05668_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__nor2_1
X_12321_ net119 net192 VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__nand2_1
X_15040_ _07285_ _07141_ VGND VGND VPWR VPWR _07287_ sky130_fd_sc_hd__nand2_1
XFILLER_5_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12252_ net106 net208 VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__nand2_1
XFILLER_79_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11203_ _03494_ _03157_ _03163_ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_118_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12183_ _04475_ _04481_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_112_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11134_ _03334_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__inv_2
X_15942_ clknet_leaf_17_clk adder_inst.sum_raw\[17\] _00190_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[17\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_1_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11065_ _03300_ net117 net222 VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__nand3_1
X_10016_ _02308_ _02310_ VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__nand2_1
XFILLER_76_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15873_ clknet_leaf_0_clk net5 _00121_ VGND VGND VPWR VPWR adder_inst.i_a\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_48_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14824_ _07055_ _07059_ _07021_ VGND VGND VPWR VPWR _07060_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14755_ _06994_ _06946_ VGND VGND VPWR VPWR _06995_ sky130_fd_sc_hd__and2_1
XFILLER_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11967_ _04264_ _04265_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__nand2_1
X_13706_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _05996_ sky130_fd_sc_hd__or4_1
X_10918_ _03135_ _03126_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__nand2_1
XFILLER_17_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14686_ _06923_ _06925_ VGND VGND VPWR VPWR _06926_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11898_ _04195_ _04196_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__nand2_1
XFILLER_32_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13637_ _05883_ net102 _05928_ VGND VGND VPWR VPWR _05932_ sky130_fd_sc_hd__nand3_1
X_10849_ _03146_ _03147_ _03046_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__nand3_1
XFILLER_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13568_ _05863_ _05864_ VGND VGND VPWR VPWR _05865_ sky130_fd_sc_hd__nand2_1
X_15307_ _05940_ VGND VGND VPWR VPWR _07530_ sky130_fd_sc_hd__buf_6
X_12519_ net118 net190 net187 net119 VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__a22o_1
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15238_ _07488_ VGND VGND VPWR VPWR adder_inst.exp_larger\[6\] sky130_fd_sc_hd__clkbuf_1
X_13499_ _05797_ VGND VGND VPWR VPWR _05798_ sky130_fd_sc_hd__inv_2
X_15169_ _07421_ _06650_ VGND VGND VPWR VPWR _07422_ sky130_fd_sc_hd__nand2_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout219 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_74_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07991_ _07760_ _07761_ VGND VGND VPWR VPWR _07762_ sky130_fd_sc_hd__nand2_1
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09730_ _01932_ _01937_ _01934_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__a21o_1
XFILLER_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09661_ _01953_ _01760_ VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__nand2_1
XFILLER_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09592_ _01890_ _01800_ VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__nand2_1
X_08612_ _00910_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__inv_2
XFILLER_54_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08543_ _00838_ _00521_ _00841_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__nand3_1
XFILLER_35_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08474_ _00772_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__inv_2
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09026_ _01324_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__inv_2
XFILLER_117_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09928_ adder_inst.man_b_r\[9\] net245 VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__nand2_1
XFILLER_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09859_ _02150_ _01815_ _01841_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__nand3_1
XFILLER_58_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12870_ _05100_ VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__inv_2
XFILLER_73_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11821_ _04119_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__inv_2
XFILLER_73_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14540_ _06778_ _06779_ _06473_ VGND VGND VPWR VPWR _06780_ sky130_fd_sc_hd__nand3_1
XFILLER_81_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11752_ _03876_ _03869_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__nand2_1
X_14471_ _06445_ _06709_ _06710_ VGND VGND VPWR VPWR _06711_ sky130_fd_sc_hd__o21ai_1
X_10703_ _03001_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__inv_2
X_11683_ net195 net135 VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__nand2_1
XFILLER_14_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10634_ _02926_ _02932_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__or2_1
X_13422_ _05663_ _05716_ VGND VGND VPWR VPWR _05721_ sky130_fd_sc_hd__nand2_1
XFILLER_41_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_16141_ clknet_leaf_19_clk _00022_ _00389_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
X_13353_ _05646_ _05647_ _05651_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__nand3_2
XFILLER_14_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10565_ _02862_ _02863_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__nand2_1
X_12304_ _04602_ _04599_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__nand2_1
X_16072_ clknet_leaf_11_clk _00070_ _00320_ VGND VGND VPWR VPWR multiplier_inst.is_nan_r
+ sky130_fd_sc_hd__dfrtp_1
X_10496_ _02717_ _02776_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__nand2_1
X_13284_ _05577_ _05581_ _05582_ VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__nand3_1
XFILLER_107_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15023_ _07267_ _07248_ VGND VGND VPWR VPWR _07269_ sky130_fd_sc_hd__nand2_1
X_12235_ _04529_ _04489_ _04533_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__nand3_1
XFILLER_5_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12166_ _04463_ _04464_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__nand2_1
X_11117_ _01349_ _01343_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__nand2_2
XFILLER_110_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12097_ _04374_ _04380_ _04395_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__nand3_1
X_15925_ clknet_leaf_9_clk adder_inst.sum_raw\[0\] _00173_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[0\]
+ sky130_fd_sc_hd__dfrtp_2
Xinput8 i_a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_11048_ _03345_ _03341_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__nand2_1
X_15856_ net294 VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__inv_2
XFILLER_76_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14807_ _06860_ _06907_ _06911_ VGND VGND VPWR VPWR _07044_ sky130_fd_sc_hd__a21oi_1
XFILLER_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15787_ net303 VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__inv_2
XFILLER_45_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12999_ _05266_ _05268_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__nand2_1
X_14738_ _06551_ _03955_ VGND VGND VPWR VPWR _06978_ sky130_fd_sc_hd__nand2_1
XFILLER_51_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14669_ _06881_ _06908_ VGND VGND VPWR VPWR _06909_ sky130_fd_sc_hd__nor2_1
XFILLER_20_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08190_ _00488_ _00485_ VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07974_ _07566_ _07744_ VGND VGND VPWR VPWR _07745_ sky130_fd_sc_hd__nand2_1
XFILLER_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09713_ _02009_ _02011_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__nor2_1
XFILLER_55_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09644_ _01929_ _01940_ _01942_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_87_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09575_ _01700_ _01871_ _01873_ VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__a21oi_1
XFILLER_43_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08526_ _00822_ _00824_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__nand2_1
XFILLER_51_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08457_ _00755_ _00482_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__nor2_1
XFILLER_51_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08388_ _00686_ VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__inv_2
XFILLER_7_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10350_ _02646_ _02647_ _02648_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_98_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10281_ _02515_ _02493_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__nand2_1
X_09009_ net177 net176 VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__nand2_1
X_12020_ _04317_ _04318_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__nand2_1
XFILLER_104_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13971_ net249 _06239_ _06227_ _06076_ _06229_ VGND VGND VPWR VPWR _06240_ sky130_fd_sc_hd__a221o_1
XFILLER_93_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15710_ net284 VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__inv_2
XFILLER_46_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12922_ _05218_ _05220_ VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__nand2_1
X_15641_ net269 VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__inv_2
XFILLER_73_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12853_ _05071_ _05067_ VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__nand2_1
XFILLER_27_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15572_ net274 VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11804_ _04100_ _04099_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__nand2_1
X_12784_ net109 net217 net113 net212 VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__a22o_1
XFILLER_27_692 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14523_ _06761_ _06637_ _06762_ VGND VGND VPWR VPWR _06763_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_60_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11735_ _04030_ _04033_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__nand2_1
X_14454_ _06688_ _06569_ VGND VGND VPWR VPWR _06694_ sky130_fd_sc_hd__nand2_1
XFILLER_41_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13405_ _05702_ _05703_ VGND VGND VPWR VPWR _05704_ sky130_fd_sc_hd__nand2_1
X_11666_ _03792_ _03963_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__nand2_1
X_10617_ _02882_ _02874_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__nand2b_1
X_14385_ _06622_ _06621_ VGND VGND VPWR VPWR _06625_ sky130_fd_sc_hd__nand2_1
X_11597_ _03801_ _03807_ _03805_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__o21ai_1
X_10548_ _02770_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__inv_2
X_16124_ clknet_leaf_15_clk _00080_ _00372_ VGND VGND VPWR VPWR mul_res\[17\] sky130_fd_sc_hd__dfrtp_1
X_13336_ _05634_ _05596_ VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__nand2_1
X_16055_ clknet_leaf_10_clk adder_inst.exp_larger\[7\] _00303_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_51_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13267_ _05565_ _05549_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__nand2_1
X_10479_ _02777_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__inv_2
X_15006_ _07119_ _07187_ _07193_ VGND VGND VPWR VPWR _07250_ sky130_fd_sc_hd__a21oi_1
X_12218_ _04513_ _04516_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__nand2_2
X_13198_ _05473_ _05494_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_71_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12149_ _04439_ _04442_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__nand2_1
XFILLER_110_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15908_ clknet_leaf_25_clk net40 _00156_ VGND VGND VPWR VPWR adder_inst.i_b\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15839_ net299 VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__inv_2
XFILLER_92_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09360_ _01654_ _01658_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__nand2_1
XFILLER_52_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09291_ _01589_ _01126_ VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__nand2_1
X_08311_ _00604_ _00607_ _00609_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_82_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_13 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08242_ _00536_ _00538_ _00540_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08173_ _00471_ _07794_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__nand2_1
XFILLER_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07957_ _07635_ _07696_ VGND VGND VPWR VPWR _07702_ sky130_fd_sc_hd__nand2_1
XFILLER_83_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09627_ _01925_ _01756_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__nand2_1
XFILLER_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09558_ _01826_ _01839_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_54_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08509_ net148 net224 VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__nand2_1
XFILLER_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09489_ _01786_ _01785_ _01787_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__nand3b_1
XFILLER_62_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11520_ _03184_ _03817_ _03818_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__a21oi_1
XFILLER_11_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11451_ _03747_ _03749_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__nand2_1
X_14170_ _06406_ _05952_ _05974_ _05973_ _06411_ VGND VGND VPWR VPWR _06412_ sky130_fd_sc_hd__a311oi_1
X_10402_ _02651_ _02697_ _02700_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__a21boi_1
X_11382_ _03678_ _03680_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__nand2_1
X_10333_ _02631_ _02620_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__nand2_1
X_13121_ _05418_ _05419_ VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__and2_1
XFILLER_11_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10264_ _02562_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__inv_2
XFILLER_105_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13052_ _05208_ _05350_ _05209_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__nand3_1
X_10195_ _02491_ _02493_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__nand2_1
XFILLER_78_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12003_ _04300_ _04299_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_109_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13954_ _06113_ adder_inst.sum_raw_r\[1\] VGND VGND VPWR VPWR _06224_ sky130_fd_sc_hd__nand2_1
XFILLER_46_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13885_ net250 _06146_ _06158_ _06131_ _06159_ VGND VGND VPWR VPWR _06160_ sky130_fd_sc_hd__a221oi_2
X_12905_ _05203_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__inv_2
XFILLER_19_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15624_ net288 VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__inv_2
XFILLER_61_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12836_ _05090_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__inv_2
X_15555_ net265 VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__inv_2
XFILLER_61_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14506_ _06742_ _06745_ VGND VGND VPWR VPWR _06746_ sky130_fd_sc_hd__nand2_1
X_12767_ _05064_ _05065_ VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__nand2_1
X_15486_ _07699_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__clkbuf_1
X_12698_ _04992_ _04994_ _04996_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__a21oi_1
X_11718_ _04014_ _04016_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__nand2_1
XFILLER_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 i_a[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_14437_ _06659_ _06670_ _06676_ VGND VGND VPWR VPWR _06677_ sky130_fd_sc_hd__o21ai_1
Xinput11 i_a[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_11649_ _03940_ _03943_ _03945_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__nand3_1
Xinput44 i_b[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput33 i_b[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput55 i_b[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
X_14368_ _06607_ VGND VGND VPWR VPWR _06608_ sky130_fd_sc_hd__inv_2
Xinput66 opcode VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
X_16107_ clknet_leaf_18_clk _00072_ _00355_ VGND VGND VPWR VPWR mul_res\[0\] sky130_fd_sc_hd__dfrtp_1
X_13319_ _05481_ _05477_ VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__nand2_1
XFILLER_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14299_ _04881_ _04582_ _06491_ VGND VGND VPWR VPWR _06540_ sky130_fd_sc_hd__mux2_1
X_16038_ clknet_leaf_12_clk _00050_ _00286_ VGND VGND VPWR VPWR add_res\[22\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_08860_ _01158_ _01004_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__nand2_1
XFILLER_69_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08791_ _01088_ _01089_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_84_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09412_ net213 net171 VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__nand2_1
XFILLER_52_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09343_ _01209_ _00989_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__nand2_1
XFILLER_40_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09274_ _01572_ _01569_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__nand2_1
XFILLER_20_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08225_ _07885_ _00523_ VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__nand2_1
XFILLER_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08156_ _07838_ _07835_ _07840_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_95_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08087_ net134 net224 VGND VGND VPWR VPWR _07858_ sky130_fd_sc_hd__nand2_1
XFILLER_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08989_ _01092_ _01095_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__nand2_1
XFILLER_57_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10951_ _03248_ _03249_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__nand2_1
X_13670_ _05929_ _05958_ _05962_ VGND VGND VPWR VPWR _05963_ sky130_fd_sc_hd__a21oi_1
XFILLER_16_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12621_ _04859_ _04917_ _04919_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__nand3_1
XFILLER_43_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10882_ net199 net141 VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15340_ _02946_ _02935_ VGND VGND VPWR VPWR _07567_ sky130_fd_sc_hd__nand2_1
X_12552_ _04848_ _04850_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__nand2_1
X_15271_ _07507_ multiplier_inst.man_final_r\[12\] _07508_ VGND VGND VPWR VPWR _07512_
+ sky130_fd_sc_hd__and3_1
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11503_ _03194_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__inv_2
X_12483_ _04780_ _04781_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__nand2_1
X_14222_ _06448_ _01449_ VGND VGND VPWR VPWR _06463_ sky130_fd_sc_hd__nand2_1
XFILLER_8_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11434_ _03732_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__inv_2
X_14153_ _06129_ _06186_ net103 _06387_ VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__a31o_1
XFILLER_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11365_ _03657_ _03663_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__nand2_1
X_10316_ _02603_ _02612_ _02614_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__nand3_2
X_14084_ _06315_ _06084_ _06333_ _06044_ _06341_ VGND VGND VPWR VPWR _06342_ sky130_fd_sc_hd__o221a_1
X_13104_ _05401_ _05402_ VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__nand2b_1
XFILLER_3_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11296_ _03590_ _03586_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10247_ _02545_ _02473_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__nand2_1
X_13035_ _05333_ _05299_ _05314_ VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__nand3_1
XFILLER_79_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10178_ net166 net233 VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__nand2_1
XFILLER_94_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14986_ _07227_ _07228_ _07178_ VGND VGND VPWR VPWR _07229_ sky130_fd_sc_hd__a21o_1
X_13937_ adder_inst.sum_raw_r\[2\] VGND VGND VPWR VPWR _06209_ sky130_fd_sc_hd__inv_2
XFILLER_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13868_ net250 _06136_ adder_inst.exp_larger_r\[2\] _06077_ VGND VGND VPWR VPWR _06143_
+ sky130_fd_sc_hd__o2bb2a_1
XFILLER_62_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15607_ net274 VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__inv_2
X_13799_ _06073_ VGND VGND VPWR VPWR _06074_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_66_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12819_ _05116_ _05043_ _05011_ VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__nand3b_1
X_15538_ net390 VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__clkbuf_1
X_15469_ _07688_ VGND VGND VPWR VPWR multiplier_inst.man_final\[19\] sky130_fd_sc_hd__inv_2
X_08010_ _07779_ _07780_ VGND VGND VPWR VPWR _07781_ sky130_fd_sc_hd__nand2_1
XFILLER_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09961_ _02202_ _02035_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__nand2_1
XFILLER_103_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08912_ _01208_ _00968_ _00989_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__nand3_1
X_09892_ net156 net236 VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__nand2_1
XFILLER_97_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08843_ _01141_ _00954_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__nor2_1
X_08774_ _01072_ _01068_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__nand2_1
XFILLER_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09326_ net148 net233 VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__nand2_1
X_09257_ _01555_ _01227_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__nand2_1
XFILLER_21_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08208_ _00498_ _00499_ _00506_ VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__nand3_1
XFILLER_119_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09188_ _01483_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__inv_2
XFILLER_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08139_ _07840_ _07835_ _07837_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__a21oi_2
XFILLER_108_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11150_ _03446_ _03275_ _03443_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__nand3_1
XFILLER_108_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10101_ _02134_ _02122_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__nand2_1
X_11081_ _03378_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__nand2_1
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10032_ _02329_ _02330_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__nand2_1
XFILLER_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14840_ _07075_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07077_ sky130_fd_sc_hd__nand2_1
XFILLER_75_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14771_ _06593_ _07010_ VGND VGND VPWR VPWR _07011_ sky130_fd_sc_hd__nor2_1
XFILLER_63_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13722_ adder_inst.i_a\[17\] adder_inst.i_a\[16\] adder_inst.i_a\[19\] adder_inst.i_a\[18\]
+ VGND VGND VPWR VPWR _06009_ sky130_fd_sc_hd__or4_1
X_11983_ _04279_ _04277_ _04276_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__nand3_1
XFILLER_29_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10934_ _03230_ _03232_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__nand2_1
X_13653_ _05946_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[4\] sky130_fd_sc_hd__inv_2
XFILLER_71_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10865_ _03162_ _03159_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__nor2_1
X_13584_ _05878_ _05652_ VGND VGND VPWR VPWR _05881_ sky130_fd_sc_hd__nor2_1
X_12604_ _04900_ _04901_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15323_ _07532_ _07531_ VGND VGND VPWR VPWR _07548_ sky130_fd_sc_hd__or2b_1
X_12535_ _04831_ _04833_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_42_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10796_ _03093_ _03094_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__nand2_1
XFILLER_12_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_117_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15254_ _07500_ VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__clkbuf_1
X_12466_ _04764_ VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__inv_2
X_15185_ _07430_ _07416_ _07438_ VGND VGND VPWR VPWR _07439_ sky130_fd_sc_hd__o21a_1
X_14205_ _06445_ VGND VGND VPWR VPWR _06446_ sky130_fd_sc_hd__inv_2
X_11417_ _03704_ _03715_ VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__nand2_1
X_12397_ net189 net131 VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__nand2_1
X_14136_ _06181_ _06186_ net104 _06387_ VGND VGND VPWR VPWR _06388_ sky130_fd_sc_hd__a31o_1
X_11348_ _03617_ _03613_ _03479_ VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__nand3_1
XFILLER_113_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14067_ _06326_ VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__clkbuf_1
X_11279_ _03499_ _03504_ _03577_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__nand3_1
XFILLER_79_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13018_ _05245_ _05316_ _05274_ VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__o21ai_1
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14969_ _07210_ VGND VGND VPWR VPWR _07211_ sky130_fd_sc_hd__inv_2
XFILLER_47_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08490_ _00782_ _00783_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__nand2_1
XFILLER_50_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09111_ _01408_ _01409_ VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__nand2_1
XFILLER_30_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09042_ net197 net155 VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_92_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09944_ _02242_ _02223_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__nor2_1
X_09875_ _02171_ _01855_ _01859_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__nand3_1
XFILLER_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08826_ net151 net224 VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__nand2_1
XFILLER_58_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08757_ _01055_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__inv_2
X_08688_ _00984_ _00985_ _00986_ VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__nand3_1
XFILLER_41_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10650_ _02948_ _02936_ VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__nand2_1
X_09309_ _01583_ _01584_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__nand2_1
XFILLER_41_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10581_ _02879_ _00651_ _02815_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__o21ai_1
XFILLER_70_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12320_ net195 VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__inv_2
XFILLER_107_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12251_ _04532_ _04549_ VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__nand2_2
XFILLER_5_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11202_ _03496_ _03493_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__nand2_1
X_12182_ _04477_ _04480_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_112_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11133_ _03297_ _03337_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__nand2_1
XFILLER_88_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15941_ clknet_leaf_17_clk adder_inst.sum_raw\[16\] _00189_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[16\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_49_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11064_ net116 net226 VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__nand2_1
X_10015_ _02312_ _02313_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__nand2_1
XFILLER_49_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15872_ clknet_leaf_0_clk net4 _00120_ VGND VGND VPWR VPWR adder_inst.i_a\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14823_ _06933_ _07058_ VGND VGND VPWR VPWR _07059_ sky130_fd_sc_hd__xor2_1
XFILLER_64_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14754_ _06926_ _06947_ VGND VGND VPWR VPWR _06994_ sky130_fd_sc_hd__nand2_1
X_11966_ _04259_ _04260_ _04262_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__nand3_2
X_13705_ _05993_ _05994_ VGND VGND VPWR VPWR _05995_ sky130_fd_sc_hd__nand2_1
X_14685_ net237 _06802_ _06924_ VGND VGND VPWR VPWR _06925_ sky130_fd_sc_hd__o21ai_1
X_10917_ _03142_ _03138_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__nand2_1
X_13636_ _05848_ _05930_ VGND VGND VPWR VPWR _05931_ sky130_fd_sc_hd__nand2_1
XFILLER_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11897_ _04189_ _04191_ _04193_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__nand3_1
X_10848_ _03054_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__inv_2
X_13567_ _05851_ adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR _05864_ sky130_fd_sc_hd__nand2_1
X_10779_ _03077_ _03071_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__nand2_1
X_15306_ _07529_ VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__inv_2
X_12518_ _04753_ _04816_ VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__nor2_1
X_13498_ _05359_ _05796_ VGND VGND VPWR VPWR _05797_ sky130_fd_sc_hd__xnor2_1
X_15237_ adder_inst.exp_a_r\[6\] adder_inst.exp_b_r\[6\] _06563_ VGND VGND VPWR VPWR
+ _07488_ sky130_fd_sc_hd__mux2_1
X_12449_ _04745_ _04741_ _04743_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__nand3_1
X_15168_ _07420_ _06639_ VGND VGND VPWR VPWR _07421_ sky130_fd_sc_hd__nand2_1
X_14119_ _06372_ _06231_ VGND VGND VPWR VPWR _06373_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_74_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout209 net210 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__clkbuf_4
X_15099_ _06610_ _07347_ VGND VGND VPWR VPWR _07348_ sky130_fd_sc_hd__or2_1
X_07990_ _07734_ _07737_ _07726_ VGND VGND VPWR VPWR _07761_ sky130_fd_sc_hd__a21oi_1
X_09660_ _01958_ _01951_ VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__nand2_1
X_08611_ _00909_ _00709_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__nand2_1
X_09591_ _01889_ _01767_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__nand2_1
XFILLER_48_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08542_ _00559_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__inv_2
XFILLER_63_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08473_ net214 net157 VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__nand2_1
XFILLER_35_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09025_ _07455_ _01323_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__nand2_1
XFILLER_117_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09927_ _02225_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__inv_2
XFILLER_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09858_ _02151_ _02153_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__nand2_1
X_09789_ _02083_ _02085_ _02087_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__a21oi_1
XFILLER_85_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08809_ _01096_ _01103_ _01107_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__a21oi_1
XFILLER_45_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11820_ _03981_ _03988_ _03984_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__o21ai_1
XFILLER_54_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11751_ _04047_ _04049_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__nand2_1
XFILLER_53_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10702_ net200 net146 VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__nand2_1
XFILLER_14_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14470_ _06580_ _06445_ VGND VGND VPWR VPWR _06710_ sky130_fd_sc_hd__nand2_1
X_11682_ net131 net202 VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10633_ _02931_ VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__inv_2
X_13421_ _04491_ _05719_ VGND VGND VPWR VPWR _05720_ sky130_fd_sc_hd__xnor2_2
X_13352_ _05649_ _05650_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__nor2_4
X_10564_ _02861_ _02823_ _02813_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__nand3_1
X_16140_ clknet_leaf_16_clk _00011_ _00388_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
XFILLER_6_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16071_ clknet_leaf_11_clk _00069_ _00319_ VGND VGND VPWR VPWR multiplier_inst.is_inf_r
+ sky130_fd_sc_hd__dfrtp_1
X_12303_ _04588_ _04600_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__nand2_1
X_10495_ _02637_ _02793_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__nor2_1
X_15022_ _07248_ _07267_ VGND VGND VPWR VPWR _07268_ sky130_fd_sc_hd__or2_1
X_13283_ _05580_ _05578_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__nand2b_1
X_12234_ _04490_ _04434_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__nand2_1
XFILLER_5_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12165_ _04456_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__inv_2
X_11116_ _03413_ _03414_ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__nand2_1
XFILLER_96_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12096_ _04393_ _04394_ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__nand2_1
X_15924_ clknet_leaf_13_clk net66 _00172_ VGND VGND VPWR VPWR opcode_stage1 sky130_fd_sc_hd__dfrtp_1
XFILLER_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11047_ _03341_ _03345_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__or2_1
XFILLER_37_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15855_ net303 VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__inv_2
Xinput9 i_a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14806_ _07036_ _07043_ VGND VGND VPWR VPWR adder_inst.sum_raw\[2\] sky130_fd_sc_hd__nand2_1
XFILLER_64_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15786_ net301 VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__inv_2
XFILLER_91_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12998_ _05296_ _05268_ _05266_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__nand3_1
X_14737_ _06975_ _06568_ _06976_ VGND VGND VPWR VPWR _06977_ sky130_fd_sc_hd__nand3_1
X_11949_ _04240_ _04245_ _04243_ VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__nand3_1
X_14668_ _06900_ _06907_ VGND VGND VPWR VPWR _06908_ sky130_fd_sc_hd__nand2_2
XFILLER_32_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13619_ _05855_ _05853_ _05912_ VGND VGND VPWR VPWR _05914_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14599_ _06451_ _06475_ _06454_ VGND VGND VPWR VPWR _06839_ sky130_fd_sc_hd__mux2_1
XFILLER_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09712_ _02010_ _01970_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__and2_1
X_07973_ _07743_ VGND VGND VPWR VPWR _07744_ sky130_fd_sc_hd__inv_2
X_09643_ _01926_ _01941_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__nand2_1
XFILLER_67_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09574_ _01872_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__inv_2
XFILLER_42_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08525_ _00823_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__inv_2
XFILLER_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08456_ net204 net166 VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__nand2_1
XFILLER_51_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08387_ _00685_ _00608_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10280_ _02578_ _02568_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__nand2_1
X_09008_ _01306_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__inv_2
XFILLER_2_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13970_ adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR _06239_ sky130_fd_sc_hd__inv_2
XFILLER_58_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12921_ _05219_ VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__inv_2
X_15640_ net273 VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__inv_2
XFILLER_46_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12852_ _05149_ _05150_ VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__nand2_1
X_15571_ net273 VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11803_ _04101_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__inv_2
X_12783_ _05081_ net109 net213 VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__and3_1
X_14522_ _06700_ _06654_ _06714_ VGND VGND VPWR VPWR _06762_ sky130_fd_sc_hd__o21a_1
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11734_ _04032_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__inv_2
X_14453_ _06690_ _06692_ VGND VGND VPWR VPWR _06693_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11665_ _03963_ _03792_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__nor2_1
X_10616_ _02914_ _02878_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__nand2_1
X_13404_ _05663_ _05695_ VGND VGND VPWR VPWR _05703_ sky130_fd_sc_hd__nand2_1
X_14384_ _06623_ VGND VGND VPWR VPWR _06624_ sky130_fd_sc_hd__inv_2
X_11596_ _03893_ _03894_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__nand2_1
X_10547_ _02771_ _02698_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__nand2_1
X_16123_ clknet_leaf_16_clk _00079_ _00371_ VGND VGND VPWR VPWR mul_res\[16\] sky130_fd_sc_hd__dfrtp_1
X_13335_ _05597_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__inv_2
XFILLER_41_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16054_ clknet_leaf_11_clk adder_inst.exp_larger\[6\] _00302_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_10478_ _02717_ _02775_ _02776_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__nand3_1
X_13266_ _05564_ _05546_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__xor2_1
X_15005_ _07226_ _07207_ VGND VGND VPWR VPWR _07249_ sky130_fd_sc_hd__nand2_1
X_12217_ _04514_ _04515_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__nand2_1
XFILLER_69_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13197_ _05474_ _05495_ VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_71_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12148_ _04374_ _04395_ _04446_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12079_ _01365_ _01364_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__nor2_1
XFILLER_110_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15907_ clknet_leaf_0_clk net39 _00155_ VGND VGND VPWR VPWR adder_inst.i_b\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15838_ net297 VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__inv_2
XFILLER_18_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15769_ net282 VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__inv_2
X_09290_ net154 net225 VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__nand2_1
X_08310_ _00608_ _00586_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_14 net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08241_ _00539_ _07863_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__nor2_1
XFILLER_33_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08172_ net197 net170 VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__nand2_1
XFILLER_99_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07956_ _07654_ _07672_ _07689_ VGND VGND VPWR VPWR _07696_ sky130_fd_sc_hd__a21o_1
XFILLER_68_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09626_ _01924_ _01753_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__nand2_1
XFILLER_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09557_ _01822_ _01819_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_54_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09488_ _01782_ _01625_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__nand2_1
X_08508_ _00806_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__inv_2
XFILLER_24_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08439_ _00479_ _00491_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__nand2_1
XFILLER_7_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11450_ _00649_ _00589_ _03748_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__o21ai_1
X_10401_ _02699_ _02578_ _02653_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__nand3_1
X_11381_ _03679_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__inv_2
X_10332_ _02399_ _02629_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__nand2_1
X_13120_ _04874_ _05417_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__nand2_1
X_13051_ _05206_ _05130_ _05131_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__nand3_1
X_10263_ _02558_ _02561_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__nand2_1
X_12002_ _04293_ _04299_ _04300_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__nand3_1
X_10194_ _02492_ _02464_ _02301_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__nand3_1
XFILLER_78_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13953_ _06209_ _06204_ _06155_ _06222_ VGND VGND VPWR VPWR _06223_ sky130_fd_sc_hd__o211a_1
X_13884_ adder_inst.exp_larger_r\[3\] _06077_ _06074_ VGND VGND VPWR VPWR _06159_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_74_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12904_ _05201_ _05202_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__nand2_1
X_15623_ net295 VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__inv_2
XFILLER_46_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12835_ _05063_ _05133_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__nand2_1
XFILLER_27_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15554_ net269 VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__inv_2
XFILLER_15_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14505_ _06743_ _06744_ _06512_ VGND VGND VPWR VPWR _06745_ sky130_fd_sc_hd__nand3_1
XFILLER_42_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12766_ _05047_ _05003_ _05062_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__nand3_1
X_15485_ add_res\[3\] mul_res\[3\] net258 VGND VGND VPWR VPWR _07699_ sky130_fd_sc_hd__mux2_1
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12697_ _04995_ net125 net198 VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__and3_1
X_11717_ _04015_ _03949_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_30_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput12 i_a[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
X_14436_ _06652_ _06569_ _06655_ VGND VGND VPWR VPWR _06676_ sky130_fd_sc_hd__or3_1
X_11648_ _03944_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__nand2_1
Xinput23 i_a[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput34 i_b[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 i_b[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
X_14367_ _06604_ _06606_ VGND VGND VPWR VPWR _06607_ sky130_fd_sc_hd__nor2_1
X_11579_ _03697_ _03877_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__nand2_1
Xinput56 i_b[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
X_16106_ clknet_leaf_13_clk _00104_ _00354_ VGND VGND VPWR VPWR mul_ovf sky130_fd_sc_hd__dfrtp_1
Xinput67 rst VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
X_13318_ _05493_ _05616_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__nand2_1
X_14298_ _06527_ VGND VGND VPWR VPWR _06539_ sky130_fd_sc_hd__buf_4
XFILLER_6_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16037_ clknet_leaf_15_clk _00049_ _00285_ VGND VGND VPWR VPWR add_res\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_97_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13249_ _05516_ _05515_ VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__or2_1
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08790_ _00833_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_84_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09411_ _01709_ _01603_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__nand2_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_17_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_09342_ _01607_ _01639_ _01640_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__a21oi_2
X_09273_ _01565_ _01568_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__nor2_1
XFILLER_119_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08224_ _00522_ _07862_ VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08155_ _07824_ _07825_ _07839_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__nand3_1
XFILLER_119_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08086_ _07854_ _07856_ VGND VGND VPWR VPWR _07857_ sky130_fd_sc_hd__nand2_1
XFILLER_102_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08988_ _01197_ _01283_ _01286_ VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__a21boi_1
XFILLER_56_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07939_ _07434_ _07528_ VGND VGND VPWR VPWR _07533_ sky130_fd_sc_hd__nand2_1
XFILLER_83_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10950_ _03089_ _03177_ _03176_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__a21boi_1
XFILLER_113_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09609_ _01714_ _01717_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__nand2_1
X_10881_ _03023_ _03019_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__nand2_1
XFILLER_28_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12620_ _04918_ _04860_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12551_ _04849_ _04799_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__nand2_1
X_15270_ _07510_ VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__clkbuf_1
X_11502_ net131 net205 VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__nand2_1
X_12482_ _04723_ _04777_ _04778_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__nand3b_2
X_14221_ _06461_ VGND VGND VPWR VPWR _06462_ sky130_fd_sc_hd__buf_2
XFILLER_11_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11433_ _03731_ net118 net222 VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__and3_1
X_14152_ _06397_ VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__inv_2
XFILLER_98_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11364_ _03660_ _03662_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__nand2_1
X_10315_ _02613_ _02588_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__nand2_1
XFILLER_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14083_ _06066_ _06337_ _06338_ _06339_ _06340_ VGND VGND VPWR VPWR _06341_ sky130_fd_sc_hd__a41o_1
X_13103_ _03127_ _04882_ _05393_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__o21ai_1
X_11295_ _03589_ _03591_ _03593_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_115_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10246_ _02544_ _02468_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__nand2_1
XFILLER_3_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13034_ _05205_ _05332_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__nand2_1
X_10177_ _02474_ _02293_ _02475_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__nand3_1
XFILLER_93_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14985_ _07225_ _06740_ _07226_ VGND VGND VPWR VPWR _07228_ sky130_fd_sc_hd__nand3_1
XFILLER_59_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13936_ _06200_ _06207_ VGND VGND VPWR VPWR _06208_ sky130_fd_sc_hd__nand2_1
XFILLER_62_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15606_ net275 VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__inv_2
X_13867_ _06084_ _06130_ _06131_ _06134_ _06141_ VGND VGND VPWR VPWR _06142_ sky130_fd_sc_hd__o2111ai_1
X_13798_ _06063_ _06068_ _06070_ _06072_ VGND VGND VPWR VPWR _06073_ sky130_fd_sc_hd__or4_1
XFILLER_62_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12818_ _05044_ _05116_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__nand2_1
X_15537_ add_res\[29\] net389 net260 VGND VGND VPWR VPWR _07730_ sky130_fd_sc_hd__mux2_1
XFILLER_63_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12749_ _05047_ _05003_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__nand2_1
XFILLER_30_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15468_ _07685_ _07620_ VGND VGND VPWR VPWR _07688_ sky130_fd_sc_hd__nand2_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14419_ _06658_ VGND VGND VPWR VPWR _06659_ sky130_fd_sc_hd__inv_2
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15399_ _07621_ _05704_ _05740_ VGND VGND VPWR VPWR _07625_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_6_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
X_09960_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__inv_2
X_08911_ _01209_ _00988_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__nand2_1
X_09891_ _02185_ _02188_ _02189_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__o21ai_1
XFILLER_111_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08842_ net213 net165 VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__nand2_1
X_08773_ _01065_ _01068_ _01071_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__nand3b_1
XFILLER_53_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09325_ _01623_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__inv_2
X_09256_ net210 net173 VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__nand2_1
X_08207_ _00505_ _00503_ VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__nand2_1
XFILLER_107_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09187_ _01479_ _01476_ _01477_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__nand3_1
XFILLER_119_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08138_ _00435_ _00436_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__nand2_1
XFILLER_108_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08069_ _07822_ _07823_ VGND VGND VPWR VPWR _07840_ sky130_fd_sc_hd__nand2_1
X_10100_ _02381_ _02397_ _02398_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__nand3_2
XFILLER_68_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11080_ _03324_ _03376_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__nand2_1
XFILLER_108_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10031_ _02328_ _02325_ _02326_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14770_ _07009_ _06573_ VGND VGND VPWR VPWR _07010_ sky130_fd_sc_hd__nand2_1
XFILLER_29_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13721_ adder_inst.man_b\[23\] _06008_ VGND VGND VPWR VPWR adder_inst.is_zero_b sky130_fd_sc_hd__nor2_1
XFILLER_90_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11982_ _04278_ _04280_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__nand2_1
X_10933_ _03226_ _03228_ _03231_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__nand3_1
X_13652_ _05944_ _05945_ VGND VGND VPWR VPWR _05946_ sky130_fd_sc_hd__nand2_1
XFILLER_71_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10864_ _03159_ _03162_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__nand2_1
X_13583_ _05874_ VGND VGND VPWR VPWR _05880_ sky130_fd_sc_hd__inv_2
X_12603_ _04879_ _04900_ _04901_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__nand3_1
X_10795_ net188 net155 VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15322_ _07545_ _02983_ VGND VGND VPWR VPWR _07547_ sky130_fd_sc_hd__nand2_1
X_12534_ _04832_ net110 net199 VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_42_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15253_ _07492_ multiplier_inst.man_final_r\[4\] _07494_ VGND VGND VPWR VPWR _07500_
+ sky130_fd_sc_hd__and3_1
X_12465_ net109 net202 net113 net199 VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__a22o_1
XFILLER_8_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15184_ _06647_ _06646_ VGND VGND VPWR VPWR _07438_ sky130_fd_sc_hd__or2_1
X_14204_ _06439_ _06444_ VGND VGND VPWR VPWR _06445_ sky130_fd_sc_hd__nand2_2
X_11416_ _03713_ _03714_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__nand2_1
X_12396_ _04693_ _04694_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__nand2_1
X_14135_ adder_inst.is_nan_r adder_inst.is_inf_r net103 VGND VGND VPWR VPWR _06387_
+ sky130_fd_sc_hd__o21a_1
XFILLER_113_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11347_ _03614_ _03618_ _03645_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__nand3_1
XFILLER_3_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14066_ _06183_ _06190_ _06325_ VGND VGND VPWR VPWR _06326_ sky130_fd_sc_hd__and3_1
X_11278_ _03575_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__nand2_1
X_10229_ _02526_ _02518_ _02507_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__nand3b_1
XFILLER_79_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13017_ _05273_ _05272_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__nor2_1
Xhold1 adder_inst.i_vld VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_94_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14968_ _07162_ _07209_ VGND VGND VPWR VPWR _07210_ sky130_fd_sc_hd__nand2_1
XFILLER_47_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13919_ _06190_ VGND VGND VPWR VPWR _06193_ sky130_fd_sc_hd__dlymetal6s2s_1
X_14899_ _07119_ _06801_ _07001_ VGND VGND VPWR VPWR _07137_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09110_ _01403_ _01400_ _01404_ VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__nand3_1
X_09041_ _07498_ _07476_ _07511_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_79_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09943_ adder_inst.man_b_r\[9\] net247 VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09874_ _02172_ _01860_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__nand2_1
XFILLER_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08825_ _01123_ _01014_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__nand2_1
XFILLER_58_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08756_ net139 net235 VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__nand2_1
XFILLER_45_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08687_ _00982_ VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__inv_2
XFILLER_110_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09308_ _01544_ _01606_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__nand2_1
X_10580_ net163 VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__inv_2
XFILLER_70_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09239_ _01537_ _01202_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__nand2_1
XFILLER_119_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12250_ _04536_ _04541_ _04548_ VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11201_ _01327_ _01315_ _01317_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__a21boi_1
X_12181_ _04478_ _04479_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11132_ _03430_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_112_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15940_ clknet_leaf_17_clk adder_inst.sum_raw\[15\] _00188_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[15\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_49_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11063_ _03358_ _03361_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__nand2_1
X_10014_ _02280_ _02275_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__nand2_1
XFILLER_88_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15871_ clknet_leaf_0_clk net3 _00119_ VGND VGND VPWR VPWR adder_inst.i_a\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14822_ _07056_ _07057_ VGND VGND VPWR VPWR _07058_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_47_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14753_ _06913_ _06992_ VGND VGND VPWR VPWR _06993_ sky130_fd_sc_hd__nand2_1
XFILLER_72_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11965_ _04261_ _04263_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__nand2_1
XFILLER_29_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13704_ adder_inst.exp_a\[0\] VGND VGND VPWR VPWR _05994_ sky130_fd_sc_hd__inv_2
X_14684_ _06914_ _06919_ _06802_ VGND VGND VPWR VPWR _06924_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10916_ _03211_ _03214_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__nand2_1
XFILLER_32_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13635_ _05927_ _05929_ VGND VGND VPWR VPWR _05930_ sky130_fd_sc_hd__nand2_1
XFILLER_44_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11896_ _04192_ _04194_ VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__nand2_1
X_10847_ _03055_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_4_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13566_ _05852_ adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR _05863_ sky130_fd_sc_hd__nand2_1
X_10778_ _03071_ _03073_ _03076_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nand3_1
XFILLER_12_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15305_ multiplier_inst.is_nan_r _06394_ multiplier_inst.sign_res_r VGND VGND VPWR
+ VPWR _07529_ sky130_fd_sc_hd__or3b_1
X_12517_ net118 net187 VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__nand2_1
X_13497_ _05783_ _05347_ VGND VGND VPWR VPWR _05796_ sky130_fd_sc_hd__nand2_1
X_15236_ _07487_ VGND VGND VPWR VPWR adder_inst.exp_larger\[5\] sky130_fd_sc_hd__clkbuf_1
XFILLER_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12448_ _04744_ _04746_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__nand2_1
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15167_ _07390_ _07386_ VGND VGND VPWR VPWR _07420_ sky130_fd_sc_hd__nand2_1
X_12379_ _04671_ _04677_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__xor2_1
X_14118_ adder_inst.sum_raw_r\[16\] net255 _06277_ adder_inst.sum_raw_r\[14\] VGND
+ VGND VPWR VPWR _06372_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_74_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15098_ _07345_ _07346_ VGND VGND VPWR VPWR _07347_ sky130_fd_sc_hd__nand2_1
X_14049_ _06231_ _06309_ VGND VGND VPWR VPWR _06310_ sky130_fd_sc_hd__nand2_1
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08610_ _00712_ _00713_ _00644_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09590_ _01888_ _01802_ _01801_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__nand3_1
XFILLER_55_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08541_ _00839_ _00559_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__nand2_1
X_08472_ net218 net150 VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_59_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09024_ net188 net164 VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_68_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09926_ adder_inst.man_b_r\[11\] net247 VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__nand2_1
XFILLER_77_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09857_ _02147_ _02155_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__nand2_1
XFILLER_58_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09788_ _02086_ _01911_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__nor2_1
XFILLER_85_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08808_ _01087_ _01106_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__nor2_1
X_08739_ _01036_ _00894_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__nand2_1
XFILLER_45_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_77_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11750_ _04041_ _04042_ _04048_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__nand3_2
XFILLER_81_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10701_ _02999_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__inv_2
XFILLER_81_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11681_ _03978_ _03979_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10632_ _02929_ _02930_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__nand2_1
X_13420_ _05715_ _04434_ VGND VGND VPWR VPWR _05719_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13351_ _05648_ adder_inst.exp_a_r\[0\] VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__and2_1
X_10563_ _02861_ _02813_ _02823_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__a21o_1
XFILLER_14_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_16070_ clknet_leaf_11_clk _00071_ _00318_ VGND VGND VPWR VPWR multiplier_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_2
X_12302_ _04599_ _04588_ _04600_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__nand3b_1
X_10494_ _02785_ _02792_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__nor2_1
X_15021_ _07261_ _07266_ VGND VGND VPWR VPWR _07267_ sky130_fd_sc_hd__nand2_1
X_13282_ _05578_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__nand2b_1
X_12233_ _02989_ _04531_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__nand2_1
XFILLER_30_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12164_ _04452_ _04391_ _04453_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__a21oi_1
XFILLER_96_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11115_ _01324_ _01320_ _01322_ VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__a21oi_2
XFILLER_1_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12095_ _04387_ _04389_ _04391_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__nand3_1
X_15923_ clknet_leaf_11_clk net57 _00171_ VGND VGND VPWR VPWR adder_inst.i_b\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11046_ _03283_ _03342_ _03344_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__o21ai_1
XFILLER_92_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15854_ net294 VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__inv_2
XFILLER_91_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15785_ net301 VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__inv_2
X_14805_ _07041_ _07042_ VGND VGND VPWR VPWR _07043_ sky130_fd_sc_hd__nand2_1
XFILLER_29_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14736_ _06662_ _06547_ VGND VGND VPWR VPWR _06976_ sky130_fd_sc_hd__nand2_1
X_12997_ _05295_ _05188_ VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__nand2_1
XFILLER_45_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11948_ _04244_ _04246_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__nand2_1
XFILLER_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14667_ _06903_ _06906_ VGND VGND VPWR VPWR _06907_ sky130_fd_sc_hd__nand2_1
X_11879_ _04108_ _04109_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__nand2b_1
X_13618_ _05855_ _05853_ _05912_ VGND VGND VPWR VPWR _05913_ sky130_fd_sc_hd__or3_1
X_14598_ _06466_ _06835_ _06488_ _06837_ VGND VGND VPWR VPWR _06838_ sky130_fd_sc_hd__o211ai_1
XFILLER_20_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13549_ _05845_ _05846_ VGND VGND VPWR VPWR _05847_ sky130_fd_sc_hd__nor2_1
XFILLER_9_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_76_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15219_ _07471_ _07474_ VGND VGND VPWR VPWR _07475_ sky130_fd_sc_hd__nand2_1
XFILLER_99_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09711_ _01970_ _01972_ _01992_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__nand3_1
X_07972_ _07742_ _07702_ VGND VGND VPWR VPWR _07743_ sky130_fd_sc_hd__nand2_1
XFILLER_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09642_ _01928_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__inv_2
XFILLER_82_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09573_ _01532_ _01535_ _01698_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__nand3_1
XFILLER_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08524_ _00779_ _00789_ _00788_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__a21boi_2
XFILLER_36_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08455_ _00745_ _00752_ _00753_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__nand3_1
X_08386_ net130 net238 VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__nand2_1
XFILLER_50_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09007_ net185 net169 VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__nand2_1
XFILLER_105_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09909_ _02201_ _02202_ _02203_ _02207_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__o22ai_1
XFILLER_86_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12920_ _05127_ _05122_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_85_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12851_ _05147_ _05137_ _05109_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__nand3_1
XFILLER_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11802_ _04099_ _04100_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_1_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15570_ net274 VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_107_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12782_ _05080_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__inv_2
XFILLER_92_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14521_ _06759_ _06760_ _06516_ VGND VGND VPWR VPWR _06761_ sky130_fd_sc_hd__a21o_1
XFILLER_41_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11733_ _03744_ _04031_ _03747_ VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__o21a_1
X_14452_ _06552_ _06688_ _06691_ VGND VGND VPWR VPWR _06692_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_60_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11664_ _03961_ _03962_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__nand2_1
X_10615_ _02913_ _02884_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__nand2_1
X_13403_ _05671_ _05701_ VGND VGND VPWR VPWR _05702_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_94_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16122_ clknet_leaf_19_clk _00078_ _00370_ VGND VGND VPWR VPWR mul_res\[15\] sky130_fd_sc_hd__dfrtp_1
X_14383_ _06621_ _06622_ VGND VGND VPWR VPWR _06623_ sky130_fd_sc_hd__nor2_1
X_11595_ _03892_ _03888_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__nand2_1
X_10546_ _02842_ _02769_ _02844_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__nand3_1
X_13334_ _05631_ _05632_ VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__nand2_1
XFILLER_41_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16053_ clknet_leaf_11_clk adder_inst.exp_larger\[5\] _00301_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_10477_ _02704_ _02701_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__nand2_1
X_13265_ _05542_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__inv_2
X_15004_ _06790_ VGND VGND VPWR VPWR _07248_ sky130_fd_sc_hd__inv_2
X_12216_ _04507_ _04505_ _04500_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__a21boi_1
X_13196_ _05494_ VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_9_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12147_ _04380_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__inv_2
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12078_ _04375_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__nand2_1
XFILLER_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15906_ clknet_leaf_0_clk net38 _00154_ VGND VGND VPWR VPWR adder_inst.i_b\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_11029_ _03322_ _03326_ _03327_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__a21bo_1
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15837_ net297 VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__inv_2
XFILLER_2_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15768_ net282 VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__inv_2
XFILLER_33_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15699_ net290 VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__inv_2
X_14719_ _06957_ _06958_ VGND VGND VPWR VPWR _06959_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08240_ net146 net221 VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__nand2_1
XFILLER_33_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08171_ _00468_ _00469_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__nand2_1
XFILLER_118_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput100 net100 VGND VGND VPWR VPWR o_res_vld sky130_fd_sc_hd__buf_2
XFILLER_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07955_ _07681_ _07328_ VGND VGND VPWR VPWR _07689_ sky130_fd_sc_hd__nor2_1
X_09625_ _01752_ _01755_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__nand2_1
XFILLER_46_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09556_ _01846_ _01851_ _01854_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_54_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09487_ net142 net239 VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__nand2_1
XFILLER_62_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08507_ net142 net226 VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__nand2_1
XFILLER_102_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08438_ _00735_ _00736_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__nand2_1
XFILLER_23_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08369_ _00611_ _00603_ _00612_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__nand3b_1
X_10400_ _02698_ _02695_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__nand2_1
X_11380_ _03472_ _03469_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__nand2_1
X_10331_ _02399_ _02626_ _02629_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__nand3_2
XFILLER_3_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10262_ _02560_ _02490_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__nand2_1
X_13050_ _05342_ _05337_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__nand2_1
XFILLER_105_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12001_ _04298_ _04296_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__or2_1
X_10193_ _02490_ _02476_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__nand2_1
XFILLER_105_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13952_ adder_inst.sum_raw_r\[19\] _06108_ _06214_ VGND VGND VPWR VPWR _06222_ sky130_fd_sc_hd__or3b_1
XFILLER_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12903_ _05200_ _05195_ _05197_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__nand3b_1
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13883_ _06154_ _06155_ _06156_ _06157_ VGND VGND VPWR VPWR _06158_ sky130_fd_sc_hd__a211o_1
X_15622_ net295 VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__inv_2
XFILLER_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12834_ _05061_ _05057_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__nand2_1
XFILLER_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15553_ net272 VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__inv_2
XFILLER_14_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12765_ _05048_ _05063_ VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__nand2_1
X_14504_ _06709_ _06484_ VGND VGND VPWR VPWR _06744_ sky130_fd_sc_hd__nand2_1
XFILLER_15_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11716_ _04013_ _04011_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__nand2_1
XFILLER_30_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15484_ _07698_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__clkbuf_1
X_12696_ _04993_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__inv_2
XFILLER_30_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14435_ _06649_ _06639_ VGND VGND VPWR VPWR _06675_ sky130_fd_sc_hd__nand2_1
Xinput13 i_a[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
XFILLER_52_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11647_ _03945_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__inv_2
Xinput24 i_a[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput35 i_b[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput46 i_b[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
X_14366_ _06605_ VGND VGND VPWR VPWR _06606_ sky130_fd_sc_hd__inv_2
X_11578_ _03875_ _03876_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__nand2_1
Xinput57 i_b[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
X_16105_ clknet_leaf_11_clk multiplier_inst.sign_res _00353_ VGND VGND VPWR VPWR multiplier_inst.sign_res_r
+ sky130_fd_sc_hd__dfrtp_1
X_10529_ _02821_ _02817_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__and2_1
X_13317_ _05610_ _05615_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__nand2_1
XFILLER_6_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16036_ clknet_leaf_15_clk _00048_ _00284_ VGND VGND VPWR VPWR add_res\[20\] sky130_fd_sc_hd__dfrtp_1
X_14297_ net114 net183 _06440_ VGND VGND VPWR VPWR _06538_ sky130_fd_sc_hd__mux2_1
X_13248_ _05542_ _05546_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__or2_1
XFILLER_97_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13179_ _05476_ _05477_ VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__nand2_1
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09410_ _01705_ _01708_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__nand2_1
XFILLER_25_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09341_ _01606_ _01544_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__nor2_1
XFILLER_21_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09272_ _01565_ _01568_ _01570_ VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__o21ai_1
XFILLER_60_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08223_ _07882_ _07884_ VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08154_ _07816_ _07819_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__nand2_1
X_08085_ _07855_ VGND VGND VPWR VPWR _07856_ sky130_fd_sc_hd__inv_2
XFILLER_106_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08987_ _01284_ _01285_ VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__nand2_1
XFILLER_87_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07938_ _07504_ _07523_ VGND VGND VPWR VPWR _07528_ sky130_fd_sc_hd__nand2_1
XFILLER_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09608_ _01900_ _01906_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__xor2_1
XFILLER_73_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10880_ _03178_ _03176_ VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__nand2_1
XFILLER_28_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09539_ _01826_ _01837_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12550_ _04781_ _04846_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11501_ _03232_ _03226_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__nand2_1
X_12481_ _04779_ _04723_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__nand2_1
X_14220_ _06460_ VGND VGND VPWR VPWR _06461_ sky130_fd_sc_hd__inv_2
XFILLER_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11432_ _03730_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__inv_2
X_14151_ _06396_ _06018_ _06187_ _06394_ VGND VGND VPWR VPWR _06397_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_59_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13102_ _05394_ net178 net120 VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__and3_1
X_11363_ _03661_ _03486_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__nand2_1
X_10314_ _02610_ _02611_ VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__nand2_1
XFILLER_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14082_ _06305_ net253 _06113_ _06295_ _06065_ VGND VGND VPWR VPWR _06340_ sky130_fd_sc_hd__a221o_1
XFILLER_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11294_ _03592_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_115_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10245_ _02467_ _02472_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__nand2_1
XFILLER_98_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13033_ _05190_ _05203_ VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__nand2_1
X_10176_ _02289_ _02292_ _02291_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__a21o_1
XFILLER_79_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14984_ _07225_ _06740_ _07226_ VGND VGND VPWR VPWR _07227_ sky130_fd_sc_hd__a21o_1
Xfanout190 net191 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_2
XFILLER_19_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13935_ adder_inst.sum_raw_r\[1\] VGND VGND VPWR VPWR _06207_ sky130_fd_sc_hd__inv_2
XFILLER_93_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13866_ adder_inst.exp_larger_r\[2\] _06113_ _06065_ _06137_ _06140_ VGND VGND VPWR
+ VPWR _06141_ sky130_fd_sc_hd__a2111o_1
XFILLER_74_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15605_ net274 VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__inv_2
X_12817_ _05112_ _05113_ _05115_ VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__nand3_1
XFILLER_34_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13797_ adder_inst.sum_raw_r\[0\] adder_inst.sum_raw_r\[1\] adder_inst.sum_raw_r\[3\]
+ _06071_ VGND VGND VPWR VPWR _06072_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_17_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15536_ _07729_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_15_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12748_ _05045_ _05046_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__nand2_1
X_15467_ _07686_ _07687_ VGND VGND VPWR VPWR multiplier_inst.man_final\[18\] sky130_fd_sc_hd__nand2_1
X_12679_ _04976_ _04977_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__nand2_1
X_14418_ _06656_ _06657_ VGND VGND VPWR VPWR _06658_ sky130_fd_sc_hd__nand2_1
XFILLER_8_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15398_ _07620_ _07623_ _07624_ VGND VGND VPWR VPWR multiplier_inst.man_final\[5\]
+ sky130_fd_sc_hd__o21ai_1
X_14349_ _06552_ _04869_ VGND VGND VPWR VPWR _06589_ sky130_fd_sc_hd__nand2_1
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16019_ clknet_leaf_18_clk _00061_ _00267_ VGND VGND VPWR VPWR add_res\[3\] sky130_fd_sc_hd__dfrtp_1
X_09890_ _02178_ _02187_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__or2_1
X_08910_ _01208_ _00968_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__nand2_1
XFILLER_97_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08841_ _01139_ VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__inv_2
XFILLER_111_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08772_ _01069_ _01070_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__nand2_1
XFILLER_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09324_ net142 net236 VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__nand2_1
X_09255_ _01553_ _01226_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__nand2_1
X_08206_ _00500_ _00503_ _00504_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__nand3b_1
X_09186_ _01478_ _01481_ VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__nand2_1
XFILLER_119_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08137_ _00434_ _00425_ _00426_ VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__nand3b_2
XFILLER_107_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08068_ _07835_ VGND VGND VPWR VPWR _07839_ sky130_fd_sc_hd__inv_2
XFILLER_108_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10030_ _02327_ _02328_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__nand2_1
XFILLER_102_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11981_ _04279_ VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__inv_2
XFILLER_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13720_ _06002_ _06007_ VGND VGND VPWR VPWR _06008_ sky130_fd_sc_hd__or2_1
X_10932_ _03100_ _03092_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__nand2_1
XFILLER_16_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13651_ _05848_ _05942_ VGND VGND VPWR VPWR _05945_ sky130_fd_sc_hd__nand2_1
XFILLER_44_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10863_ _03161_ _03124_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__nand2_1
X_13582_ _05874_ _05878_ _05652_ VGND VGND VPWR VPWR _05879_ sky130_fd_sc_hd__nor3_1
XFILLER_71_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12602_ _04889_ _04898_ _04890_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__nand3_1
X_10794_ net189 net152 VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15321_ _02983_ _07545_ VGND VGND VPWR VPWR _07546_ sky130_fd_sc_hd__or2_1
X_12533_ _04829_ VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_42_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15252_ _07499_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_117_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14203_ _06443_ VGND VGND VPWR VPWR _06444_ sky130_fd_sc_hd__inv_2
X_12464_ _04556_ net109 net198 VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__and3_1
XFILLER_8_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15183_ _07409_ _07436_ VGND VGND VPWR VPWR _07437_ sky130_fd_sc_hd__nand2_1
X_11415_ _03712_ _03705_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__nand2_1
X_12395_ _04607_ _04605_ _04606_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__nand3b_1
X_14134_ adder_inst.is_nan_r _06386_ net103 VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__o21a_1
X_11346_ _03644_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__inv_2
X_14065_ net249 adder_inst.sum_raw_r\[16\] adder_inst.sum_raw_r\[15\] _06076_ _06324_
+ VGND VGND VPWR VPWR _06325_ sky130_fd_sc_hd__a221o_1
X_11277_ _03509_ _03416_ _03415_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__nand3_1
X_13016_ _05312_ _05314_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__nand2_1
X_10228_ _02519_ _02526_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__nand2_1
Xhold2 adder_inst.i_vld_r VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_66_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10159_ _01700_ _01872_ VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__nand2_1
XFILLER_58_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14967_ _07208_ VGND VGND VPWR VPWR _07209_ sky130_fd_sc_hd__inv_2
XFILLER_66_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13918_ _06182_ VGND VGND VPWR VPWR _06192_ sky130_fd_sc_hd__dlymetal6s2s_1
X_14898_ _06818_ _07135_ VGND VGND VPWR VPWR _07136_ sky130_fd_sc_hd__xnor2_1
XFILLER_90_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13849_ _06123_ VGND VGND VPWR VPWR _06124_ sky130_fd_sc_hd__inv_2
XFILLER_22_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15519_ add_res\[20\] mul_res\[20\] net260 VGND VGND VPWR VPWR _07719_ sky130_fd_sc_hd__mux2_1
X_09040_ _01333_ _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__nand2_1
XFILLER_30_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09942_ _02237_ _02240_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__nand2_1
XFILLER_100_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09873_ _02171_ _01855_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__nand2_1
XFILLER_58_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08824_ _01121_ _01122_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__nand2_1
XFILLER_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08755_ _01053_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__inv_2
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08686_ _00970_ _00778_ _00972_ VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__nand3_1
XFILLER_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09307_ _01580_ _01599_ _01605_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__a21boi_1
XFILLER_110_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09238_ _01275_ _01272_ VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__nand2_1
XFILLER_21_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09169_ _01457_ _01466_ _01467_ VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__nand3_1
XFILLER_119_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11200_ _03492_ _03498_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__nand2_1
X_12180_ _04445_ _04450_ _04470_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__nand3_1
XFILLER_102_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11131_ _03419_ _03428_ _03429_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_112_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11062_ _03359_ _03360_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__nand2_1
X_10013_ _02309_ _02311_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__nand2_1
XFILLER_88_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15870_ clknet_leaf_0_clk net2 _00118_ VGND VGND VPWR VPWR adder_inst.i_a\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_76_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14821_ _06909_ _07033_ VGND VGND VPWR VPWR _07057_ sky130_fd_sc_hd__nand2_1
XFILLER_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14752_ _06950_ _06991_ VGND VGND VPWR VPWR _06992_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_47_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11964_ _04262_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__inv_2
X_13703_ adder_inst.exp_a\[1\] VGND VGND VPWR VPWR _05993_ sky130_fd_sc_hd__inv_2
X_14683_ _06922_ VGND VGND VPWR VPWR _06923_ sky130_fd_sc_hd__inv_2
X_10915_ _03212_ _03213_ _03180_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__nand3_1
XFILLER_17_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11895_ _04193_ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__inv_2
X_13634_ _05879_ _05928_ _05922_ VGND VGND VPWR VPWR _05929_ sky130_fd_sc_hd__nand3_1
X_10846_ _03144_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_27_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15304_ net105 _07525_ net375 _00104_ VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__a31o_1
X_13565_ _05861_ VGND VGND VPWR VPWR _05862_ sky130_fd_sc_hd__inv_2
X_10777_ _03074_ _03075_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__nand2_1
X_13496_ _05664_ _05784_ VGND VGND VPWR VPWR _05795_ sky130_fd_sc_hd__nand2_1
X_12516_ _04813_ _04814_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__nand2_1
XFILLER_40_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15235_ adder_inst.exp_a_r\[5\] adder_inst.exp_b_r\[5\] _06563_ VGND VGND VPWR VPWR
+ _07487_ sky130_fd_sc_hd__mux2_1
X_12447_ _04745_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__inv_2
X_15166_ _07417_ _07418_ _07178_ VGND VGND VPWR VPWR _07419_ sky130_fd_sc_hd__a21o_1
X_14117_ _06371_ VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__clkbuf_1
X_12378_ _04674_ _04676_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__nor2_1
XFILLER_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15097_ _06594_ VGND VGND VPWR VPWR _07346_ sky130_fd_sc_hd__inv_2
X_11329_ _03626_ _03627_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__nand2_1
X_14048_ adder_inst.sum_raw_r\[9\] net255 VGND VGND VPWR VPWR _06309_ sky130_fd_sc_hd__nand2_1
XFILLER_79_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_105_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15999_ clknet_leaf_1_clk net355 _00247_ VGND VGND VPWR VPWR adder_inst.man_b_r\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_54_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08540_ _00838_ _00521_ VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__nand2_1
XFILLER_63_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08471_ _00741_ _00769_ VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_114_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09023_ _07490_ _01321_ VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__nor2_1
XFILLER_116_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09925_ _02222_ _01448_ _02223_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__o21ai_1
XFILLER_49_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09856_ _02152_ _02154_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__nand2_1
XFILLER_112_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08807_ _01104_ _01105_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__nand2_1
XFILLER_105_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09787_ net219 net174 VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__nand2_1
XFILLER_73_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08738_ _01033_ _00894_ _01036_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__nand3_1
XFILLER_39_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08669_ _00938_ _00967_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__nand2_1
XFILLER_81_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10700_ net201 net143 VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__nand2_1
X_11680_ _03977_ _03972_ _03973_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_24_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10631_ _02928_ _02927_ VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__nand2_1
XFILLER_41_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13350_ adder_inst.exp_a_r\[0\] _05648_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__nor2_1
X_10562_ _02824_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__inv_2
XFILLER_14_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13281_ _05569_ _05579_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__xor2_1
XFILLER_5_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12301_ _04584_ _04586_ VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__nand2_1
XFILLER_108_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10493_ _02789_ _02790_ _02791_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__nand3_1
X_15020_ _07264_ VGND VGND VPWR VPWR _07266_ sky130_fd_sc_hd__inv_2
X_12232_ _04364_ _04530_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__nor2_1
XFILLER_107_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12163_ _04461_ VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__inv_2
XFILLER_96_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11114_ _03412_ _03053_ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__nand2_1
X_12094_ _04390_ _04392_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__nand2_1
X_15922_ clknet_leaf_7_clk net56 _00170_ VGND VGND VPWR VPWR adder_inst.exp_b\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_39_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11045_ _03281_ _03343_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__nand2_1
XFILLER_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15853_ net300 VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__inv_2
X_15784_ net301 VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__inv_2
XFILLER_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14804_ _05998_ VGND VGND VPWR VPWR _07042_ sky130_fd_sc_hd__clkbuf_4
X_12996_ _05181_ _05134_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__nand2_1
X_14735_ _06973_ _06714_ _06974_ VGND VGND VPWR VPWR _06975_ sky130_fd_sc_hd__nand3_1
X_11947_ _04245_ VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__inv_2
XFILLER_72_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14666_ _06904_ _06905_ VGND VGND VPWR VPWR _06906_ sky130_fd_sc_hd__nand2_1
XFILLER_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11878_ _04109_ _04108_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__nand2b_1
X_13617_ _05910_ _05911_ VGND VGND VPWR VPWR _05912_ sky130_fd_sc_hd__nor2_2
X_14597_ _06836_ _06466_ VGND VGND VPWR VPWR _06837_ sky130_fd_sc_hd__nand2_1
X_10829_ net164 VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__inv_2
X_13548_ _05740_ _05807_ VGND VGND VPWR VPWR _05846_ sky130_fd_sc_hd__nand2_1
XFILLER_9_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15218_ _07473_ VGND VGND VPWR VPWR _07474_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_76_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13479_ _05773_ _05777_ VGND VGND VPWR VPWR _05778_ sky130_fd_sc_hd__nand2_1
XFILLER_114_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15149_ _07393_ _07400_ _07042_ VGND VGND VPWR VPWR _07401_ sky130_fd_sc_hd__a21o_1
XFILLER_99_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07971_ _07702_ _07714_ _07741_ VGND VGND VPWR VPWR _07742_ sky130_fd_sc_hd__nand3_1
XFILLER_99_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09710_ _01837_ _02008_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__nand2_1
XFILLER_67_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09641_ _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_87_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09572_ _01867_ _01698_ _01870_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__nand3b_1
XFILLER_27_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08523_ _00821_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__inv_2
XFILLER_63_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08454_ _00743_ _00473_ _00472_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__nand3_1
XFILLER_51_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08385_ net122 net241 VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__nand2_1
XFILLER_11_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09006_ _07223_ _01304_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__or2_1
XFILLER_105_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09908_ _02206_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__inv_2
X_09839_ _02001_ _02006_ _02015_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__nand3_1
XFILLER_76_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12850_ _05138_ _05148_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_29_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11801_ _03958_ _03953_ VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__and2_1
XFILLER_27_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14520_ _06460_ _06711_ VGND VGND VPWR VPWR _06760_ sky130_fd_sc_hd__or2_1
XFILLER_54_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12781_ net113 net216 VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__nand2_1
XFILLER_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_107_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11732_ _03749_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__inv_2
X_14451_ _06552_ net145 VGND VGND VPWR VPWR _06691_ sky130_fd_sc_hd__nand2_1
XFILLER_41_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11663_ _03958_ _03960_ _03959_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__nand3_1
X_10614_ _02885_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__inv_2
X_14382_ _06619_ _01042_ _06558_ VGND VGND VPWR VPWR _06622_ sky130_fd_sc_hd__mux2_1
XFILLER_41_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13402_ _05699_ _05700_ VGND VGND VPWR VPWR _05701_ sky130_fd_sc_hd__nand2_1
X_16121_ clknet_leaf_15_clk _00077_ _00369_ VGND VGND VPWR VPWR mul_res\[14\] sky130_fd_sc_hd__dfrtp_1
X_13333_ _05623_ _05627_ _05621_ VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__o21a_1
X_11594_ _03888_ _03892_ VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__or2_1
X_10545_ _02843_ _02756_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__nand2_1
XFILLER_41_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16052_ clknet_leaf_10_clk adder_inst.exp_larger\[4\] _00300_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_10476_ _02774_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__inv_2
X_13264_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__inv_2
XFILLER_108_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15003_ _07245_ _07246_ _07173_ VGND VGND VPWR VPWR _07247_ sky130_fd_sc_hd__a21o_1
X_13195_ _05492_ _05493_ VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__nand2_1
X_12215_ _04512_ _03695_ VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__nand2_1
X_12146_ _04438_ _04444_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12077_ _03580_ _04370_ _03584_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__nand3_1
X_15905_ clknet_leaf_0_clk net37 _00153_ VGND VGND VPWR VPWR adder_inst.i_b\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11028_ net106 net238 VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__nand2_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15836_ net297 VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__inv_2
XFILLER_64_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15767_ net282 VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__inv_2
X_12979_ _05277_ _05245_ VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__nand2_1
XFILLER_18_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15698_ net303 VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__inv_2
X_14718_ _06553_ adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR _06958_ sky130_fd_sc_hd__nand2_1
XFILLER_33_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14649_ _06882_ _06888_ VGND VGND VPWR VPWR _06889_ sky130_fd_sc_hd__nand2_1
XFILLER_33_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08170_ _00466_ _07793_ _07791_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__nand3_1
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput101 net101 VGND VGND VPWR VPWR overflow sky130_fd_sc_hd__buf_2
XFILLER_118_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07954_ net191 net176 VGND VGND VPWR VPWR _07681_ sky130_fd_sc_hd__nand2_1
XFILLER_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09624_ _01898_ _01922_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__nand2_1
XFILLER_83_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09555_ _01849_ _01651_ _01853_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_54_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09486_ _01783_ _01784_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__nand2_1
XFILLER_70_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08506_ _00804_ _00539_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__nand2_1
XFILLER_62_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08437_ _00519_ _00493_ _00513_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_34_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08368_ _00666_ _00611_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__nand2_1
XFILLER_109_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08299_ _00597_ _00585_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__nand2_1
X_10330_ _02627_ _02628_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__nand2_1
XFILLER_11_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10261_ _02559_ _02486_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__nand2_1
XFILLER_3_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12000_ _04296_ _04298_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__nand2_1
X_10192_ _02465_ _02476_ _02490_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__nand3_1
XFILLER_87_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13951_ adder_inst.sum_raw_r\[4\] VGND VGND VPWR VPWR _06221_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_109_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12902_ _05198_ _05200_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__nand2_1
XFILLER_19_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13882_ adder_inst.exp_larger_r\[3\] _06119_ _06120_ VGND VGND VPWR VPWR _06157_
+ sky130_fd_sc_hd__a21oi_1
X_15621_ net289 VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__inv_2
X_12833_ _05130_ _05131_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__nand2_1
X_15552_ net269 VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__inv_2
XFILLER_61_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12764_ _05062_ VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__inv_2
X_15483_ net397 mul_res\[2\] net258 VGND VGND VPWR VPWR _07698_ sky130_fd_sc_hd__mux2_1
X_14503_ _06465_ _06704_ VGND VGND VPWR VPWR _06743_ sky130_fd_sc_hd__or2_1
X_11715_ _03950_ _04011_ _04013_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__nand3_1
XFILLER_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12695_ _01663_ _04629_ _04993_ VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__o21ai_1
X_14434_ _06673_ VGND VGND VPWR VPWR _06674_ sky130_fd_sc_hd__inv_2
X_11646_ _03756_ _03724_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__nand2_1
Xinput25 i_a[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput36 i_b[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
X_14365_ _06603_ _04241_ _06553_ VGND VGND VPWR VPWR _06605_ sky130_fd_sc_hd__mux2_1
Xinput14 i_a[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_11577_ _03869_ _03870_ _03873_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__nand3_1
Xinput58 i_b[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
X_16104_ clknet_leaf_13_clk multiplier_inst.exp_final\[7\] _00352_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
X_10528_ net156 net247 VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__nand2_1
Xinput47 i_b[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_13316_ _05609_ _05607_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__nand2_1
X_14296_ _06535_ _06536_ _06453_ VGND VGND VPWR VPWR _06537_ sky130_fd_sc_hd__mux2_1
XFILLER_10_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16035_ clknet_leaf_15_clk _00046_ _00283_ VGND VGND VPWR VPWR add_res\[19\] sky130_fd_sc_hd__dfrtp_1
X_13247_ _05544_ _05545_ VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__nand2_1
X_10459_ _02756_ _02757_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__nand2_1
X_13178_ _05468_ _05475_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__nand2_1
XFILLER_111_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12129_ _04427_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__inv_2
XFILLER_111_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15819_ net302 VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__inv_2
XFILLER_25_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09340_ _01637_ _01638_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__nand2_2
X_09271_ _01569_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__inv_2
XFILLER_33_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08222_ _00458_ _00520_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__nand2_1
XFILLER_33_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08153_ _00447_ _00451_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__nand2_1
XFILLER_9_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08084_ net134 net221 VGND VGND VPWR VPWR _07855_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_95_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08986_ _01276_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__inv_2
X_07937_ _07511_ _07517_ _07465_ VGND VGND VPWR VPWR _07523_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_3_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09607_ _01902_ _01905_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__nor2_1
XFILLER_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09538_ _01834_ _01836_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__or2_1
XFILLER_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09469_ _01631_ _01633_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__nand2_1
XFILLER_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11500_ _03798_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__inv_2
XFILLER_12_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12480_ _04777_ _04778_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__nand2_1
X_11431_ net119 net220 VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__nand2_1
X_14150_ adder_inst.is_zero_r _06179_ VGND VGND VPWR VPWR _06396_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_59_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11362_ _03537_ _03542_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__nand2_1
X_10313_ _02610_ _02587_ _02611_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__nand3_1
X_13101_ _05399_ _05396_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__nand2_1
X_14081_ adder_inst.sum_raw_r\[12\] net256 VGND VGND VPWR VPWR _06339_ sky130_fd_sc_hd__nand2_1
XFILLER_3_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11293_ _01393_ _01380_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10244_ _02542_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__inv_2
X_13032_ _05293_ _05330_ VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__nor2_1
X_10175_ _02473_ _02467_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__nand2_1
XFILLER_93_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14983_ _06757_ VGND VGND VPWR VPWR _07226_ sky130_fd_sc_hd__inv_2
Xfanout180 net182 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_4
Xfanout191 adder_inst.man_a_r\[19\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_4
X_13934_ _06196_ _06204_ _06205_ VGND VGND VPWR VPWR _06206_ sky130_fd_sc_hd__o21ai_1
XFILLER_19_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13865_ _06108_ _06133_ _06066_ _06139_ VGND VGND VPWR VPWR _06140_ sky130_fd_sc_hd__o211a_1
XFILLER_74_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15604_ net275 VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__inv_2
XFILLER_62_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12816_ _04953_ _05114_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__and2_1
X_13796_ adder_inst.sum_raw_r\[5\] adder_inst.sum_raw_r\[4\] adder_inst.sum_raw_r\[7\]
+ adder_inst.sum_raw_r\[6\] VGND VGND VPWR VPWR _06071_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_17_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15535_ net394 mul_res\[28\] net260 VGND VGND VPWR VPWR _07729_ sky130_fd_sc_hd__mux2_1
X_12747_ _04978_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__inv_2
X_15466_ _07683_ _07620_ VGND VGND VPWR VPWR _07687_ sky130_fd_sc_hd__nand2_1
X_12678_ _04965_ _04974_ _04967_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__nand3_1
X_14417_ _06655_ _06653_ VGND VGND VPWR VPWR _06657_ sky130_fd_sc_hd__nand2_1
XFILLER_8_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11629_ _03925_ _03927_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__and2_1
X_15397_ _07618_ _07620_ VGND VGND VPWR VPWR _07624_ sky130_fd_sc_hd__nand2_1
X_14348_ _06587_ net196 _06554_ VGND VGND VPWR VPWR _06588_ sky130_fd_sc_hd__mux2_1
XFILLER_6_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14279_ _06519_ VGND VGND VPWR VPWR _06520_ sky130_fd_sc_hd__inv_2
X_16018_ clknet_leaf_16_clk _00058_ _00266_ VGND VGND VPWR VPWR add_res\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_97_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08840_ net214 net160 VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08771_ net126 adder_inst.man_a_r\[1\] VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__nand2_1
XFILLER_38_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09323_ _01621_ _01154_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__nand2_1
XFILLER_41_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09254_ _01552_ _01224_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__nand2_1
XFILLER_21_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08205_ _00501_ _07826_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__nand2_1
X_09185_ _01480_ _01482_ _01483_ VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__nand3_1
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08136_ _00427_ _00434_ VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__nand2_1
XFILLER_108_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08067_ _07837_ VGND VGND VPWR VPWR _07838_ sky130_fd_sc_hd__inv_2
XFILLER_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08969_ _01266_ _01267_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__nand2_1
X_11980_ _04081_ _04078_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__nand2_1
XFILLER_29_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10931_ _03229_ _03092_ _03100_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__nand3_1
XFILLER_29_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13650_ _05940_ _05943_ VGND VGND VPWR VPWR _05944_ sky130_fd_sc_hd__nand2_1
XFILLER_71_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10862_ _03160_ _02810_ _01304_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__o21ai_1
X_13581_ _05877_ VGND VGND VPWR VPWR _05878_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_65_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12601_ _04891_ _04899_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__nand2_1
X_10793_ _03030_ _03091_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__nand2_1
XFILLER_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15320_ _07543_ _02429_ VGND VGND VPWR VPWR _07545_ sky130_fd_sc_hd__nand2_1
X_12532_ _04830_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_14_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15251_ _07492_ multiplier_inst.man_final_r\[3\] _07494_ VGND VGND VPWR VPWR _07499_
+ sky130_fd_sc_hd__and3_1
X_12463_ net107 net205 VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__nand2_1
X_14202_ _07128_ _06442_ VGND VGND VPWR VPWR _06443_ sky130_fd_sc_hd__xnor2_1
X_11414_ _03705_ _03712_ VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_117_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15182_ _07435_ VGND VGND VPWR VPWR _07436_ sky130_fd_sc_hd__inv_2
X_12394_ _04692_ _04604_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__nand2_1
X_14133_ net252 _06195_ _06188_ _06385_ _06183_ VGND VGND VPWR VPWR _06386_ sky130_fd_sc_hd__o2111a_1
X_11345_ _03643_ _03622_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__nand2_1
XFILLER_113_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14064_ _06042_ _06323_ VGND VGND VPWR VPWR _06324_ sky130_fd_sc_hd__nor2_1
X_11276_ _03506_ _03510_ _03507_ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__nand3_1
XFILLER_3_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10227_ _02521_ _02523_ _02525_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__a21oi_1
X_13015_ _05297_ _05313_ _05299_ VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__nand3_1
Xhold3 adder_inst.i_a\[31\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_94_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10158_ _01871_ _02456_ VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__nand2_1
X_10089_ _02382_ _02077_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__nand2_1
X_14966_ _06725_ _06699_ VGND VGND VPWR VPWR _07208_ sky130_fd_sc_hd__nand2_1
XFILLER_81_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13917_ _06191_ VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__clkbuf_1
X_14897_ _07000_ _07002_ _06801_ VGND VGND VPWR VPWR _07135_ sky130_fd_sc_hd__a21bo_1
XFILLER_62_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13848_ _06121_ _06122_ VGND VGND VPWR VPWR _06123_ sky130_fd_sc_hd__nand2_1
XFILLER_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13779_ adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR _06054_ sky130_fd_sc_hd__inv_2
XFILLER_22_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15518_ net418 VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__clkbuf_1
X_15449_ _05846_ _05813_ VGND VGND VPWR VPWR _07671_ sky130_fd_sc_hd__nand2_1
XFILLER_30_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09941_ _02238_ _02239_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__nand2_1
X_09872_ _02169_ _02170_ VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__nand2_1
XFILLER_97_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08823_ _01013_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__inv_2
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08754_ _01051_ _01052_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__nand2_1
XFILLER_38_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08685_ _00971_ _00974_ VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__nand2_1
XFILLER_38_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09306_ _01602_ _01604_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__nand2_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09237_ _01532_ _01535_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__nand2_1
X_09168_ _01465_ _01458_ VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__nand2_1
XFILLER_5_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08119_ _07872_ _07889_ VGND VGND VPWR VPWR _07890_ sky130_fd_sc_hd__nand2_1
X_09099_ _01395_ _01397_ VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__nand2_1
XFILLER_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11130_ _03418_ _03410_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_112_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11061_ _03292_ _03291_ _03288_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__a21boi_1
XFILLER_103_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10012_ _02310_ _02100_ _02090_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__nand3_1
XFILLER_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14820_ _06880_ _06907_ _06878_ VGND VGND VPWR VPWR _07056_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_67_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14751_ _06970_ _06990_ VGND VGND VPWR VPWR _06991_ sky130_fd_sc_hd__nand2_1
XFILLER_72_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11963_ _03770_ net177 net149 VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__and3_1
X_13702_ _05992_ VGND VGND VPWR VPWR adder_inst.man_b\[23\] sky130_fd_sc_hd__buf_1
X_14682_ _06920_ _06921_ VGND VGND VPWR VPWR _06922_ sky130_fd_sc_hd__nand2_1
XFILLER_44_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10914_ _03202_ _03203_ _03207_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__nand3_1
X_11894_ _03930_ _03925_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__nand2_1
X_13633_ _05924_ VGND VGND VPWR VPWR _05928_ sky130_fd_sc_hd__inv_2
X_10845_ _03142_ _03143_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_27_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15303_ net104 _07525_ net383 _00104_ VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__a31o_1
X_13564_ _05859_ _05860_ VGND VGND VPWR VPWR _05861_ sky130_fd_sc_hd__nand2_1
XFILLER_81_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10776_ net201 net146 VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__nand2_1
X_13495_ _05788_ _05793_ VGND VGND VPWR VPWR _05794_ sky130_fd_sc_hd__nand2_1
X_12515_ _04812_ _04802_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__nand2b_1
XFILLER_8_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15234_ _07486_ VGND VGND VPWR VPWR adder_inst.exp_larger\[4\] sky130_fd_sc_hd__clkbuf_1
X_12446_ _04593_ _04577_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__nand2_1
X_15165_ _07414_ _06639_ _06650_ VGND VGND VPWR VPWR _07418_ sky130_fd_sc_hd__nand3_1
X_12377_ _04675_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__inv_2
X_14116_ _06183_ _06190_ _06370_ VGND VGND VPWR VPWR _06371_ sky130_fd_sc_hd__and3_1
XFILLER_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11328_ _03625_ _03623_ VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__or2b_1
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15096_ _07008_ _07011_ VGND VGND VPWR VPWR _07345_ sky130_fd_sc_hd__nand2_1
X_14047_ _06308_ VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__clkbuf_1
X_11259_ _03552_ _03435_ _03555_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__nand3_1
XFILLER_79_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15998_ clknet_leaf_1_clk net346 _00246_ VGND VGND VPWR VPWR adder_inst.man_b_r\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_54_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14949_ _06726_ _07188_ VGND VGND VPWR VPWR _07189_ sky130_fd_sc_hd__nand2_1
XFILLER_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08470_ _00754_ _00765_ _00768_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__a21boi_1
XFILLER_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09022_ net188 net161 VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__nand2_1
XFILLER_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09924_ adder_inst.man_b_r\[10\] net245 VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__nand2_1
XFILLER_98_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09855_ _02153_ _02150_ _01815_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__nand3_1
XFILLER_58_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08806_ _01090_ _00843_ _00899_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__nand3_1
X_09786_ _02084_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__inv_2
XFILLER_58_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08737_ _01034_ _01035_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__nand2_1
XFILLER_26_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08668_ _00951_ _00962_ _00966_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__a21boi_1
XFILLER_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10630_ _02927_ _02928_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_62_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08599_ _00851_ _00852_ _00895_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_24_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10561_ _02858_ _02859_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__nand2_1
XFILLER_22_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10492_ _02630_ _02634_ _02635_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__nand3b_1
X_13280_ _05570_ _05568_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__nand2b_1
X_12300_ _04595_ _04597_ _04598_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__a21oi_1
X_12231_ _04492_ _04529_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__nand2_1
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12162_ _03634_ _04460_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__nand2_1
XFILLER_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11113_ _03411_ _03048_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__nand2_1
X_12093_ _04391_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__inv_2
X_15921_ clknet_leaf_6_clk net54 _00169_ VGND VGND VPWR VPWR adder_inst.exp_b\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_73_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11044_ net128 net212 VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__nand2_1
XFILLER_76_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15852_ net304 VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__inv_2
X_15783_ net301 VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14803_ _06908_ _07040_ VGND VGND VPWR VPWR _07041_ sky130_fd_sc_hd__xor2_1
XFILLER_17_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12995_ _05282_ _05285_ _05283_ VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__a21boi_1
X_14734_ _06778_ _06779_ _06516_ VGND VGND VPWR VPWR _06974_ sky130_fd_sc_hd__nand3_1
XFILLER_55_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11946_ net195 net131 VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__nand2_1
XFILLER_32_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14665_ _06802_ _02810_ VGND VGND VPWR VPWR _06905_ sky130_fd_sc_hd__nand2_1
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11877_ _04110_ _04175_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__nand2_1
XFILLER_32_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13616_ adder_inst.exp_b_r\[4\] _05899_ VGND VGND VPWR VPWR _05911_ sky130_fd_sc_hd__nor2_1
X_14596_ _06481_ _06503_ _06453_ VGND VGND VPWR VPWR _06836_ sky130_fd_sc_hd__mux2_1
X_10828_ net178 VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__clkinv_4
XFILLER_32_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13547_ _05835_ VGND VGND VPWR VPWR _05845_ sky130_fd_sc_hd__inv_2
X_10759_ _03056_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__inv_2
X_15217_ _07472_ _05998_ VGND VGND VPWR VPWR _07473_ sky130_fd_sc_hd__nand2_1
X_13478_ _05646_ _05647_ _05776_ VGND VGND VPWR VPWR _05777_ sky130_fd_sc_hd__nand3_1
X_12429_ _04721_ _04712_ _04727_ VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__nand3_2
XFILLER_114_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15148_ _07399_ _07173_ VGND VGND VPWR VPWR _07400_ sky130_fd_sc_hd__nand2_1
XFILLER_113_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15079_ _07320_ _07326_ VGND VGND VPWR VPWR _07327_ sky130_fd_sc_hd__xor2_1
X_07970_ _07738_ _07740_ VGND VGND VPWR VPWR _07741_ sky130_fd_sc_hd__nand2_1
XFILLER_95_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09640_ _01938_ _01932_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__nand2_1
X_09571_ _01868_ _01869_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__nand2_1
XFILLER_36_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08522_ _00820_ _00552_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__nand2_1
XFILLER_63_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08453_ _00747_ _00749_ _00751_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__a21oi_1
XFILLER_36_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_633 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08384_ _00672_ _00682_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_21_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09005_ net177 net170 VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__nand2_1
X_09907_ _02204_ _02205_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__nand2_1
XFILLER_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09838_ _02007_ _02017_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__nand2_1
XFILLER_58_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09769_ _02067_ _01979_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_29_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11800_ _04096_ _04098_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__nand2_1
XFILLER_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12780_ net107 net220 VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_107_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11731_ _04026_ _04029_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__nand2_1
X_14450_ net220 _06552_ _06689_ VGND VGND VPWR VPWR _06690_ sky130_fd_sc_hd__o21ai_1
X_11662_ _03958_ _03959_ _03960_ VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__a21o_1
XFILLER_14_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10613_ _02887_ _02911_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__or2_1
X_14381_ _06569_ _06619_ _06620_ VGND VGND VPWR VPWR _06621_ sky130_fd_sc_hd__o21ai_1
X_11593_ _03710_ _03889_ _03891_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__o21ai_1
X_13401_ _05293_ _04550_ VGND VGND VPWR VPWR _05700_ sky130_fd_sc_hd__or2b_1
X_10544_ _02765_ _02768_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__nand2_1
X_16120_ clknet_leaf_15_clk _00076_ _00368_ VGND VGND VPWR VPWR mul_res\[13\] sky130_fd_sc_hd__dfrtp_1
X_13332_ _05592_ _05630_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__nand2_1
XFILLER_10_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16051_ clknet_leaf_10_clk adder_inst.exp_larger\[3\] _00299_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[3\] sky130_fd_sc_hd__dfrtp_4
X_10475_ _02719_ _02715_ _02773_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__nand3_2
X_13263_ _05534_ _05561_ VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__nor2_1
X_15002_ _07244_ _06790_ VGND VGND VPWR VPWR _07246_ sky130_fd_sc_hd__nand2_1
X_13194_ _05491_ _05480_ _05481_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__nand3b_1
XFILLER_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12214_ _04509_ _03695_ _04512_ VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__nand3_1
XFILLER_69_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12145_ _04440_ _04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12076_ _04369_ _03598_ VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__nand2_1
X_15904_ clknet_leaf_0_clk net36 _00152_ VGND VGND VPWR VPWR adder_inst.i_b\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_49_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11027_ _03325_ VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__inv_2
X_15835_ net297 VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__inv_2
XFILLER_64_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15766_ net280 VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__inv_2
XFILLER_64_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12978_ _05275_ _05274_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__nand2_1
XFILLER_17_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15697_ net290 VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__inv_2
X_14717_ _06955_ _06550_ _06956_ VGND VGND VPWR VPWR _06957_ sky130_fd_sc_hd__nand3_1
X_11929_ _04224_ _04227_ VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__nand2_1
XFILLER_82_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14648_ _06884_ _06474_ _06887_ VGND VGND VPWR VPWR _06888_ sky130_fd_sc_hd__nand3_1
X_14579_ _06801_ _06818_ _06817_ VGND VGND VPWR VPWR _06819_ sky130_fd_sc_hd__o21a_1
XFILLER_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07953_ _07663_ VGND VGND VPWR VPWR _07672_ sky130_fd_sc_hd__inv_2
XFILLER_101_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09623_ _01907_ _01919_ _01921_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__a21boi_1
XFILLER_55_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09554_ _01689_ _01852_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_54_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09485_ _01625_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__inv_2
XFILLER_63_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08505_ net143 net224 VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__nand2_1
XFILLER_24_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08436_ _00731_ _00734_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__nand2_1
XFILLER_23_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08367_ _00603_ _00612_ VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__nand2_1
XFILLER_11_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08298_ _00587_ _00591_ VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__nand2_1
X_10260_ _02489_ _02476_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__nand2_1
XFILLER_11_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10191_ _02486_ _02489_ _02476_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__nand3b_1
XFILLER_78_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13950_ _06220_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_109_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12901_ _05079_ _05084_ _05199_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__o21a_1
X_13881_ adder_inst.exp_larger_r\[3\] _06132_ _06117_ VGND VGND VPWR VPWR _06156_
+ sky130_fd_sc_hd__a21oi_1
X_15620_ net289 VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__inv_2
XFILLER_15_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12832_ _05119_ _05128_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__nand2_1
XFILLER_34_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15551_ net269 VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__inv_2
X_12763_ _05057_ _05061_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__nor2_1
X_15482_ _07697_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__clkbuf_1
X_14502_ _06484_ _06580_ _06487_ _06583_ VGND VGND VPWR VPWR _06742_ sky130_fd_sc_hd__o211ai_1
XFILLER_42_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11714_ _04012_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__inv_2
X_14433_ _06651_ _06672_ VGND VGND VPWR VPWR _06673_ sky130_fd_sc_hd__nand2_1
XFILLER_42_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12694_ net128 net195 VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__nand2_1
X_11645_ _03940_ _03943_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__nand2_1
Xinput26 i_a[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput37 i_b[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
X_14364_ _06603_ _04882_ _06558_ VGND VGND VPWR VPWR _06604_ sky130_fd_sc_hd__mux2_1
Xinput15 i_a[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
X_11576_ _03871_ _03874_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__nand2_1
Xinput48 i_b[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput59 i_b[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
X_16103_ clknet_leaf_12_clk multiplier_inst.exp_final\[6\] _00351_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_10527_ _02803_ _02825_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__nand2_1
X_13315_ _05595_ _05613_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__xnor2_1
X_14295_ net108 net178 _06440_ VGND VGND VPWR VPWR _06536_ sky130_fd_sc_hd__mux2_1
X_10458_ _02754_ _02753_ VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__nand2_1
X_16034_ clknet_leaf_15_clk _00045_ _00282_ VGND VGND VPWR VPWR add_res\[18\] sky130_fd_sc_hd__dfrtp_1
X_13246_ _04906_ _05543_ VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__nand2_1
XFILLER_108_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10389_ _02685_ _02665_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__or2_1
XFILLER_111_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13177_ _05475_ _05468_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__or2_1
X_12128_ _01509_ _01505_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__nand2_1
XFILLER_96_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12059_ _04351_ _04354_ _04357_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__nand3_2
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15818_ net301 VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_84_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15749_ net275 VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__inv_2
XFILLER_80_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09270_ net219 net159 VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__nand2_1
X_08221_ _00493_ _00513_ _00519_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_31_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08152_ _07845_ _07850_ _00450_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__nand3_1
XFILLER_119_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_08083_ _07853_ VGND VGND VPWR VPWR _07854_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_95_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08985_ _01280_ _01282_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__nand2_1
XFILLER_87_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07936_ _07498_ VGND VGND VPWR VPWR _07517_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_39_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09606_ _01904_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__inv_2
XFILLER_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09537_ _01674_ _01835_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09468_ _01762_ _01764_ _01766_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__nand3_2
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09399_ _01694_ _01697_ _01533_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__nand3_2
XFILLER_51_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08419_ _00717_ _00696_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__nand2_1
XFILLER_11_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11430_ _03728_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__inv_2
XFILLER_20_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11361_ _03659_ _03537_ _03542_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__nand3_1
X_10312_ _02608_ _02605_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__nand2_1
X_13100_ _04881_ _04582_ _05398_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__or3_1
X_14080_ _06277_ adder_inst.sum_raw_r\[10\] VGND VGND VPWR VPWR _06338_ sky130_fd_sc_hd__nand2_1
X_11292_ _03590_ _03585_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_115_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10243_ _02523_ _02541_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__xor2_1
XFILLER_79_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13031_ _05327_ _05329_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__or2_1
X_10174_ _02467_ _02469_ _02472_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__nand3_1
XFILLER_105_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14982_ _07194_ _07207_ VGND VGND VPWR VPWR _07225_ sky130_fd_sc_hd__nand2_1
Xfanout170 net173 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_4
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout192 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_4
X_13933_ _06155_ VGND VGND VPWR VPWR _06205_ sky130_fd_sc_hd__buf_2
XFILLER_93_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13864_ _06136_ _06054_ adder_inst.sum_raw_r\[18\] _06138_ VGND VGND VPWR VPWR _06139_
+ sky130_fd_sc_hd__a211o_1
XFILLER_47_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15603_ net274 VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__inv_2
X_12815_ _04951_ _04949_ VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__nand2_1
X_15534_ _07728_ VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__clkbuf_1
X_13795_ adder_inst.sum_raw_r\[9\] adder_inst.sum_raw_r\[10\] _06069_ VGND VGND VPWR
+ VPWR _06070_ sky130_fd_sc_hd__or3_1
XFILLER_63_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12746_ _05000_ _05002_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__nand2_1
X_15465_ _07685_ _07530_ VGND VGND VPWR VPWR _07686_ sky130_fd_sc_hd__nand2_1
X_12677_ _04968_ _04975_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__nand2_1
XFILLER_30_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14416_ _06653_ _06655_ VGND VGND VPWR VPWR _06656_ sky130_fd_sc_hd__or2_1
X_15396_ _07621_ _07622_ VGND VGND VPWR VPWR _07623_ sky130_fd_sc_hd__nand2_1
X_11628_ _00649_ _03746_ _03926_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__o21ai_1
XFILLER_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14347_ _06547_ _06586_ VGND VGND VPWR VPWR _06587_ sky130_fd_sc_hd__nor2_1
X_11559_ _03856_ _03857_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__nand2_1
XFILLER_7_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14278_ _06439_ _06518_ VGND VGND VPWR VPWR _06519_ sky130_fd_sc_hd__nand2_2
X_16017_ clknet_leaf_16_clk _00047_ _00265_ VGND VGND VPWR VPWR add_res\[1\] sky130_fd_sc_hd__dfrtp_1
X_13229_ _05524_ _05518_ VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__nand2_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08770_ net130 net243 VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__nand2_1
XFILLER_84_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09322_ net145 net233 VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__nand2_1
XFILLER_80_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09253_ _01551_ _01219_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__nand2_1
XFILLER_21_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08204_ _00502_ _07827_ VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__nand2_1
X_09184_ _00659_ _00616_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__nand2_1
X_08135_ _00428_ _00433_ VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__xnor2_1
XFILLER_119_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08066_ _07823_ _07822_ VGND VGND VPWR VPWR _07837_ sky130_fd_sc_hd__nor2_1
XFILLER_0_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08968_ _00991_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__inv_2
XFILLER_29_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08899_ _01170_ _01171_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__nand2_1
X_07919_ _07349_ VGND VGND VPWR VPWR _07360_ sky130_fd_sc_hd__inv_2
XFILLER_83_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10930_ _03226_ _03228_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__nand2_1
XFILLER_56_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12600_ _04898_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__inv_2
X_10861_ net182 VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__inv_2
XFILLER_17_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13580_ _07159_ _05876_ VGND VGND VPWR VPWR _05877_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_65_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10792_ _03090_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__inv_2
XFILLER_12_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12531_ _00650_ _04629_ _04829_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15250_ _07497_ VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__clkbuf_1
X_12462_ _04759_ _04760_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__nand2_1
XFILLER_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14201_ _07066_ adder_inst.exp_larger\[0\] VGND VGND VPWR VPWR _06442_ sky130_fd_sc_hd__or2_1
X_11413_ _03709_ _03711_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_117_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15181_ _06650_ _06642_ VGND VGND VPWR VPWR _07435_ sky130_fd_sc_hd__nand2_1
X_12393_ _04607_ _04606_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__nand2b_1
X_14132_ _06384_ _06194_ adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _06385_ sky130_fd_sc_hd__a21o_1
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11344_ _03622_ _03639_ _03642_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__nand3_1
XFILLER_98_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14063_ _06295_ _06084_ _06305_ _06044_ _06322_ VGND VGND VPWR VPWR _06323_ sky130_fd_sc_hd__o221a_1
X_11275_ _03573_ _03512_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__nand2_1
X_10226_ _02479_ _02524_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__nor2_1
XFILLER_3_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13014_ _05311_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__inv_2
Xhold4 add_vld VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_94_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10157_ _02455_ _01867_ VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__nand2_1
X_10088_ _02385_ _02386_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__nand2_1
X_14965_ _06741_ VGND VGND VPWR VPWR _07207_ sky130_fd_sc_hd__inv_2
X_13916_ _06183_ _06184_ _06185_ _06190_ VGND VGND VPWR VPWR _06191_ sky130_fd_sc_hd__and4_1
X_14896_ _07122_ _07134_ VGND VGND VPWR VPWR adder_inst.sum_raw\[8\] sky130_fd_sc_hd__nand2_1
XFILLER_74_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13847_ adder_inst.exp_larger_r\[4\] VGND VGND VPWR VPWR _06122_ sky130_fd_sc_hd__inv_2
XFILLER_23_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13778_ _06048_ VGND VGND VPWR VPWR _06053_ sky130_fd_sc_hd__inv_2
XFILLER_62_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15517_ add_res\[19\] net417 net259 VGND VGND VPWR VPWR _07718_ sky130_fd_sc_hd__mux2_1
X_12729_ _05027_ _05014_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__nand2_1
X_15448_ _05813_ _05846_ VGND VGND VPWR VPWR _07670_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_41_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15379_ _07606_ VGND VGND VPWR VPWR _07607_ sky130_fd_sc_hd__inv_4
XTAP_TAPCELL_ROW_92_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09940_ _02236_ _02234_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__nand2_1
XFILLER_89_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09871_ _01846_ VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__inv_2
XFILLER_112_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08822_ _01010_ _01011_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__nand2_1
X_08753_ net136 net235 VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_49_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08684_ _00973_ _00975_ _00982_ VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__nand3_1
XFILLER_80_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09305_ _01603_ _01578_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__nand2_1
X_09236_ _01296_ _01534_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09167_ _01458_ _01465_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__or2_1
XFILLER_119_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08118_ net207 net146 VGND VGND VPWR VPWR _07889_ sky130_fd_sc_hd__nand2_1
X_09098_ _01396_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__inv_2
XFILLER_79_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08049_ _07768_ _07769_ VGND VGND VPWR VPWR _07820_ sky130_fd_sc_hd__nand2_1
X_11060_ _03357_ _03354_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_112_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10011_ _02093_ _02094_ VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__or2b_1
XFILLER_49_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14750_ _06989_ VGND VGND VPWR VPWR _06990_ sky130_fd_sc_hd__inv_2
XFILLER_28_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13701_ adder_inst.exp_b\[3\] adder_inst.exp_b\[2\] _05990_ _05991_ VGND VGND VPWR
+ VPWR _05992_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_67_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11962_ _04259_ _04260_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__nand2_1
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14681_ _06660_ _02879_ VGND VGND VPWR VPWR _06921_ sky130_fd_sc_hd__nand2_1
XFILLER_72_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10913_ _03204_ _03209_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__nand2_1
X_11893_ _04189_ _04191_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__nand2_1
X_13632_ _05922_ _05926_ VGND VGND VPWR VPWR _05927_ sky130_fd_sc_hd__or2_1
X_10844_ _03140_ _03112_ _03113_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__nand3_1
X_13563_ _05851_ _05852_ _05858_ VGND VGND VPWR VPWR _05860_ sky130_fd_sc_hd__o21ai_1
XFILLER_71_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15302_ net105 _07525_ net378 _00104_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__a31o_1
X_12514_ _04802_ _04812_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__nand2b_1
XFILLER_40_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10775_ net206 net143 VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13494_ _05646_ _05647_ _05792_ VGND VGND VPWR VPWR _05793_ sky130_fd_sc_hd__nand3_1
X_15233_ adder_inst.exp_a_r\[4\] adder_inst.exp_b_r\[4\] _06563_ VGND VGND VPWR VPWR
+ _07486_ sky130_fd_sc_hd__mux2_1
X_12445_ _04741_ _04743_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__nand2_1
XFILLER_8_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15164_ _07415_ _07416_ VGND VGND VPWR VPWR _07417_ sky130_fd_sc_hd__nand2_1
X_12376_ net109 net208 net113 net206 VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__a22o_1
X_14115_ net250 adder_inst.sum_raw_r\[21\] net254 _06076_ _06369_ VGND VGND VPWR VPWR
+ _06370_ sky130_fd_sc_hd__a221o_1
X_11327_ _03623_ _03625_ VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__or2b_1
XFILLER_4_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15095_ _07342_ _07343_ _07178_ VGND VGND VPWR VPWR _07344_ sky130_fd_sc_hd__a21oi_1
XFILLER_4_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14046_ _06183_ _06190_ _06307_ VGND VGND VPWR VPWR _06308_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11258_ _03553_ _03556_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__nand2_1
X_10209_ _02507_ _02504_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__nand2_1
X_11189_ _03487_ _03172_ _03173_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__nand3_1
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15997_ clknet_leaf_1_clk net343 _00245_ VGND VGND VPWR VPWR adder_inst.man_b_r\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_19_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14948_ _07155_ _06816_ VGND VGND VPWR VPWR _07188_ sky130_fd_sc_hd__nand2_1
XFILLER_47_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14879_ _07115_ _06968_ VGND VGND VPWR VPWR _07116_ sky130_fd_sc_hd__nand2_1
XFILLER_23_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09021_ _01319_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_28_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09923_ net148 VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__inv_2
X_09854_ _01841_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__inv_2
XFILLER_58_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08805_ _01091_ _01094_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_37_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09785_ adder_inst.man_a_r\[9\] net167 VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__nand2_1
XFILLER_54_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08736_ _00893_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__inv_2
X_08667_ _00963_ _00964_ _00965_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__nand3_2
XFILLER_26_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08598_ _00853_ _00896_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__nand2_1
XFILLER_26_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10560_ _02833_ _02832_ _02826_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__nand3b_1
X_10491_ _02636_ _02630_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__nand2_1
X_09219_ _01514_ _01517_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__nand2_1
XFILLER_107_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12230_ _04517_ _04528_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__nor2_1
XFILLER_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12161_ _04459_ VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__inv_2
XFILLER_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11112_ _03047_ _03052_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__nand2_1
X_12092_ _01477_ _01442_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__nand2_1
X_15920_ clknet_leaf_7_clk net53 _00168_ VGND VGND VPWR VPWR adder_inst.exp_b\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_77_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_55_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11043_ net125 net212 VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__nand2_1
X_15851_ net302 VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__inv_2
XFILLER_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14802_ _07038_ _07039_ VGND VGND VPWR VPWR _07040_ sky130_fd_sc_hd__nand2_1
XFILLER_49_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15782_ net300 VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__inv_2
XFILLER_91_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12994_ _05291_ _05292_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__nand2_1
X_14733_ _06971_ _06700_ _06972_ VGND VGND VPWR VPWR _06973_ sky130_fd_sc_hd__nand3_1
XFILLER_55_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11945_ _04240_ _04243_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__nand2_1
XFILLER_17_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14664_ _06895_ _06896_ _06554_ VGND VGND VPWR VPWR _06904_ sky130_fd_sc_hd__nand3_1
XFILLER_60_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13615_ adder_inst.exp_a_r\[4\] _05898_ VGND VGND VPWR VPWR _05910_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_64_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11876_ _04174_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__inv_2
XFILLER_32_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14595_ _06479_ _06539_ _06834_ VGND VGND VPWR VPWR _06835_ sky130_fd_sc_hd__o21ai_1
X_10827_ _03102_ net177 net161 VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__nand3b_1
XFILLER_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13546_ _05844_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[1\] sky130_fd_sc_hd__inv_2
XFILLER_9_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10758_ _03026_ _03056_ VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__nand2_1
XFILLER_71_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13477_ _05775_ VGND VGND VPWR VPWR _05776_ sky130_fd_sc_hd__inv_2
X_15216_ _06665_ _06667_ VGND VGND VPWR VPWR _07472_ sky130_fd_sc_hd__or2_1
X_10689_ _02978_ _02987_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__nand2_1
X_12428_ _04726_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__inv_2
XFILLER_114_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15147_ _07386_ _07398_ VGND VGND VPWR VPWR _07399_ sky130_fd_sc_hd__xor2_1
X_12359_ net115 net205 VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__nand2_1
XFILLER_114_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_73_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15078_ _07301_ _07293_ _07009_ VGND VGND VPWR VPWR _07326_ sky130_fd_sc_hd__a21bo_1
X_14029_ adder_inst.sum_raw_r\[9\] _06204_ adder_inst.sum_raw_r\[8\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06292_ sky130_fd_sc_hd__o221a_1
XFILLER_82_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09570_ _01694_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__inv_2
X_08521_ _00818_ _00819_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__nand2_1
XFILLER_51_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08452_ _00750_ _00471_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__nor2_1
XFILLER_51_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08383_ _00681_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_21_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09004_ _07745_ _07777_ _07746_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__a21boi_1
XFILLER_105_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09906_ net228 net165 VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__nand2_1
X_09837_ _02019_ _02135_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__nand2_1
XFILLER_74_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09768_ _01982_ _01985_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__nand2_1
XFILLER_73_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08719_ _00815_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__inv_2
X_09699_ _01994_ _01997_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11730_ _04027_ _04028_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_107_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11661_ _03780_ _03772_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__nand2_1
XFILLER_25_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10612_ _02886_ _02860_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__and2_1
X_14380_ _06569_ net189 VGND VGND VPWR VPWR _06620_ sky130_fd_sc_hd__nand2_1
XFILLER_10_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11592_ _03707_ _03890_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__nand2_1
X_13400_ _04550_ _05293_ VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__or2b_1
X_10543_ _02841_ _02837_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__nand2_1
X_13331_ _05623_ _05629_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__nor2_1
XFILLER_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16050_ clknet_leaf_10_clk adder_inst.exp_larger\[2\] _00298_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[2\] sky130_fd_sc_hd__dfrtp_4
X_10474_ _02772_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__inv_2
X_15001_ _06790_ _07244_ VGND VGND VPWR VPWR _07245_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_75_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13262_ _05559_ _05560_ VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__nand2_1
XFILLER_6_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13193_ _05482_ _05491_ VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__nand2_1
X_12213_ _04510_ _04511_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__nand2_1
X_12144_ _03608_ _04442_ _03655_ VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__nand3_1
XFILLER_111_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12075_ _04372_ _04373_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__nand2_1
XFILLER_92_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15903_ clknet_leaf_3_clk net35 _00151_ VGND VGND VPWR VPWR adder_inst.i_b\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11026_ _03323_ _02804_ _03324_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__nor3_1
X_15834_ net285 VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__inv_2
XFILLER_66_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15765_ net287 VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__inv_2
XFILLER_45_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12977_ _05245_ _05274_ _05275_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__nand3b_1
XFILLER_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15696_ net304 VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__inv_2
X_14716_ _06611_ _06472_ _06461_ _06520_ VGND VGND VPWR VPWR _06956_ sky130_fd_sc_hd__a31o_1
X_11928_ _04062_ _04226_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__nand2_1
XFILLER_32_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14647_ _06885_ _06886_ _06488_ VGND VGND VPWR VPWR _06887_ sky130_fd_sc_hd__nand3_1
X_11859_ _04149_ _04157_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__nand2_1
X_14578_ _06816_ _06817_ VGND VGND VPWR VPWR _06818_ sky130_fd_sc_hd__nand2_2
XFILLER_32_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13529_ _05827_ _05681_ VGND VGND VPWR VPWR _05828_ sky130_fd_sc_hd__nand2_1
XFILLER_13_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_81_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07952_ net194 net169 VGND VGND VPWR VPWR _07663_ sky130_fd_sc_hd__nand2_1
XFILLER_68_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09622_ _01920_ _01718_ _01909_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__nand3_2
XFILLER_83_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09553_ _01659_ _01660_ _01676_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__nand3_1
XFILLER_55_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08504_ _00800_ _00802_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__nand2_1
XFILLER_102_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09484_ _01782_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__inv_2
XFILLER_62_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08435_ _00732_ _00733_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__nand2_1
XFILLER_23_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08366_ _00664_ _00567_ VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__nand2_1
X_08297_ _00594_ _00595_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__nand2_1
XFILLER_109_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10190_ _02487_ _02488_ VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__nand2_1
XFILLER_105_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13880_ _06064_ VGND VGND VPWR VPWR _06155_ sky130_fd_sc_hd__clkbuf_4
X_12900_ _05082_ VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__inv_2
XFILLER_74_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12831_ _05119_ _05129_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__nand2b_1
XFILLER_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15550_ net273 VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__inv_2
XFILLER_14_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12762_ _05059_ _05060_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__nand2_1
XFILLER_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15481_ add_res\[1\] mul_res\[1\] net258 VGND VGND VPWR VPWR _07697_ sky130_fd_sc_hd__mux2_1
X_14501_ _06738_ _06740_ VGND VGND VPWR VPWR _06741_ sky130_fd_sc_hd__nand2_2
X_11713_ _04010_ _04008_ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__nor2_1
XFILLER_14_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12693_ _04991_ VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_81_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14432_ _06659_ _06671_ VGND VGND VPWR VPWR _06672_ sky130_fd_sc_hd__nor2_1
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11644_ _03941_ _03942_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__nand2_1
XFILLER_52_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput16 i_a[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput27 i_a[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
X_16102_ clknet_leaf_13_clk multiplier_inst.exp_final\[5\] _00350_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_14363_ _06602_ VGND VGND VPWR VPWR _06603_ sky130_fd_sc_hd__inv_2
X_11575_ _03873_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__inv_2
XFILLER_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput49 i_b[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_116_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10526_ _02813_ _02823_ _02824_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__a21oi_1
Xinput38 i_b[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
X_13314_ _05611_ _05612_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__or2b_1
X_14294_ net111 net180 _06440_ VGND VGND VPWR VPWR _06535_ sky130_fd_sc_hd__mux2_1
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10457_ _02755_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__inv_2
XFILLER_108_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16033_ clknet_leaf_15_clk _00044_ _00281_ VGND VGND VPWR VPWR add_res\[17\] sky130_fd_sc_hd__dfrtp_1
X_13245_ _05543_ _04906_ VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__or2_1
XFILLER_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10388_ _02686_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__inv_2
XFILLER_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13176_ _05466_ _05454_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__nand2_1
X_12127_ _04421_ _04425_ VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__nand2_1
XFILLER_96_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12058_ _04355_ _04356_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__nand2_1
XFILLER_77_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11009_ _03306_ _03307_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__nand2_1
XFILLER_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15817_ net301 VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__inv_2
XFILLER_92_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15748_ net290 VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__inv_2
XFILLER_80_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15679_ net279 VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__inv_2
XFILLER_21_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08220_ _00516_ _00518_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08151_ _00448_ _00449_ VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__nand2_1
XFILLER_119_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08082_ net138 net224 VGND VGND VPWR VPWR _07853_ sky130_fd_sc_hd__nand2_1
XFILLER_106_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08984_ _01276_ _01280_ _01282_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__nand3_1
XFILLER_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07935_ _07444_ _07455_ VGND VGND VPWR VPWR _07511_ sky130_fd_sc_hd__nor2_1
XFILLER_29_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09605_ _01903_ _01727_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__nand2_1
XFILLER_83_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09536_ _01673_ _01666_ VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_104_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09467_ _01605_ _01580_ _01765_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__nand3_1
XFILLER_24_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08418_ _00696_ _00715_ _00716_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__nand3_1
X_09398_ _01695_ _01696_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__nand2_1
XFILLER_7_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08349_ net110 VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__inv_4
XFILLER_20_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11360_ _03552_ _03658_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__nand2_1
XFILLER_118_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10311_ _02609_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__inv_2
XFILLER_22_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11291_ _03588_ _03427_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__nand2_1
X_13030_ _05328_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__inv_2
X_10242_ _02479_ _02524_ _02521_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10173_ _02470_ _02471_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__nand2_1
XFILLER_105_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout160 adder_inst.man_b_r\[5\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_4
Xfanout171 net173 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14981_ _07206_ _06019_ _07224_ VGND VGND VPWR VPWR adder_inst.sum_raw\[12\] sky130_fd_sc_hd__a21o_1
XFILLER_47_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout182 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_4
X_13932_ _06052_ VGND VGND VPWR VPWR _06204_ sky130_fd_sc_hd__buf_2
Xfanout193 net194 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13863_ _06054_ _06130_ VGND VGND VPWR VPWR _06138_ sky130_fd_sc_hd__nor2_1
XFILLER_74_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15602_ net275 VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__inv_2
X_13794_ adder_inst.sum_raw_r\[13\] adder_inst.sum_raw_r\[12\] adder_inst.sum_raw_r\[15\]
+ adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR _06069_ sky130_fd_sc_hd__or4_1
X_12814_ _05064_ _05065_ _05110_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__nand3_1
X_15533_ net404 mul_res\[27\] net261 VGND VGND VPWR VPWR _07728_ sky130_fd_sc_hd__mux2_1
XFILLER_63_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12745_ _05043_ _05011_ VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__nand2_1
XFILLER_70_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15464_ _07680_ _05833_ _05847_ VGND VGND VPWR VPWR _07685_ sky130_fd_sc_hd__a21oi_1
X_12676_ _04974_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__inv_2
X_14415_ _06654_ _06474_ _06521_ net178 _06637_ VGND VGND VPWR VPWR _06655_ sky130_fd_sc_hd__a32o_1
X_15395_ _07616_ _05698_ VGND VGND VPWR VPWR _07622_ sky130_fd_sc_hd__nand2_1
XFILLER_8_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11627_ net112 net224 VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__nand2_1
XFILLER_30_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14346_ _06585_ _06474_ VGND VGND VPWR VPWR _06586_ sky130_fd_sc_hd__nand2_1
X_11558_ _03851_ _03854_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__nand2_1
XFILLER_7_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10509_ _02729_ net174 net240 VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__and3_1
XFILLER_10_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14277_ _06436_ VGND VGND VPWR VPWR _06518_ sky130_fd_sc_hd__inv_2
X_16016_ clknet_leaf_18_clk _00036_ _00264_ VGND VGND VPWR VPWR add_res\[0\] sky130_fd_sc_hd__dfrtp_1
X_11489_ _03782_ _03785_ _03783_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__nand3_1
X_13228_ _05525_ _05507_ _05473_ VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__nand3b_1
X_13159_ net111 net183 VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__nand2_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09321_ _01175_ _01619_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__xor2_1
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09252_ _01223_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__inv_2
XFILLER_119_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08203_ _00501_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__inv_2
X_09183_ _01481_ _01476_ _01477_ VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__nand3_1
X_08134_ _00431_ _00432_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__nand2_1
X_08065_ _07824_ _07825_ _07835_ VGND VGND VPWR VPWR _07836_ sky130_fd_sc_hd__nand3_1
XFILLER_115_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08967_ _00993_ _00994_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__nand2_1
XFILLER_84_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08898_ _01196_ _01171_ VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__nand2_1
XFILLER_56_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07918_ net191 net169 VGND VGND VPWR VPWR _07349_ sky130_fd_sc_hd__nand2_1
XFILLER_90_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10860_ _01309_ _01307_ _03158_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__a21oi_1
X_09519_ _01816_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10791_ net186 net152 VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__nand2_1
X_12530_ net113 net196 VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12461_ _04758_ _04750_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__nand2b_1
X_14200_ _06441_ VGND VGND VPWR VPWR adder_inst.exp_larger\[0\] sky130_fd_sc_hd__clkbuf_1
X_15180_ _07428_ _07433_ VGND VGND VPWR VPWR adder_inst.sum_raw\[21\] sky130_fd_sc_hd__nand2_1
XFILLER_8_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11412_ _03342_ _03710_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_117_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14131_ adder_inst.sum_raw_r\[21\] _06081_ _06383_ _06155_ VGND VGND VPWR VPWR _06384_
+ sky130_fd_sc_hd__a22o_1
X_12392_ _04685_ _04686_ _04690_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__o21a_1
X_11343_ _03640_ _03641_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__nand2_1
XFILLER_98_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14062_ _06319_ _06320_ _06321_ VGND VGND VPWR VPWR _06322_ sky130_fd_sc_hd__o21ai_1
X_11274_ _03499_ _03504_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__nand2_1
X_10225_ net165 net236 VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__nand2_1
XFILLER_106_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13013_ _05300_ _05311_ VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__nand2_1
XFILLER_3_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10156_ _01870_ _01698_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__nand2_1
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold5 adder_inst.i_b\[31\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
X_10087_ _02374_ _02355_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__nand2_1
X_14964_ _07197_ _07205_ VGND VGND VPWR VPWR _07206_ sky130_fd_sc_hd__nand2_1
XFILLER_59_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13915_ _06189_ VGND VGND VPWR VPWR _06190_ sky130_fd_sc_hd__clkbuf_2
XFILLER_75_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14895_ _07132_ _07133_ _06019_ VGND VGND VPWR VPWR _07134_ sky130_fd_sc_hd__a21o_1
XFILLER_74_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13846_ _06065_ _06116_ _06117_ _06120_ VGND VGND VPWR VPWR _06121_ sky130_fd_sc_hd__o211a_1
XFILLER_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13777_ _06051_ VGND VGND VPWR VPWR _06052_ sky130_fd_sc_hd__clkbuf_4
XFILLER_62_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10989_ _03279_ _03285_ _03287_ VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__nand3_1
X_15516_ net414 VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12728_ _05016_ _05026_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__nand2_1
X_15447_ _07530_ _07666_ _07669_ VGND VGND VPWR VPWR multiplier_inst.man_final\[14\]
+ sky130_fd_sc_hd__o21ai_1
X_12659_ _04664_ _04957_ VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__nand2_1
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15378_ _07600_ _05735_ _05739_ VGND VGND VPWR VPWR _07606_ sky130_fd_sc_hd__a21bo_1
Xmax_cap102 _05886_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_92_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14329_ _06568_ VGND VGND VPWR VPWR _06569_ sky130_fd_sc_hd__clkbuf_4
XFILLER_7_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09870_ _01851_ _01854_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nand2_1
X_08821_ _01119_ _01078_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__nand2_1
XFILLER_112_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08752_ net139 net232 VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__nand2_1
XFILLER_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08683_ _00981_ _00979_ VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__nand2_1
XFILLER_66_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09304_ _01578_ _01563_ _01574_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__nand3_1
X_09235_ _01533_ _01286_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__nand2_1
X_09166_ _01462_ _01464_ VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__nand2_1
XFILLER_119_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08117_ net207 net143 VGND VGND VPWR VPWR _07888_ sky130_fd_sc_hd__nand2_1
X_09097_ _07762_ _07771_ _07764_ VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__a21boi_2
X_08048_ _07817_ _07818_ VGND VGND VPWR VPWR _07819_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_112_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10010_ _02308_ _02095_ VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09999_ _02201_ _02202_ _02206_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__o21ai_1
XFILLER_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11961_ _04254_ _04255_ _04257_ VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__nand3_1
X_13700_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _05991_ sky130_fd_sc_hd__or4_1
XFILLER_84_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10912_ _03180_ _03208_ _03210_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__nand3b_1
X_14680_ _06914_ _06919_ _06568_ VGND VGND VPWR VPWR _06920_ sky130_fd_sc_hd__nand3_1
XFILLER_56_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11892_ _03948_ _03940_ _04190_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__nand3_1
X_13631_ _05924_ _05925_ VGND VGND VPWR VPWR _05926_ sky130_fd_sc_hd__nor2_1
XFILLER_71_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10843_ _03114_ _03141_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__nand2_1
XFILLER_32_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13562_ _05851_ _05852_ _05858_ VGND VGND VPWR VPWR _05859_ sky130_fd_sc_hd__or3_1
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10774_ _03072_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_27_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15301_ net105 _07525_ net377 _00104_ VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__a31o_1
X_12513_ _04810_ _04811_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__nand2_1
XFILLER_60_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13493_ _05790_ _05791_ VGND VGND VPWR VPWR _05792_ sky130_fd_sc_hd__nand2_1
XFILLER_12_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15232_ _07485_ VGND VGND VPWR VPWR adder_inst.exp_larger\[3\] sky130_fd_sc_hd__clkbuf_1
X_12444_ _04738_ _04742_ _04739_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_78_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15163_ _06650_ VGND VGND VPWR VPWR _07416_ sky130_fd_sc_hd__inv_2
X_12375_ _04673_ net109 net206 VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__and3_1
X_14114_ _06042_ _06368_ VGND VGND VPWR VPWR _06369_ sky130_fd_sc_hd__nor2_1
X_15094_ _07339_ _06610_ VGND VGND VPWR VPWR _07343_ sky130_fd_sc_hd__nand2_1
X_11326_ _03461_ _03624_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__nand2_1
X_14045_ _06184_ _06304_ _06306_ VGND VGND VPWR VPWR _06307_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11257_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__inv_2
X_10208_ _02502_ _02504_ _02506_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__nand3b_1
X_11188_ _03152_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__inv_2
X_10139_ _02436_ _02437_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__nand2_1
XFILLER_67_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15996_ clknet_leaf_1_clk net352 _00244_ VGND VGND VPWR VPWR adder_inst.man_b_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_89_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14947_ _07005_ VGND VGND VPWR VPWR _07187_ sky130_fd_sc_hd__inv_2
XFILLER_63_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14878_ _07102_ _06963_ VGND VGND VPWR VPWR _07115_ sky130_fd_sc_hd__nand2_1
XFILLER_63_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13829_ adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _06104_ sky130_fd_sc_hd__inv_2
XFILLER_90_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09020_ net194 net158 VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__nand2_1
XFILLER_31_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09922_ net139 net247 VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__nand2_1
X_09853_ _02151_ _01841_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__nand2_1
X_09784_ _02082_ _01916_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__nand2_1
XFILLER_58_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08804_ _01100_ _01102_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__nand2_1
XFILLER_105_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08735_ _00879_ _00882_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__nand2_1
XFILLER_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08666_ _00941_ _00748_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__nand2_1
XFILLER_26_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08597_ _00895_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__inv_2
XFILLER_14_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_101_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10490_ _02788_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__inv_2
X_09218_ _01516_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__inv_2
X_09149_ net241 VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__inv_2
X_12160_ _04458_ net110 net240 VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__and3_1
XFILLER_107_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11111_ _03409_ _03082_ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__nand2_1
X_12091_ _04387_ _04389_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__nand2_1
XFILLER_89_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11042_ net122 net220 VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_110_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15850_ net302 VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__inv_2
X_14801_ _06856_ _06851_ VGND VGND VPWR VPWR _07039_ sky130_fd_sc_hd__nand2_1
XFILLER_64_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15781_ net281 VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__inv_2
XFILLER_29_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12993_ _05289_ _05235_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__nand2_1
XFILLER_91_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14732_ _06885_ _06886_ _06462_ VGND VGND VPWR VPWR _06972_ sky130_fd_sc_hd__nand3_1
XFILLER_44_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11944_ _04241_ _01670_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__o21ai_2
XFILLER_72_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14663_ _06901_ _06902_ VGND VGND VPWR VPWR _06903_ sky130_fd_sc_hd__nand2_1
XFILLER_45_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11875_ _04172_ _04173_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__nand2_1
XFILLER_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13614_ _05873_ _05859_ VGND VGND VPWR VPWR _05909_ sky130_fd_sc_hd__nand2_1
XFILLER_60_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10826_ _03122_ _03124_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__nand2_1
X_14594_ _06539_ _06476_ VGND VGND VPWR VPWR _06834_ sky130_fd_sc_hd__nand2_1
XFILLER_9_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13545_ _07169_ _05655_ _05843_ VGND VGND VPWR VPWR _05844_ sky130_fd_sc_hd__mux2_1
X_10757_ _03046_ _03054_ _03055_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__a21oi_2
XFILLER_13_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10688_ _02986_ _02460_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__nor2_1
XFILLER_40_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13476_ _05330_ _05774_ VGND VGND VPWR VPWR _05775_ sky130_fd_sc_hd__xnor2_1
X_15215_ _07440_ _06671_ VGND VGND VPWR VPWR _07471_ sky130_fd_sc_hd__nand2_1
XFILLER_65_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12427_ _04722_ _04725_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__nand2_1
X_15146_ _07394_ _07397_ VGND VGND VPWR VPWR _07398_ sky130_fd_sc_hd__nand2_1
X_12358_ _04655_ _04644_ _04645_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__nand3b_2
XFILLER_99_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15077_ _07323_ _07324_ _06019_ VGND VGND VPWR VPWR _07325_ sky130_fd_sc_hd__a21o_1
X_11309_ _03600_ _03607_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__nand2_2
X_12289_ _04585_ _04587_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__nand2_1
XFILLER_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14028_ _06277_ adder_inst.sum_raw_r\[5\] _06232_ adder_inst.sum_raw_r\[6\] _06290_
+ VGND VGND VPWR VPWR _06291_ sky130_fd_sc_hd__a221o_1
XFILLER_95_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15979_ clknet_leaf_7_clk net363 _00227_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_95_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08520_ _00550_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__inv_2
XFILLER_35_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08451_ net200 net176 VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__nand2_1
XFILLER_51_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08382_ _00673_ _00677_ _00680_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_21_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09003_ _01301_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__inv_2
XFILLER_3_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09905_ net162 net230 VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__nand2_1
XFILLER_113_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09836_ _02122_ _02128_ _02134_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__a21boi_1
X_09767_ _02065_ _02061_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__nand2_1
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09698_ _01995_ _01996_ _01992_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_57_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08718_ _00812_ _00813_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__nand2_1
X_08649_ _00947_ _00746_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_1_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11660_ _03957_ _03951_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__nand2_1
X_10611_ _02909_ _02896_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__nand2_1
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11591_ net128 net205 VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__nand2_1
XFILLER_25_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10542_ _02837_ _02840_ _02829_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__nand3_1
X_13330_ _05627_ _05628_ VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__nand2_1
XFILLER_50_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13261_ _05537_ _05529_ _05557_ VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__nand3_1
X_10473_ _02770_ _02771_ _02698_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__nand3_1
X_15000_ _07242_ _06822_ VGND VGND VPWR VPWR _07244_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12212_ _03694_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__inv_2
X_13192_ _05489_ _05490_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__nand2_1
X_12143_ _03676_ _04441_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__nand2_1
XFILLER_111_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12074_ _01406_ _01363_ _01366_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__a21boi_1
X_15902_ clknet_leaf_3_clk net34 _00150_ VGND VGND VPWR VPWR adder_inst.i_b\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_77_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11025_ net110 net234 VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__nand2_1
XFILLER_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15833_ net283 VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_86_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15764_ net280 VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__inv_2
XFILLER_18_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14715_ _06951_ _06954_ _06520_ VGND VGND VPWR VPWR _06955_ sky130_fd_sc_hd__nand3_1
X_12976_ _05273_ _05271_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__nand2b_1
X_15695_ net304 VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__inv_2
X_11927_ _04225_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__inv_2
XFILLER_17_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14646_ _06506_ _06466_ VGND VGND VPWR VPWR _06886_ sky130_fd_sc_hd__nand2_1
X_11858_ _04156_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__inv_2
X_14577_ _06815_ _06813_ VGND VGND VPWR VPWR _06817_ sky130_fd_sc_hd__nand2b_1
X_10809_ _03107_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__inv_2
X_11789_ _03962_ _04084_ _04085_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__nand3b_1
X_13528_ _05826_ VGND VGND VPWR VPWR _05827_ sky130_fd_sc_hd__inv_2
XFILLER_9_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13459_ _05757_ _04923_ VGND VGND VPWR VPWR _05758_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_97_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15129_ _07359_ _06610_ VGND VGND VPWR VPWR _07380_ sky130_fd_sc_hd__nand2_1
X_07951_ _07645_ _07370_ VGND VGND VPWR VPWR _07654_ sky130_fd_sc_hd__nand2_1
XFILLER_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09621_ _01918_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__inv_2
XFILLER_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09552_ _01850_ _01679_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__nand2_1
XFILLER_70_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08503_ _00801_ _00537_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__nand2_1
XFILLER_36_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09483_ net145 net236 VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_54_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08434_ _00509_ _00506_ _00511_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__nand3_1
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08365_ _00662_ _00659_ VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__nand2_1
X_08296_ _00593_ _00580_ _00583_ VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__nand3b_1
XFILLER_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_640 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09819_ _02115_ _02116_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__nand2_1
XFILLER_19_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12830_ _05128_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__inv_2
XFILLER_61_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12761_ _05058_ _04938_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__nand2_1
X_15480_ _07695_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__clkbuf_1
X_14500_ _06739_ _06733_ VGND VGND VPWR VPWR _06740_ sky130_fd_sc_hd__nand2_2
X_11712_ _04008_ _04010_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__nand2_1
X_12692_ net123 net202 VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__nand2_1
X_14431_ _06669_ _06670_ VGND VGND VPWR VPWR _06671_ sky130_fd_sc_hd__nand2_2
XFILLER_42_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11643_ _03830_ _03828_ _03825_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_81_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 i_a[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
X_16101_ clknet_leaf_13_clk multiplier_inst.exp_final\[4\] _00349_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
Xinput28 i_a[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
X_14362_ _06519_ _06601_ VGND VGND VPWR VPWR _06602_ sky130_fd_sc_hd__nor2_1
XFILLER_52_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11574_ _03566_ _03872_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__nand2_1
X_10525_ _02812_ _02809_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__nor2_1
Xinput39 i_b[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
X_14293_ _06533_ _06462_ VGND VGND VPWR VPWR _06534_ sky130_fd_sc_hd__nand2_1
X_13313_ _05610_ _05606_ VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__nand2_1
X_10456_ _02753_ _02754_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__nor2_1
X_16032_ clknet_leaf_15_clk _00043_ _00280_ VGND VGND VPWR VPWR add_res\[16\] sky130_fd_sc_hd__dfrtp_1
X_13244_ _04898_ _04891_ _04889_ VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__o21ai_1
XFILLER_6_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13175_ _05473_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__inv_2
XFILLER_6_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10387_ _02665_ _02685_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__nand2_1
X_12126_ _04424_ _04365_ VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__nand2_1
XFILLER_97_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12057_ _04206_ VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__inv_2
XFILLER_77_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11008_ _03305_ _03298_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__nand2_1
XFILLER_37_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15816_ net304 VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__inv_2
XFILLER_65_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15747_ net290 VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__inv_2
XFILLER_92_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12959_ _05257_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__inv_2
X_15678_ net272 VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__inv_2
X_14629_ _06867_ _06714_ _06868_ VGND VGND VPWR VPWR _06869_ sky130_fd_sc_hd__nand3_1
XFILLER_60_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08150_ _00439_ _00441_ _07886_ VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_31_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08081_ net132 net226 VGND VGND VPWR VPWR _07852_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_11_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08983_ _01278_ _01281_ _01031_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__nand3_1
X_07934_ _07444_ _07455_ _07476_ _07498_ VGND VGND VPWR VPWR _07504_ sky130_fd_sc_hd__o211ai_1
XFILLER_68_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09604_ net223 net162 VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__nand2_1
XFILLER_68_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09535_ _01833_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__inv_2
XFILLER_71_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_104_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09466_ _01599_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08417_ _00694_ _00667_ _00668_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__nand3_1
XFILLER_12_616 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09397_ _01197_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__inv_2
XFILLER_8_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08348_ _00646_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__inv_2
X_08279_ _00570_ _00577_ VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__or2_1
X_10310_ _02605_ _02608_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__nor2_1
XFILLER_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11290_ _03586_ _03427_ _03588_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__nand3_2
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10241_ _02538_ _02539_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__nand2_1
XFILLER_98_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10172_ net228 net171 VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__nand2_1
X_14980_ _07221_ _07222_ _06019_ VGND VGND VPWR VPWR _07224_ sky130_fd_sc_hd__a21oi_1
Xfanout172 net173 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_1
XFILLER_94_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13931_ _06203_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__clkbuf_1
Xfanout183 net185 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_2
Xfanout150 net151 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_4
Xfanout161 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout194 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_4
X_13862_ _06052_ _06136_ VGND VGND VPWR VPWR _06137_ sky130_fd_sc_hd__nor2_1
X_15601_ net274 VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__inv_2
X_13793_ adder_inst.sum_raw_r\[2\] _06065_ _06067_ _06041_ VGND VGND VPWR VPWR _06068_
+ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_83_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12813_ _05066_ _05111_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__nand2_1
X_15532_ net406 VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__clkbuf_1
X_12744_ _05042_ _05008_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__nand2_1
XFILLER_15_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15463_ _07530_ _07678_ _07684_ VGND VGND VPWR VPWR multiplier_inst.man_final\[17\]
+ sky130_fd_sc_hd__o21ai_1
X_12675_ _04969_ _04973_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__xor2_1
X_14414_ _06488_ _06612_ VGND VGND VPWR VPWR _06654_ sky130_fd_sc_hd__nor2_1
X_15394_ _05698_ _07616_ VGND VGND VPWR VPWR _07621_ sky130_fd_sc_hd__or2_1
X_11626_ _03924_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__inv_2
X_14345_ _06578_ _06584_ VGND VGND VPWR VPWR _06585_ sky130_fd_sc_hd__nand2_1
X_11557_ _03852_ _03855_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__nand2_1
X_10508_ _02804_ _02805_ _02806_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__o21ai_1
XFILLER_7_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16015_ clknet_leaf_11_clk adder_inst.is_nan_b _00263_ VGND VGND VPWR VPWR adder_inst.is_nan_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_14276_ _06514_ _06516_ VGND VGND VPWR VPWR _06517_ sky130_fd_sc_hd__nand2_1
XFILLER_7_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11488_ _03784_ _03786_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__nand2_1
X_10439_ _02737_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__inv_2
X_13227_ _05508_ _05525_ VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__nand2_1
X_13158_ net108 net190 VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__nand2_1
XFILLER_111_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13089_ net111 net190 net113 net187 VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__a22o_1
X_12109_ _04405_ _04407_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__nand2_1
XFILLER_111_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09320_ _01180_ _01177_ VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__nand2_1
X_09251_ _01549_ _01251_ VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08202_ net211 net153 VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__nand2_1
XFILLER_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09182_ _00449_ _00441_ VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__nand2_1
X_08133_ _07855_ _00429_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__nand2_1
X_08064_ _07834_ _07828_ VGND VGND VPWR VPWR _07835_ sky130_fd_sc_hd__nand2_1
XFILLER_108_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08966_ _01255_ _01263_ _01264_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__a21oi_1
XFILLER_68_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08897_ _01170_ _01171_ _01195_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__nand3_1
X_07917_ _07328_ _07180_ VGND VGND VPWR VPWR _07338_ sky130_fd_sc_hd__nand2_1
XFILLER_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09518_ _01662_ _01665_ _01674_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__nand3b_1
XFILLER_44_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10790_ _03085_ _03088_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__nand2_1
X_09449_ _01741_ _01747_ _01743_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__nand3_1
XFILLER_52_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12460_ _04750_ _04758_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__nand2b_1
X_11411_ net128 net208 VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__nand2_1
X_12391_ _04687_ _04689_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_117_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14130_ _06380_ _06381_ _06231_ adder_inst.sum_raw_r\[19\] _06382_ VGND VGND VPWR
+ VPWR _06383_ sky130_fd_sc_hd__a32o_1
XFILLER_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11342_ _01437_ _01435_ _03619_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__a21oi_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14061_ adder_inst.sum_raw_r\[12\] _06052_ adder_inst.sum_raw_r\[11\] _06252_ _06155_
+ VGND VGND VPWR VPWR _06321_ sky130_fd_sc_hd__o221a_1
XFILLER_4_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11273_ _01338_ _01359_ _03571_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__a21o_1
X_10224_ _02522_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__inv_2
XFILLER_79_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13012_ _05309_ _05310_ VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__nand2_1
XFILLER_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10155_ _02190_ _02453_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__nor2_1
XFILLER_94_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10086_ _02383_ _02384_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__nand2_1
X_14963_ _07203_ _07204_ _07021_ VGND VGND VPWR VPWR _07205_ sky130_fd_sc_hd__a21o_1
Xhold6 adder_inst.i_a\[13\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13914_ _06188_ _06018_ net103 VGND VGND VPWR VPWR _06189_ sky130_fd_sc_hd__and3_1
X_14894_ _07131_ _07112_ VGND VGND VPWR VPWR _07133_ sky130_fd_sc_hd__nand2_1
X_13845_ adder_inst.exp_larger_r\[3\] _06119_ _06083_ VGND VGND VPWR VPWR _06120_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13776_ net253 VGND VGND VPWR VPWR _06051_ sky130_fd_sc_hd__inv_2
XFILLER_15_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10988_ _03286_ _03280_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__nand2_1
X_15515_ add_res\[18\] net413 net260 VGND VGND VPWR VPWR _07717_ sky130_fd_sc_hd__mux2_1
XFILLER_43_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12727_ _05025_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__inv_2
XFILLER_90_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15446_ _07668_ _07530_ VGND VGND VPWR VPWR _07669_ sky130_fd_sc_hd__nand2_1
X_12658_ _04663_ _04658_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11609_ _03906_ _03907_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__nand2_1
XFILLER_30_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_15377_ _07605_ VGND VGND VPWR VPWR multiplier_inst.man_final\[1\] sky130_fd_sc_hd__clkbuf_1
X_12589_ _04886_ _04887_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__nand2_1
X_14328_ _06414_ VGND VGND VPWR VPWR _06568_ sky130_fd_sc_hd__clkbuf_4
X_14259_ _06482_ _06496_ _06499_ VGND VGND VPWR VPWR _06500_ sky130_fd_sc_hd__a21o_1
XFILLER_97_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08820_ _01118_ _01044_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__nand2_1
XFILLER_112_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08751_ net133 net238 VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__nand2_1
XFILLER_65_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08682_ _00976_ _00979_ _00980_ VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__nand3b_1
XFILLER_81_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09303_ _01600_ _01601_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__nand2_1
X_09234_ _01286_ _01283_ _01197_ VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09165_ _00620_ _01463_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__nand2_1
XFILLER_119_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08116_ net140 net214 VGND VGND VPWR VPWR _07887_ sky130_fd_sc_hd__nand2_1
XFILLER_119_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09096_ _01394_ VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__inv_2
X_08047_ _07799_ _07810_ _07797_ VGND VGND VPWR VPWR _07818_ sky130_fd_sc_hd__a21boi_1
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_112_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09998_ _02203_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__inv_2
XFILLER_76_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08949_ _01213_ _00962_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__nand2_1
XFILLER_57_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11960_ _04256_ _04258_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__nand2_1
XFILLER_91_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10911_ _03202_ _03203_ _03209_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__nand3_1
XFILLER_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11891_ _04188_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__inv_2
X_13630_ _05881_ _05880_ VGND VGND VPWR VPWR _05925_ sky130_fd_sc_hd__nand2_1
XFILLER_72_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10842_ _03140_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__inv_2
X_13561_ _05857_ VGND VGND VPWR VPWR _05858_ sky130_fd_sc_hd__inv_2
X_10773_ net207 net140 VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_27_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15300_ net105 _07525_ net380 _00104_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__a31o_1
X_12512_ _04809_ _04732_ _04735_ VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__nand3_1
XFILLER_8_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15231_ adder_inst.exp_a_r\[3\] adder_inst.exp_b_r\[3\] _06563_ VGND VGND VPWR VPWR
+ _07485_ sky130_fd_sc_hd__mux2_1
X_13492_ _05789_ _05384_ VGND VGND VPWR VPWR _05791_ sky130_fd_sc_hd__or2b_1
XFILLER_40_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12443_ _04565_ _04562_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__nand2_1
XFILLER_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15162_ _07414_ _06639_ VGND VGND VPWR VPWR _07415_ sky130_fd_sc_hd__nand2_1
XFILLER_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12374_ _04672_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__inv_2
X_14113_ _06112_ _06044_ _06108_ _06084_ _06367_ VGND VGND VPWR VPWR _06368_ sky130_fd_sc_hd__o221a_1
X_15093_ _07340_ _07341_ VGND VGND VPWR VPWR _07342_ sky130_fd_sc_hd__nand2_1
X_11325_ _03460_ _03458_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__nand2_1
X_14044_ _06194_ _06305_ _06295_ _06195_ VGND VGND VPWR VPWR _06306_ sky130_fd_sc_hd__o22a_1
X_11256_ _03554_ _03319_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__nand2_1
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10207_ _02505_ _01448_ _02212_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__o21ai_1
XFILLER_39_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11187_ _03482_ _03485_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__nand2_1
X_15995_ clknet_leaf_3_clk net345 _00243_ VGND VGND VPWR VPWR adder_inst.man_b_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
X_10138_ _02424_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__inv_2
XFILLER_79_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10069_ _02367_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__inv_2
X_14946_ _07181_ _07186_ VGND VGND VPWR VPWR adder_inst.sum_raw\[11\] sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_89_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14877_ _07058_ _06992_ VGND VGND VPWR VPWR _07114_ sky130_fd_sc_hd__nand2_1
XFILLER_63_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13828_ _06102_ VGND VGND VPWR VPWR _06103_ sky130_fd_sc_hd__inv_2
XFILLER_63_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13759_ _05960_ _05978_ VGND VGND VPWR VPWR _06037_ sky130_fd_sc_hd__and2_1
XFILLER_62_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15429_ _07648_ _05751_ VGND VGND VPWR VPWR _07653_ sky130_fd_sc_hd__nand2_1
XFILLER_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09921_ _02219_ _02209_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__nand2_1
X_09852_ _02150_ _01815_ VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__nand2_1
X_09783_ net219 net171 VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__nand2_1
X_08803_ _01097_ _01101_ _01037_ VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__nand3_1
X_08734_ _01032_ _01020_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__nand2_1
XFILLER_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08665_ _00940_ _00749_ _00747_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__nand3_1
XFILLER_81_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08596_ _00894_ _00882_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_62_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09217_ _00907_ _00917_ _01515_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__a21oi_1
X_09148_ _01446_ VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__inv_2
X_09079_ _01376_ _01373_ _01374_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__nand3b_1
XFILLER_107_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11110_ _03408_ _03068_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__nand2_1
X_12090_ _04388_ _04383_ _03643_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__nand3_1
XFILLER_103_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11041_ _03293_ _03288_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__nand2_1
XFILLER_39_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14800_ _07016_ _07037_ VGND VGND VPWR VPWR _07038_ sky130_fd_sc_hd__nand2_1
X_15780_ net280 VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__inv_2
XFILLER_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12992_ _05290_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__inv_2
X_14731_ _06466_ _06681_ _06488_ _06682_ VGND VGND VPWR VPWR _06971_ sky130_fd_sc_hd__o211ai_1
X_11943_ net189 net137 VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__nand2_1
X_14662_ _06554_ net241 VGND VGND VPWR VPWR _06902_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_43_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11874_ _04167_ _04168_ _04170_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__nand3_1
X_13613_ _05907_ VGND VGND VPWR VPWR _05908_ sky130_fd_sc_hd__inv_2
XFILLER_44_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10825_ _03120_ _03123_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__nand2_1
X_14593_ _06820_ _06832_ VGND VGND VPWR VPWR _06833_ sky130_fd_sc_hd__nor2_1
XFILLER_60_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13544_ _05837_ _05838_ _05842_ VGND VGND VPWR VPWR _05843_ sky130_fd_sc_hd__nand3_1
X_10756_ _03045_ _03038_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__nor2_1
XFILLER_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10687_ _02985_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__inv_2
X_13475_ _05700_ _05291_ VGND VGND VPWR VPWR _05774_ sky130_fd_sc_hd__nand2_1
X_15214_ _07466_ _07469_ _06000_ VGND VGND VPWR VPWR _07470_ sky130_fd_sc_hd__nand3_1
X_12426_ _04724_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__inv_2
X_15145_ _07395_ _06627_ _07396_ VGND VGND VPWR VPWR _07397_ sky130_fd_sc_hd__a21oi_1
X_12357_ _04646_ _04655_ VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__nand2_1
X_15076_ _07322_ _07320_ VGND VGND VPWR VPWR _07324_ sky130_fd_sc_hd__nand2_1
XFILLER_4_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11308_ _03602_ _03606_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__nand2_1
X_12288_ _04586_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__inv_2
XFILLER_113_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14027_ _06231_ _06289_ VGND VGND VPWR VPWR _06290_ sky130_fd_sc_hd__nand2_1
X_11239_ _03531_ _03534_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__nand2_1
XFILLER_67_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15978_ clknet_leaf_8_clk net360 _00226_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_82_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14929_ _07160_ _07168_ VGND VGND VPWR VPWR adder_inst.sum_raw\[10\] sky130_fd_sc_hd__nand2_1
XFILLER_82_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08450_ _00748_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__inv_2
XFILLER_35_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08381_ _00679_ _00546_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__nand2_1
XFILLER_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09002_ _01299_ _01300_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__nand2_1
XFILLER_104_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09904_ net159 net233 VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__nand2_1
XFILLER_104_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09835_ _02131_ _02133_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__nand2_1
XFILLER_86_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09766_ _02061_ _02063_ _02064_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_29_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09697_ _01969_ _01965_ _01795_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__nand3_1
XFILLER_54_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08717_ _00983_ _00975_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__nand2_1
X_08648_ net201 net176 VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08579_ _00691_ _00683_ _00692_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__nand3b_1
X_10610_ _02908_ _02893_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__nand2_1
X_11590_ net125 net205 VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__nand2_1
XFILLER_22_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10541_ _02838_ _02839_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__nand2_1
XFILLER_41_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13260_ _05538_ _05558_ VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__nand2_1
XFILLER_41_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10472_ _02691_ _02695_ _02694_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__a21o_1
XFILLER_41_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12211_ _03686_ _03691_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__nand2_1
X_13191_ net178 adder_inst.man_b_r\[20\] _05393_ _05488_ VGND VGND VPWR VPWR _05490_
+ sky130_fd_sc_hd__a31o_1
X_12142_ _03647_ _03648_ _03645_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_9_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12073_ _04371_ _03599_ VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__nand2_1
X_15901_ clknet_leaf_3_clk net64 _00149_ VGND VGND VPWR VPWR adder_inst.i_b\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_89_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11024_ net112 VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__inv_2
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15832_ net285 VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__inv_2
XFILLER_92_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15763_ net280 VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__inv_2
X_12975_ _05272_ _05273_ VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__nand2_1
X_14714_ _06952_ _06473_ _06953_ VGND VGND VPWR VPWR _06954_ sky130_fd_sc_hd__nand3_1
X_11926_ net181 net143 VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__nand2_2
XFILLER_17_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15694_ net293 VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__inv_2
XFILLER_82_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14645_ _06483_ _06447_ VGND VGND VPWR VPWR _06885_ sky130_fd_sc_hd__nand2_1
XFILLER_17_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11857_ _04151_ _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__xor2_1
X_14576_ _06813_ _06815_ VGND VGND VPWR VPWR _06816_ sky130_fd_sc_hd__nand2b_1
X_10808_ _03103_ _03105_ _03106_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__a21oi_2
X_11788_ _04086_ _03962_ VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__nand2_1
X_13527_ _05534_ _05825_ VGND VGND VPWR VPWR _05826_ sky130_fd_sc_hd__xnor2_1
X_10739_ _03035_ _03037_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__nand2_1
XFILLER_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13458_ _05756_ _05037_ VGND VGND VPWR VPWR _05757_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_97_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13389_ _05686_ _05687_ VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__nand2_1
X_12409_ _04684_ _04707_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__nand2_1
XFILLER_99_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15128_ _07378_ _07141_ VGND VGND VPWR VPWR _07379_ sky130_fd_sc_hd__nand2_1
X_15059_ _07305_ _07259_ VGND VGND VPWR VPWR _07306_ sky130_fd_sc_hd__nor2_1
X_07950_ net191 net170 VGND VGND VPWR VPWR _07645_ sky130_fd_sc_hd__nand2_1
XFILLER_68_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09620_ _01910_ _01918_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__nand2_1
XFILLER_68_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09551_ _01849_ _01651_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__nand2_1
XFILLER_83_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08502_ _00540_ _00799_ VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__nor2_1
X_09482_ _01778_ _01780_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__nand2_1
XFILLER_51_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08433_ _00498_ _00499_ _00510_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_34_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08364_ _00568_ _00659_ _00662_ VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__nand3_1
XFILLER_32_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08295_ _00584_ _00593_ VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__nand2_1
XFILLER_117_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09818_ _02113_ _02115_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__nand3_2
XFILLER_74_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09749_ _02029_ _01938_ _02047_ VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__nand3_1
XFILLER_15_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12760_ _04938_ _05058_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__or2_1
XFILLER_42_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11711_ _04009_ _03834_ _03796_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__o21ai_1
XFILLER_14_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12691_ _04982_ _04690_ _04988_ VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__a21o_1
XFILLER_36_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14430_ _06667_ _06666_ VGND VGND VPWR VPWR _06670_ sky130_fd_sc_hd__nand2_1
XFILLER_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11642_ _03939_ _03936_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14361_ _06600_ _06473_ VGND VGND VPWR VPWR _06601_ sky130_fd_sc_hd__nand2_1
XFILLER_42_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 i_a[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
X_16100_ clknet_leaf_14_clk multiplier_inst.exp_final\[3\] _00348_ VGND VGND VPWR
+ VPWR multiplier_inst.exp_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
X_13312_ _05606_ _05610_ VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__nor2_1
X_11573_ _03553_ _03555_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__nand2_1
X_10524_ _02822_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__inv_2
Xinput29 i_a[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
X_14292_ _06466_ _06526_ _06532_ VGND VGND VPWR VPWR _06533_ sky130_fd_sc_hd__o21ai_1
X_10455_ _02725_ _02722_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__and2_1
X_16031_ clknet_leaf_15_clk _00042_ _00279_ VGND VGND VPWR VPWR add_res\[15\] sky130_fd_sc_hd__dfrtp_1
X_13243_ _04893_ _04896_ _04894_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__a21oi_1
X_13174_ _05448_ _05471_ _05472_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__nand3_2
X_10386_ _02679_ _02683_ _02684_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__a21oi_1
XFILLER_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12125_ _04422_ _04423_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__nand2_1
XFILLER_117_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12056_ _04353_ _04204_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__nand2_1
X_11007_ _03298_ _03305_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__or2_1
X_15815_ net300 VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__inv_2
XFILLER_92_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15746_ net276 VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__inv_2
XFILLER_92_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12958_ _04260_ _04255_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__nand2_1
XFILLER_18_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15677_ net277 VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__inv_2
XFILLER_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12889_ _05134_ _05179_ _05180_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__nand3b_1
X_11909_ _04204_ _04206_ _04207_ VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__a21o_1
X_14628_ _06707_ _06712_ _06515_ VGND VGND VPWR VPWR _06868_ sky130_fd_sc_hd__nand3_1
XFILLER_60_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14559_ _06554_ _01422_ VGND VGND VPWR VPWR _06799_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08080_ _07845_ _07850_ VGND VGND VPWR VPWR _07851_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_11_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08982_ _01085_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__inv_2
X_07933_ _07484_ _07490_ VGND VGND VPWR VPWR _07498_ sky130_fd_sc_hd__nand2_1
XFILLER_95_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09603_ _01901_ _01729_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__nor2_1
XFILLER_83_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09534_ _01187_ _01832_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__nor2_1
XFILLER_71_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09465_ _01763_ _01599_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08416_ _00711_ _00714_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__nand2_1
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09396_ _01286_ _01283_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__nand2_1
XFILLER_11_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08347_ _00645_ net111 net244 VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__and3_1
X_08278_ _00575_ _00576_ VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__nand2_1
X_10240_ _02537_ _02529_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__or2b_1
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10171_ adder_inst.man_a_r\[8\] net174 VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__nand2_1
XFILLER_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout140 net142 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_4
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
Xfanout173 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_4
Xfanout151 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_4
X_13930_ _06192_ _06193_ _06202_ VGND VGND VPWR VPWR _06203_ sky130_fd_sc_hd__and3_1
XFILLER_101_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout184 net185 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_4
Xfanout195 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__clkbuf_4
X_13861_ _06103_ _06135_ VGND VGND VPWR VPWR _06136_ sky130_fd_sc_hd__nand2_1
X_15600_ net265 VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__inv_2
XFILLER_47_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13792_ _06066_ VGND VGND VPWR VPWR _06067_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_83_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12812_ _05110_ VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__inv_2
X_15531_ net405 mul_res\[26\] net260 VGND VGND VPWR VPWR _07727_ sky130_fd_sc_hd__mux2_1
XFILLER_103_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12743_ _05006_ _05010_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__nand2_1
X_15462_ _07683_ _07530_ VGND VGND VPWR VPWR _07684_ sky130_fd_sc_hd__nand2_1
XFILLER_15_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14413_ _06652_ _06569_ VGND VGND VPWR VPWR _06653_ sky130_fd_sc_hd__nor2_1
X_12674_ _04971_ _04972_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__nor2_1
X_15393_ _07604_ VGND VGND VPWR VPWR _07620_ sky130_fd_sc_hd__buf_6
X_11625_ _00649_ _01422_ _03748_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__nor3_1
X_14344_ _06466_ _06580_ _06462_ _06583_ VGND VGND VPWR VPWR _06584_ sky130_fd_sc_hd__o211ai_1
X_11556_ _03854_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__inv_2
X_10507_ net172 net240 VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__nand2_1
X_14275_ _06515_ VGND VGND VPWR VPWR _06516_ sky130_fd_sc_hd__buf_2
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16014_ clknet_leaf_13_clk net105 _00262_ VGND VGND VPWR VPWR add_vld sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_94_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13226_ _05510_ _05523_ _05524_ VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__nand3b_1
X_11487_ _03785_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__inv_2
X_10438_ _02735_ _02736_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__nand2_1
XFILLER_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10369_ _02666_ _02549_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__nand2_1
XFILLER_97_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13157_ _05454_ _05455_ VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__and2_1
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13088_ _03323_ _04239_ _05386_ VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__or3_1
X_12108_ _04406_ _01468_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__nand2_1
X_12039_ _04336_ _04334_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__nand2_1
XFILLER_93_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15729_ net304 VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__inv_2
XFILLER_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09250_ _01545_ _01548_ VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08201_ net214 net150 VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__nand2_1
XFILLER_21_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09181_ _01478_ _01479_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__nand2_1
X_08132_ _07856_ _00430_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__nand2_1
X_08063_ _07828_ _07830_ _07833_ VGND VGND VPWR VPWR _07834_ sky130_fd_sc_hd__nand3_1
X_08965_ _01254_ _01212_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__nor2_1
X_07916_ net188 net170 VGND VGND VPWR VPWR _07328_ sky130_fd_sc_hd__nand2_1
XFILLER_96_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08896_ _01194_ _01193_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__nand2_1
XFILLER_29_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09517_ _01674_ _01665_ _01662_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a21bo_1
XFILLER_37_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09448_ _01745_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_65_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09379_ _01659_ _01660_ _01675_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__nand3_1
XFILLER_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11410_ _03706_ _03708_ VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__nand2_1
X_12390_ _04688_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_117_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11341_ _03621_ _03451_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__nand2_1
XFILLER_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14060_ adder_inst.sum_raw_r\[10\] net256 _06055_ adder_inst.sum_raw_r\[9\] _06067_
+ VGND VGND VPWR VPWR _06320_ sky130_fd_sc_hd__a221o_1
XFILLER_4_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11272_ _01333_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__inv_2
X_10223_ net159 net239 VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__nand2_1
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13011_ _05308_ _05304_ _05305_ VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__nand3b_1
X_10154_ _02441_ _02452_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__nor2_1
XFILLER_79_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10085_ _02120_ _02117_ _02077_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__nand3_1
Xhold7 adder_inst.i_a\[6\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
X_14962_ _06741_ _07202_ VGND VGND VPWR VPWR _07204_ sky130_fd_sc_hd__or2_1
XFILLER_75_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13913_ _06074_ _06186_ _06187_ VGND VGND VPWR VPWR _06188_ sky130_fd_sc_hd__and3_1
X_14893_ _07112_ _07131_ VGND VGND VPWR VPWR _07132_ sky130_fd_sc_hd__or2_1
XFILLER_114_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13844_ _06118_ VGND VGND VPWR VPWR _06119_ sky130_fd_sc_hd__inv_2
XFILLER_90_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13775_ adder_inst.exp_larger_r\[1\] _06049_ _06044_ VGND VGND VPWR VPWR _06050_
+ sky130_fd_sc_hd__o21ai_1
X_10987_ _03282_ _03284_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__nand2_1
X_15514_ _07716_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_15_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12726_ _05023_ _05024_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__nand2_1
XFILLER_90_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15445_ _05794_ _07665_ VGND VGND VPWR VPWR _07668_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_13_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12657_ _04954_ _04955_ VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__nand2_1
X_15376_ _07603_ _07597_ _07604_ VGND VGND VPWR VPWR _07605_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_41_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11608_ _03904_ _03901_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__nand2_1
XFILLER_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14327_ _06547_ _06546_ VGND VGND VPWR VPWR _06567_ sky130_fd_sc_hd__or2_1
X_12588_ _04881_ _04239_ _04885_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__o21ai_1
X_11539_ _03769_ _03836_ _03837_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__nand3_1
X_14258_ _06498_ _06453_ VGND VGND VPWR VPWR _06499_ sky130_fd_sc_hd__nor2_1
X_14189_ _05865_ _06399_ _05863_ VGND VGND VPWR VPWR _06431_ sky130_fd_sc_hd__o21a_1
XFILLER_98_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13209_ _05507_ _05473_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__nand2_1
XFILLER_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08750_ _01047_ _01048_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__nand2_1
X_08681_ _00772_ _00977_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__nand2_1
XFILLER_80_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09302_ _01239_ _01231_ _01548_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__nand3_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09233_ _01531_ _01287_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__nand2_1
X_09164_ net121 net232 VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__nand2_1
XFILLER_9_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08115_ _07885_ _07882_ VGND VGND VPWR VPWR _07886_ sky130_fd_sc_hd__nand2_1
XFILLER_119_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09095_ _01392_ _01393_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__nand2_1
X_08046_ _07815_ _07742_ VGND VGND VPWR VPWR _07817_ sky130_fd_sc_hd__nand2_1
XFILLER_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09997_ _02294_ _02284_ _02283_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08948_ _01246_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__inv_2
XFILLER_48_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08879_ _01177_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__inv_2
XFILLER_28_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10910_ _03207_ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__inv_2
XFILLER_84_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11890_ _04186_ _04188_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__nand2_1
X_10841_ _03138_ _03139_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__nand2_1
XFILLER_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13560_ _05854_ _05856_ VGND VGND VPWR VPWR _05857_ sky130_fd_sc_hd__nand2_1
X_10772_ _01372_ _03000_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__nand2_1
XFILLER_25_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13491_ _05384_ _05789_ VGND VGND VPWR VPWR _05790_ sky130_fd_sc_hd__or2b_1
X_12511_ _04732_ _04735_ _04809_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__a21o_1
X_15230_ _07483_ VGND VGND VPWR VPWR adder_inst.exp_larger\[2\] sky130_fd_sc_hd__clkbuf_1
X_12442_ _04740_ _04562_ _04565_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__nand3_1
XFILLER_8_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15161_ _07394_ _06641_ _07397_ VGND VGND VPWR VPWR _07414_ sky130_fd_sc_hd__nand3_1
XFILLER_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12373_ net113 net208 VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__nand2_1
X_14112_ _06364_ _06365_ _06366_ VGND VGND VPWR VPWR _06367_ sky130_fd_sc_hd__o21ai_1
X_15092_ _06610_ VGND VGND VPWR VPWR _07341_ sky130_fd_sc_hd__inv_2
X_11324_ _01466_ _01462_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__nand2_1
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14043_ adder_inst.sum_raw_r\[14\] VGND VGND VPWR VPWR _06305_ sky130_fd_sc_hd__inv_2
X_11255_ _03330_ _03321_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__or2_1
XFILLER_106_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10206_ net154 VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__inv_2
X_11186_ _03483_ _03484_ _03480_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__nand3_1
X_15994_ clknet_leaf_3_clk net336 _00242_ VGND VGND VPWR VPWR adder_inst.man_b_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_10137_ _02432_ _02435_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__nand2_1
XFILLER_79_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10068_ _02234_ _02231_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__nand2_1
X_14945_ _07184_ _07185_ _06000_ VGND VGND VPWR VPWR _07186_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14876_ _07112_ _07000_ VGND VGND VPWR VPWR _07113_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_46_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13827_ _06101_ _06047_ VGND VGND VPWR VPWR _06102_ sky130_fd_sc_hd__nor2_1
X_13758_ _06034_ _06035_ VGND VGND VPWR VPWR _06036_ sky130_fd_sc_hd__nand2_1
X_12709_ _04655_ _05007_ VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__nand2_1
X_13689_ _05966_ _05980_ VGND VGND VPWR VPWR _05981_ sky130_fd_sc_hd__nand2_1
X_15428_ _07652_ VGND VGND VPWR VPWR multiplier_inst.man_final\[10\] sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15359_ _01301_ _05709_ VGND VGND VPWR VPWR _07587_ sky130_fd_sc_hd__xor2_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09920_ _02209_ _02210_ _02218_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__nand3_1
X_09851_ _02148_ _02149_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__nand2_1
XFILLER_112_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09782_ _02080_ _01914_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__nand2_1
XFILLER_85_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08802_ _01099_ VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08733_ _01020_ _01023_ _01015_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__nand3_1
XFILLER_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08664_ _00944_ _00946_ _00948_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__a21o_1
XFILLER_26_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08595_ _00879_ _00882_ _00893_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_62_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09216_ _00725_ _00729_ _00904_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09147_ net108 net248 VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__nand2_1
XFILLER_107_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09078_ _01375_ _01376_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_15_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08029_ net200 net164 VGND VGND VPWR VPWR _07800_ sky130_fd_sc_hd__nand2_1
XFILLER_1_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11040_ _03338_ _03297_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__nand2_1
XFILLER_89_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12991_ _05235_ _05289_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__nor2_1
X_14730_ _06969_ VGND VGND VPWR VPWR _06970_ sky130_fd_sc_hd__inv_2
XFILLER_55_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11942_ net192 VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__inv_2
XFILLER_72_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14661_ _06890_ _06891_ _06558_ VGND VGND VPWR VPWR _06901_ sky130_fd_sc_hd__nand3_1
X_11873_ _04169_ _04171_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__nand2_1
X_13612_ _05905_ _05906_ VGND VGND VPWR VPWR _05907_ sky130_fd_sc_hd__nand2_1
X_14592_ _06825_ _06831_ VGND VGND VPWR VPWR _06832_ sky130_fd_sc_hd__nand2_1
X_10824_ _03119_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__inv_2
XFILLER_111_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13543_ _05841_ VGND VGND VPWR VPWR _05842_ sky130_fd_sc_hd__inv_2
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10755_ _03053_ _03047_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__nand2_1
X_10686_ _02452_ _02984_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__nor2_1
XFILLER_71_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13474_ _05664_ _05701_ VGND VGND VPWR VPWR _05773_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15213_ _07467_ _07468_ VGND VGND VPWR VPWR _07469_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_33_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12425_ _04569_ _04723_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__nor2_1
X_15144_ _06609_ _06623_ _06625_ VGND VGND VPWR VPWR _07396_ sky130_fd_sc_hd__o21ai_1
X_12356_ _04650_ _04652_ _04654_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__a21o_1
XFILLER_114_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11307_ _03515_ _03520_ _03605_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__nand3_1
X_15075_ _07320_ _07322_ VGND VGND VPWR VPWR _07323_ sky130_fd_sc_hd__or2_1
XFILLER_4_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12287_ net192 net123 VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__nand2_1
X_14026_ adder_inst.sum_raw_r\[7\] net255 VGND VGND VPWR VPWR _06289_ sky130_fd_sc_hd__nand2_1
X_11238_ _03530_ _03536_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__nand2_1
X_11169_ _00649_ _02804_ _03467_ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__nor3_1
XFILLER_67_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15977_ clknet_leaf_8_clk net366 _00225_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_95_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14928_ _07166_ _07167_ _06000_ VGND VGND VPWR VPWR _07168_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_59_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14859_ _06990_ _07095_ VGND VGND VPWR VPWR _07096_ sky130_fd_sc_hd__or2_1
X_08380_ _00678_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__inv_2
XFILLER_50_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09001_ _01114_ _01116_ _01297_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__nand3_1
XFILLER_117_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09903_ net228 net162 VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__nand2_1
XFILLER_104_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09834_ _02132_ _02120_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__nand2_1
XFILLER_86_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_60_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09765_ _02060_ _01980_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__nand2_1
XFILLER_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09696_ _01971_ _01966_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__nand2_1
X_08716_ _01014_ _01011_ VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__nand2_1
XFILLER_27_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08647_ _00945_ VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08578_ _00876_ _00691_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__nand2_1
X_10540_ _02826_ _02832_ _02833_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__a21oi_1
XFILLER_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10471_ _02769_ _02765_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__nand2_1
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12210_ _04508_ _04500_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__nand2_1
XFILLER_108_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13190_ _03954_ _04881_ _05394_ _05488_ VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__or4b_1
X_12141_ _04439_ _03650_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__nand2_1
XFILLER_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12072_ _04369_ _04370_ VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__nand2_1
X_15900_ clknet_leaf_5_clk net63 _00148_ VGND VGND VPWR VPWR adder_inst.i_b\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_110_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11023_ net110 net237 net112 net234 VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__a22o_1
XFILLER_77_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15831_ net283 VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__inv_2
XFILLER_66_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15762_ net280 VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__inv_2
XFILLER_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12974_ _04327_ _04268_ VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_86_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14713_ _06461_ _06706_ VGND VGND VPWR VPWR _06953_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_56_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11925_ net181 net146 net184 net144 VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__a22o_1
XFILLER_17_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15693_ net278 VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__inv_2
XFILLER_45_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14644_ _06447_ _06478_ _06462_ _06883_ VGND VGND VPWR VPWR _06884_ sky130_fd_sc_hd__o211ai_1
X_11856_ _04152_ _04154_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__nand2_1
XFILLER_33_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14575_ net148 _06554_ _06814_ VGND VGND VPWR VPWR _06815_ sky130_fd_sc_hd__o21ai_1
X_10807_ _03043_ _03102_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__nor2_1
X_11787_ _04084_ _04085_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__nand2_1
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13526_ _05819_ _05560_ VGND VGND VPWR VPWR _05825_ sky130_fd_sc_hd__nand2_1
X_10738_ _03031_ _03036_ _03032_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__nand3_1
XFILLER_13_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13457_ _05755_ _05370_ VGND VGND VPWR VPWR _05756_ sky130_fd_sc_hd__nand2_1
X_10669_ _02910_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__nor2_1
X_12408_ _04706_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_97_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13388_ _05685_ _05682_ VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__nand2_1
XFILLER_114_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15127_ _07371_ _07377_ VGND VGND VPWR VPWR _07378_ sky130_fd_sc_hd__nand2_1
X_12339_ _04551_ _04637_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__xor2_1
XFILLER_114_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15058_ _06790_ _06777_ VGND VGND VPWR VPWR _07305_ sky130_fd_sc_hd__nand2_1
X_14009_ _06273_ _06131_ VGND VGND VPWR VPWR _06274_ sky130_fd_sc_hd__and2_1
XFILLER_95_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09550_ _01847_ _01848_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__nand2_1
XFILLER_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09481_ _01779_ _01623_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__nand2_1
X_08501_ _00540_ _00799_ _00538_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__o21ai_1
X_08432_ _00519_ _00493_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__nand2_1
XFILLER_23_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08363_ _00660_ _00661_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_34_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08294_ _00592_ _00587_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__nand2_1
XFILLER_31_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout300 net305 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_6_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09817_ _01951_ _01923_ _01947_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__nand3_1
XFILLER_74_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09748_ _02037_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__inv_2
X_09679_ _01977_ _01788_ VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__nand2_1
X_11710_ _03797_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__inv_2
XFILLER_15_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12690_ _04983_ _04988_ VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__nand2b_1
X_11641_ _03885_ _03936_ _03939_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_81_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14360_ _06596_ _06599_ VGND VGND VPWR VPWR _06600_ sky130_fd_sc_hd__and2_1
X_11572_ _03869_ _03870_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__nand2_1
Xinput19 i_a[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
X_10523_ _02820_ _02821_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__nand2_1
X_13311_ _05607_ _05609_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__or2_1
XFILLER_10_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14291_ _06446_ _06531_ VGND VGND VPWR VPWR _06532_ sky130_fd_sc_hd__or2_1
XFILLER_6_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10454_ _02660_ _02752_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__nand2_1
XFILLER_108_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16030_ clknet_leaf_15_clk _00041_ _00278_ VGND VGND VPWR VPWR add_res\[14\] sky130_fd_sc_hd__dfrtp_1
X_13242_ _05540_ _05525_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__nand2_1
X_10385_ _02678_ _02669_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__nor2_1
X_13173_ _05446_ _05444_ _05445_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__o21bai_1
X_12124_ _04400_ _04403_ _04416_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__nand3_1
XFILLER_77_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12055_ _04353_ _04206_ _04204_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__nand3_1
X_11006_ _03303_ _03304_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__nand2_1
X_15814_ net296 VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__inv_2
XFILLER_80_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15745_ net276 VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__inv_2
XFILLER_93_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12957_ _05255_ _05176_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__nand2_1
XFILLER_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15676_ net271 VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__inv_2
X_12888_ _05185_ _05116_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__nand2_1
XFILLER_33_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11908_ _04203_ _04201_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__nor2_1
XFILLER_60_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14627_ _06863_ _06700_ _06866_ VGND VGND VPWR VPWR _06867_ sky130_fd_sc_hd__nand3_1
X_11839_ _01042_ _04136_ _04137_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_99_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14558_ _06795_ _06558_ VGND VGND VPWR VPWR _06798_ sky130_fd_sc_hd__nand2_1
XFILLER_9_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14489_ _06727_ _06728_ _06473_ VGND VGND VPWR VPWR _06729_ sky130_fd_sc_hd__nand3_1
X_13509_ _05791_ _05582_ VGND VGND VPWR VPWR _05808_ sky130_fd_sc_hd__nand2_1
XFILLER_9_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16159_ clknet_leaf_15_clk _00012_ _00407_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
XFILLER_114_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08981_ _01279_ _01085_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__nand2_1
X_07932_ net191 net164 VGND VGND VPWR VPWR _07490_ sky130_fd_sc_hd__nand2_1
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09602_ net223 net165 VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__nand2_1
XFILLER_95_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09533_ _01827_ _01831_ _01829_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_39_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09464_ _01605_ _01580_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09395_ _01693_ _01686_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__nand2_1
X_08415_ _00712_ _00645_ _00713_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__nand3_1
XFILLER_24_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08346_ _00644_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__inv_2
XFILLER_24_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08277_ _00571_ _00573_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__nand2_1
XFILLER_106_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10170_ _02468_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__inv_2
Xfanout130 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_4
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_4
Xfanout163 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_4
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_2
XFILLER_74_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout196 net197 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_2
Xfanout185 adder_inst.man_a_r\[21\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13860_ _06047_ _06101_ VGND VGND VPWR VPWR _06135_ sky130_fd_sc_hd__nand2_1
XFILLER_74_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13791_ adder_inst.sum_raw_r\[19\] net253 VGND VGND VPWR VPWR _06066_ sky130_fd_sc_hd__nor2_2
X_12811_ _05109_ _05108_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__nand2_1
XFILLER_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15530_ net396 VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__clkbuf_1
X_12742_ _04923_ _05040_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__nor2_1
XFILLER_15_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15461_ _07680_ _07682_ VGND VGND VPWR VPWR _07683_ sky130_fd_sc_hd__and2_1
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12673_ _04673_ net109 net212 VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__and3_1
X_14412_ net108 VGND VGND VPWR VPWR _06652_ sky130_fd_sc_hd__inv_2
XFILLER_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11624_ _03922_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__inv_2
X_15392_ _07619_ VGND VGND VPWR VPWR multiplier_inst.man_final\[4\] sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_7_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14343_ _06446_ _06582_ VGND VGND VPWR VPWR _06583_ sky130_fd_sc_hd__or2_1
X_11555_ _03853_ _03373_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__nand2_1
XFILLER_11_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10506_ net175 VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__inv_2
X_14274_ _06472_ VGND VGND VPWR VPWR _06515_ sky130_fd_sc_hd__inv_2
X_11486_ _03223_ _03221_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__nand2_1
X_16013_ clknet_leaf_11_clk net312 _00261_ VGND VGND VPWR VPWR adder_inst.sign_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_10437_ _02677_ _02670_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__nand2_1
XFILLER_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13225_ _05518_ _05521_ _05519_ VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10368_ _02549_ _02666_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__or2_1
XFILLER_88_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13156_ _05452_ _05451_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__nand2_1
X_10299_ _02579_ _02595_ _02597_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__nand3_1
XFILLER_69_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13087_ net111 net187 VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__nand2_1
X_12107_ _01455_ _01471_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__or2_1
XFILLER_2_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12038_ _04209_ _04334_ _04336_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__nand3_1
XFILLER_77_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13989_ _06184_ _06255_ VGND VGND VPWR VPWR _06256_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_36_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15728_ net301 VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__inv_2
XFILLER_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15659_ net278 VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_16_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08200_ _00495_ _07834_ _00497_ VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__a21o_1
XFILLER_21_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09180_ _00439_ _07886_ _00441_ VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__a21boi_1
X_08131_ _00429_ VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__inv_2
X_08062_ _07831_ _07832_ VGND VGND VPWR VPWR _07833_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08964_ _01259_ _01262_ VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__nand2_1
XFILLER_69_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07915_ _07275_ _07307_ VGND VGND VPWR VPWR _07318_ sky130_fd_sc_hd__nand2_1
XFILLER_84_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08895_ _00888_ _01192_ _01193_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__nand3b_1
XFILLER_56_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09516_ _01805_ _01812_ _01814_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__nand3_1
X_09447_ _01744_ _01745_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09378_ _01661_ _01676_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__nand2_1
XFILLER_8_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08329_ _00618_ _00627_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_117_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11340_ _03637_ _03638_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__nand2_1
XFILLER_116_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13010_ _05306_ _05308_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__nand2_1
X_11271_ _03565_ _03569_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__nand2_1
X_10222_ _02477_ _02520_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__nand2_1
XFILLER_4_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10153_ _02449_ _02185_ _02451_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__nand3_1
X_10084_ _02382_ _02078_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__nand2_1
X_14961_ _07202_ _06741_ VGND VGND VPWR VPWR _07203_ sky130_fd_sc_hd__nand2_1
Xhold8 adder_inst.i_a\[9\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_59_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13912_ adder_inst.is_inf_r VGND VGND VPWR VPWR _06187_ sky130_fd_sc_hd__inv_2
X_14892_ _07125_ _07130_ VGND VGND VPWR VPWR _07131_ sky130_fd_sc_hd__nand2_2
XFILLER_75_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13843_ adder_inst.exp_larger_r\[1\] adder_inst.exp_larger_r\[2\] VGND VGND VPWR
+ VPWR _06118_ sky130_fd_sc_hd__nor2_1
XFILLER_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13774_ adder_inst.sum_raw_r\[21\] VGND VGND VPWR VPWR _06049_ sky130_fd_sc_hd__inv_2
X_15513_ add_res\[17\] mul_res\[17\] net260 VGND VGND VPWR VPWR _07716_ sky130_fd_sc_hd__mux2_1
XFILLER_43_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10986_ _03280_ _03282_ _03284_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__nand3b_1
X_12725_ _05022_ _05019_ _05020_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__nand3b_1
X_15444_ _07620_ _07666_ _07667_ VGND VGND VPWR VPWR multiplier_inst.man_final\[13\]
+ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_13_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12656_ _04934_ _04710_ _04952_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__nand3_2
XFILLER_30_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15375_ _05848_ VGND VGND VPWR VPWR _07604_ sky130_fd_sc_hd__buf_6
X_12587_ _04881_ _04239_ _04885_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_41_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11607_ _03722_ _03886_ _03717_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__o21a_1
X_14326_ _06561_ _06566_ VGND VGND VPWR VPWR adder_inst.sum_raw\[0\] sky130_fd_sc_hd__nand2_1
X_11538_ _03798_ _03834_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__nand2_1
X_14257_ _06497_ _04552_ _06440_ VGND VGND VPWR VPWR _06498_ sky130_fd_sc_hd__mux2_1
X_11469_ _03764_ _03767_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__nand2_1
X_14188_ _05865_ _06415_ _05864_ VGND VGND VPWR VPWR _06430_ sky130_fd_sc_hd__o21a_1
X_13208_ _05505_ _05506_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__nand2_1
XFILLER_97_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13139_ _05436_ _05437_ VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__nand2_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08680_ _00773_ _00978_ VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__nand2_1
XFILLER_81_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09301_ _01545_ _01236_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_101_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09232_ _01294_ _01291_ VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__xor2_1
XFILLER_119_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09163_ _01459_ _01461_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nand2_1
XFILLER_119_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08114_ _07862_ _07882_ _07884_ VGND VGND VPWR VPWR _07885_ sky130_fd_sc_hd__nand3b_1
X_09094_ _01391_ _01380_ _01381_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__nand3b_1
X_08045_ _07812_ _07742_ _07815_ VGND VGND VPWR VPWR _07816_ sky130_fd_sc_hd__nand3_2
XFILLER_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09996_ _02285_ _02294_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__nand2_1
XFILLER_103_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08947_ _01244_ _01245_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__nand2_1
XFILLER_69_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08878_ _01176_ _01055_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__nand2_1
XFILLER_84_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_88_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10840_ _03122_ _03136_ _03124_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__nand3_1
XFILLER_29_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10771_ _03069_ _03007_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__nand2_1
XFILLER_25_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13490_ _05582_ _05581_ VGND VGND VPWR VPWR _05789_ sky130_fd_sc_hd__nand2_1
X_12510_ _04807_ _04808_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__nand2_1
XFILLER_100_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12441_ _04738_ _04739_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__nand2_1
XFILLER_12_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15160_ _07401_ _07412_ VGND VGND VPWR VPWR adder_inst.sum_raw\[20\] sky130_fd_sc_hd__nand2_1
XFILLER_60_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12372_ net107 net212 VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_97_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14111_ adder_inst.sum_raw_r\[17\] _06052_ adder_inst.sum_raw_r\[16\] _06252_ _06155_
+ VGND VGND VPWR VPWR _06366_ sky130_fd_sc_hd__o221a_1
X_15091_ _07339_ VGND VGND VPWR VPWR _07340_ sky130_fd_sc_hd__inv_2
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11323_ _03620_ _03451_ _03621_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_91_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14042_ _06301_ _06302_ _06303_ VGND VGND VPWR VPWR _06304_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11254_ _03552_ _03435_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__nand2_1
X_10205_ _02214_ _02503_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__or2_1
XFILLER_69_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11185_ _03434_ _03430_ _03338_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__nand3_1
X_15993_ clknet_leaf_4_clk net357 _00241_ VGND VGND VPWR VPWR adder_inst.man_b_r\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_10136_ _02166_ _02434_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__nand2_1
X_10067_ _02364_ _02365_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__nand2_1
X_14944_ _07182_ _06725_ _07183_ VGND VGND VPWR VPWR _07185_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_89_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14875_ _07003_ VGND VGND VPWR VPWR _07112_ sky130_fd_sc_hd__inv_2
XFILLER_62_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13826_ adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR _06101_ sky130_fd_sc_hd__inv_2
XFILLER_90_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13757_ _05938_ _05946_ VGND VGND VPWR VPWR _06035_ sky130_fd_sc_hd__nor2_1
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10969_ _03252_ _03255_ _03253_ VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__o21a_1
X_12708_ _04650_ _04652_ _04654_ VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__nand3_1
X_13688_ _05979_ VGND VGND VPWR VPWR _05980_ sky130_fd_sc_hd__inv_2
X_15427_ _07651_ _07644_ _05848_ VGND VGND VPWR VPWR _07652_ sky130_fd_sc_hd__mux2_1
X_12639_ _04937_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__inv_2
X_15358_ _07539_ _07550_ _07585_ VGND VGND VPWR VPWR _07586_ sky130_fd_sc_hd__a21oi_1
X_15289_ _07491_ multiplier_inst.man_final_r\[21\] _07493_ VGND VGND VPWR VPWR _07522_
+ sky130_fd_sc_hd__and3_1
X_14309_ _06448_ VGND VGND VPWR VPWR _06550_ sky130_fd_sc_hd__buf_2
XFILLER_98_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09850_ _01805_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__inv_2
X_09781_ _02079_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__inv_2
X_08801_ _01098_ _01099_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__nand2_1
XFILLER_85_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08732_ _00932_ _01030_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__nand2_1
XFILLER_39_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08663_ _00959_ _00961_ VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__nand2_1
XFILLER_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08594_ _00891_ _00892_ VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__nand2_1
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09215_ _01512_ _01513_ VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__nand2_1
XFILLER_6_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09146_ _01442_ _01444_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__nand2_1
XFILLER_108_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09077_ net140 net211 VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__nand2_1
XFILLER_107_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08028_ _07787_ _07798_ _07788_ VGND VGND VPWR VPWR _07799_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_73_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09979_ _02275_ _02277_ VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__nand2_1
XFILLER_89_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12990_ _05287_ _05288_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__nand2_1
XFILLER_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11941_ _04239_ _01670_ _04076_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__or3_1
X_14660_ _06894_ _06899_ VGND VGND VPWR VPWR _06900_ sky130_fd_sc_hd__nand2_1
XFILLER_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11872_ _04170_ VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__inv_2
X_13611_ _05898_ _05899_ _05904_ VGND VGND VPWR VPWR _05906_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14591_ _06827_ _06830_ VGND VGND VPWR VPWR _06831_ sky130_fd_sc_hd__nand2_1
XFILLER_72_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10823_ _03116_ _03118_ _03121_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__nand3_1
XFILLER_25_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13542_ _05840_ _05652_ VGND VGND VPWR VPWR _05841_ sky130_fd_sc_hd__nand2_1
X_10754_ _03047_ _03049_ _03052_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__nand3_1
X_10685_ _02982_ _02983_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__nand2_1
X_13473_ _05752_ _05767_ _05771_ VGND VGND VPWR VPWR _05772_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_51_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15212_ _07015_ _07019_ _06668_ VGND VGND VPWR VPWR _07468_ sky130_fd_sc_hd__a21oi_1
X_12424_ net178 net133 VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__nand2_1
X_15143_ _07009_ _06593_ _06592_ VGND VGND VPWR VPWR _07395_ sky130_fd_sc_hd__o21ai_1
X_12355_ _04571_ _04653_ VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__xor2_1
X_11306_ _03603_ _03604_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__nand2_1
X_15074_ _07315_ _07010_ _07321_ VGND VGND VPWR VPWR _07322_ sky130_fd_sc_hd__a21bo_1
X_12286_ _04584_ VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__inv_2
XFILLER_106_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14025_ _06288_ VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11237_ _03532_ _03535_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__nand2_1
XFILLER_96_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11168_ net114 net240 VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__nand2_1
XFILLER_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10119_ _02136_ _02142_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__nand2_1
X_15976_ clknet_leaf_8_clk net364 _00224_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_11099_ _03391_ _03395_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__nand2_1
X_14927_ _07165_ _07150_ VGND VGND VPWR VPWR _07167_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_59_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14858_ _07065_ _06932_ _06948_ _07094_ VGND VGND VPWR VPWR _07095_ sky130_fd_sc_hd__a31o_1
X_13809_ _06083_ VGND VGND VPWR VPWR _06084_ sky130_fd_sc_hd__inv_2
XFILLER_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14789_ _07027_ _07016_ VGND VGND VPWR VPWR _07028_ sky130_fd_sc_hd__or2_1
XFILLER_50_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09000_ _01117_ _01298_ VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__nand2_1
XFILLER_105_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09902_ net230 net165 VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__nand2_1
X_09833_ _02078_ _02120_ _02117_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__nand3_1
XFILLER_86_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09764_ _02062_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__inv_2
XFILLER_86_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09695_ _01970_ _01972_ _01993_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__nand3_1
XFILLER_66_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08715_ _01010_ _01011_ _01013_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__nand3_1
XFILLER_39_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08646_ net204 net169 VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08577_ _00683_ _00692_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__nand2_1
XFILLER_42_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10470_ _02765_ _02768_ _02755_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__nand3_1
XFILLER_10_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09129_ _01424_ _01427_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__nand2_1
X_12140_ _03608_ _03655_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__nand2_1
XFILLER_108_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12071_ _03598_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__inv_2
X_11022_ _03319_ _03320_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__nand2_1
XFILLER_77_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15830_ net285 VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__inv_2
XFILLER_92_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15761_ net280 VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__inv_2
X_12973_ _05271_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_86_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15692_ net268 VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__inv_2
X_14712_ _06465_ _06836_ _06512_ _06861_ VGND VGND VPWR VPWR _06952_ sky130_fd_sc_hd__o211ai_1
XFILLER_45_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11924_ _04176_ _04178_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__nand2_1
XFILLER_72_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14643_ _06455_ _06447_ VGND VGND VPWR VPWR _06883_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_56_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11855_ _00650_ _01422_ _04153_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14574_ _06811_ _06637_ VGND VGND VPWR VPWR _06814_ sky130_fd_sc_hd__nand2_1
XFILLER_60_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10806_ _03104_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__inv_2
X_11786_ _04083_ _04072_ _04073_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__nand3b_1
X_13525_ _05813_ _05823_ VGND VGND VPWR VPWR _05824_ sky130_fd_sc_hd__or2_1
XFILLER_41_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10737_ _03034_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__inv_2
X_13456_ _05753_ _05754_ VGND VGND VPWR VPWR _05755_ sky130_fd_sc_hd__nand2_1
XFILLER_9_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10668_ _02959_ _02965_ _02966_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__a21oi_1
X_12407_ _04705_ _04704_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__nand2_1
X_10599_ _02795_ _02851_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_97_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13387_ _05682_ _05685_ VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__or2_1
XFILLER_99_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15126_ _07376_ _07173_ VGND VGND VPWR VPWR _07377_ sky130_fd_sc_hd__nand2_1
XFILLER_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12338_ _04555_ _04557_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__nor2_1
X_15057_ _07303_ _07141_ VGND VGND VPWR VPWR _07304_ sky130_fd_sc_hd__nand2_1
X_12269_ net138 VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__inv_2
X_14008_ _06270_ _06271_ _06272_ VGND VGND VPWR VPWR _06273_ sky130_fd_sc_hd__a21o_1
XFILLER_68_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15959_ clknet_leaf_0_clk net315 _00207_ VGND VGND VPWR VPWR adder_inst.man_a_r\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_09480_ _01625_ _01149_ _01622_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__o21ai_1
X_08500_ _00536_ VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__inv_2
XFILLER_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08431_ _00725_ _00729_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_106_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08362_ _00658_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_34_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08293_ _00585_ _00587_ _00591_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__nand3b_1
XFILLER_11_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout301 net305 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_4
XFILLER_59_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09816_ _02114_ _01948_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__nand2_1
XFILLER_100_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09747_ _02045_ _02041_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__nand2_1
XFILLER_74_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09678_ _01785_ _01787_ _01786_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__a21bo_1
XFILLER_54_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08629_ _00927_ _00798_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__nand2_1
XFILLER_42_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11640_ _03937_ _03938_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11571_ _03867_ _03864_ _03865_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__nand3_1
X_10522_ _02819_ _02814_ _02817_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__nand3b_1
X_13310_ _05608_ _05595_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__nand2_1
XFILLER_10_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14290_ _06527_ _06528_ _06530_ VGND VGND VPWR VPWR _06531_ sky130_fd_sc_hd__o21a_1
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10453_ _02505_ _00651_ _02531_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__o21ai_1
X_13241_ _05539_ _05510_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__nand2_1
XFILLER_10_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10384_ _02682_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__inv_2
X_13172_ _05469_ _05470_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__and2_1
X_12123_ _04404_ _04418_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__nand2_1
XFILLER_96_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12054_ _04352_ _04200_ _04198_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__nand3_1
XFILLER_77_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11005_ _03299_ _03301_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nand2_1
X_15813_ net298 VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__inv_2
X_15744_ net290 VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__inv_2
XFILLER_65_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12956_ _05253_ _05254_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__nand2_1
X_15675_ net272 VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__inv_2
XFILLER_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12887_ _05182_ _05185_ _05116_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__nand3_1
X_11907_ _04205_ _04029_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__nand2_1
X_14626_ _06864_ _06462_ _06865_ VGND VGND VPWR VPWR _06866_ sky130_fd_sc_hd__nand3_1
X_11838_ net119 net212 VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__nand2_1
X_14557_ _06558_ _06795_ _06796_ VGND VGND VPWR VPWR _06797_ sky130_fd_sc_hd__o21ai_1
X_13508_ _05772_ _05806_ VGND VGND VPWR VPWR _05807_ sky130_fd_sc_hd__nor2_1
X_11769_ _04066_ _04067_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__nand2_1
XFILLER_13_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14488_ _06465_ _06495_ _06512_ _06501_ VGND VGND VPWR VPWR _06728_ sky130_fd_sc_hd__o211ai_1
XFILLER_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13439_ _05727_ _05690_ _05737_ VGND VGND VPWR VPWR _05738_ sky130_fd_sc_hd__o21ai_1
X_16158_ clknet_leaf_15_clk _00010_ _00406_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_11_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15109_ _07355_ _07358_ VGND VGND VPWR VPWR _07359_ sky130_fd_sc_hd__nand2_1
X_16089_ clknet_leaf_20_clk multiplier_inst.man_final\[15\] _00337_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[15\] sky130_fd_sc_hd__dfrtp_1
X_08980_ _01278_ _01031_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__nand2_1
XFILLER_68_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07931_ net194 net161 VGND VGND VPWR VPWR _07484_ sky130_fd_sc_hd__nand2_1
XFILLER_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09601_ _01899_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__inv_2
XFILLER_83_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09532_ _01829_ _01830_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_39_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09463_ _01739_ _01760_ _01761_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__a21oi_1
X_09394_ _01686_ _01687_ _01692_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__nand3_1
X_08414_ _00698_ _00708_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08345_ net112 net248 VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__nand2_1
XFILLER_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08276_ _00572_ _00574_ VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_119_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout120 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_2
Xfanout131 net132 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_4
Xfanout142 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_4
Xfanout164 net166 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_4
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
Xfanout175 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout186 net188 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_4
Xfanout197 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_4
XFILLER_74_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12810_ _05090_ _05107_ _05108_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__nand3_1
X_13790_ _06064_ VGND VGND VPWR VPWR _06065_ sky130_fd_sc_hd__inv_2
XFILLER_27_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12741_ _05037_ _05039_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__nand2_1
XFILLER_27_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15460_ _07676_ _05830_ VGND VGND VPWR VPWR _07682_ sky130_fd_sc_hd__nand2_1
X_12672_ _04970_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__inv_2
X_14411_ _06642_ _06650_ VGND VGND VPWR VPWR _06651_ sky130_fd_sc_hd__nor2_1
XFILLER_42_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11623_ net106 net229 VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__nand2_1
X_15391_ _07618_ _07612_ _07604_ VGND VGND VPWR VPWR _07619_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_22_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14342_ _06540_ _06539_ _06581_ VGND VGND VPWR VPWR _06582_ sky130_fd_sc_hd__o21ai_1
X_11554_ _03383_ _03374_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__or2_1
XFILLER_11_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14273_ _06502_ _06513_ VGND VGND VPWR VPWR _06514_ sky130_fd_sc_hd__nand2_1
X_10505_ net237 VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__inv_2
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11485_ _03782_ _03783_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__nand2_1
X_16012_ clknet_leaf_13_clk _00068_ _00260_ VGND VGND VPWR VPWR add_ovf sky130_fd_sc_hd__dfrtp_1
X_10436_ _02670_ _02677_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_94_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13224_ _05520_ _05522_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__nand2_1
XFILLER_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10367_ _02471_ _02551_ _02548_ VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__o21ai_1
X_13155_ _05453_ VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__inv_2
X_10298_ _02596_ _02590_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__nand2_1
XFILLER_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13086_ net106 net193 VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__nand2_1
X_12106_ _01484_ _01482_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__nand2_1
XFILLER_111_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12037_ _04335_ _04221_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_108_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13988_ _06239_ _06044_ _06227_ _06084_ _06254_ VGND VGND VPWR VPWR _06255_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_36_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15727_ net301 VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__inv_2
X_12939_ _04326_ _04323_ _05237_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__a21o_1
XFILLER_73_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15658_ net262 VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_103_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14609_ _06848_ _06568_ VGND VGND VPWR VPWR _06849_ sky130_fd_sc_hd__nand2_1
XFILLER_61_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_15589_ net270 VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__inv_2
X_08130_ net138 net218 VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__nand2_1
XFILLER_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08061_ net204 net155 VGND VGND VPWR VPWR _07832_ sky130_fd_sc_hd__nand2_1
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08963_ _01260_ _01261_ _01166_ VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__nand3_1
XFILLER_102_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07914_ _07286_ _07296_ VGND VGND VPWR VPWR _07307_ sky130_fd_sc_hd__nand2_1
XFILLER_69_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08894_ _01173_ _01190_ _01074_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__nand3_1
XFILLER_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09515_ _01810_ _01607_ _01813_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__nand3_1
X_09446_ _01730_ _01733_ _01728_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09377_ _01675_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__inv_2
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08328_ _00621_ _00626_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_117_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08259_ _00556_ _00557_ _00553_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__nand3_1
XFILLER_109_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11270_ _03568_ _03545_ _03550_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nand3_1
X_10221_ net162 net236 VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__nand2_1
XFILLER_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10152_ _02450_ _02167_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__nand2_1
X_10083_ _02120_ _02117_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__nand2_1
X_14960_ _07198_ _07200_ VGND VGND VPWR VPWR _07202_ sky130_fd_sc_hd__nand2_1
X_13911_ adder_inst.is_zero_r VGND VGND VPWR VPWR _06186_ sky130_fd_sc_hd__inv_2
Xhold9 adder_inst.i_a\[8\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14891_ _07094_ _07126_ _07129_ VGND VGND VPWR VPWR _07130_ sky130_fd_sc_hd__a21oi_1
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13842_ _06045_ _06099_ _06043_ VGND VGND VPWR VPWR _06117_ sky130_fd_sc_hd__a21o_1
X_13773_ _06046_ _06047_ VGND VGND VPWR VPWR _06048_ sky130_fd_sc_hd__nand2_1
XFILLER_62_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15512_ net387 VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__clkbuf_1
X_10985_ _03259_ _03283_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__nand2_1
X_12724_ _05021_ _05022_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__nand2_1
X_15443_ _07660_ _07604_ VGND VGND VPWR VPWR _07667_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_13_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12655_ _04935_ _04953_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__nand2_1
XFILLER_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15374_ _07602_ VGND VGND VPWR VPWR _07603_ sky130_fd_sc_hd__inv_2
X_12586_ _04883_ _04884_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11606_ _03887_ _03901_ _03904_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__nand3_1
X_14325_ _06562_ _06565_ VGND VGND VPWR VPWR _06566_ sky130_fd_sc_hd__nand2_1
X_11537_ _03799_ _03835_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__nand2_1
XFILLER_109_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14256_ net133 VGND VGND VPWR VPWR _06497_ sky130_fd_sc_hd__inv_2
X_11468_ _03765_ _03766_ _03699_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__nand3_1
X_14187_ _06421_ _06428_ VGND VGND VPWR VPWR _06429_ sky130_fd_sc_hd__nor2_1
X_10419_ _02700_ _02697_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__nand2_1
X_13207_ _05471_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__inv_2
X_11399_ _03547_ _03247_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__nand2_1
XFILLER_97_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13138_ _05435_ _05428_ VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__nand2_1
XFILLER_112_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13069_ _05367_ _05358_ VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09300_ _01596_ _01598_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__nand2_1
XFILLER_34_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09231_ _01528_ _01529_ VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__nand2_2
XFILLER_21_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09162_ _01460_ VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__inv_2
XFILLER_119_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08113_ _07883_ _07871_ VGND VGND VPWR VPWR _07884_ sky130_fd_sc_hd__nand2_1
XFILLER_119_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09093_ _01382_ _01391_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__nand2_1
X_08044_ _07813_ _07814_ VGND VGND VPWR VPWR _07815_ sky130_fd_sc_hd__nand2_1
XFILLER_1_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09995_ _02293_ _02289_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__nand2_1
XFILLER_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08946_ _01146_ _01144_ _01133_ VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__nand3_1
XFILLER_69_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08877_ net136 net238 VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__nand2_1
XFILLER_29_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10770_ _03003_ _03006_ _03005_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__a21o_1
XFILLER_100_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09429_ _01727_ _01566_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__nor2_1
XFILLER_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12440_ _04735_ _04724_ _04736_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__nand3_1
X_14110_ adder_inst.sum_raw_r\[15\] net256 _06055_ adder_inst.sum_raw_r\[14\] _06067_
+ VGND VGND VPWR VPWR _06365_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_78_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12371_ _04668_ _04669_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__nand2_1
X_15090_ _07336_ _07337_ VGND VGND VPWR VPWR _07339_ sky130_fd_sc_hd__nand2_1
X_11322_ _03448_ _03449_ _03450_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__a21o_1
XFILLER_109_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14041_ adder_inst.sum_raw_r\[12\] net251 _06200_ adder_inst.sum_raw_r\[11\] VGND
+ VGND VPWR VPWR _06303_ sky130_fd_sc_hd__a22o_1
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11253_ _03435_ _03437_ _03480_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__nand3_1
XFILLER_106_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10204_ net156 net242 VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__nand2_1
XFILLER_79_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11184_ _03436_ _03431_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__nand2_1
X_15992_ clknet_leaf_4_clk net362 _00240_ VGND VGND VPWR VPWR adder_inst.man_b_r\[8\]
+ sky130_fd_sc_hd__dfrtp_1
X_10135_ _02136_ _02144_ _02433_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10066_ _02362_ _02359_ _02072_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__nand3_1
X_14943_ _07182_ _07183_ _06725_ VGND VGND VPWR VPWR _07184_ sky130_fd_sc_hd__a21o_1
XFILLER_85_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14874_ _07106_ _07111_ VGND VGND VPWR VPWR adder_inst.sum_raw\[7\] sky130_fd_sc_hd__nand2_1
XFILLER_85_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13825_ _06099_ _06047_ VGND VGND VPWR VPWR _06100_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_89_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13756_ _05970_ _05987_ VGND VGND VPWR VPWR _06034_ sky130_fd_sc_hd__nor2_1
XFILLER_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10968_ _03256_ _03264_ _03266_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__nand3_1
X_13687_ _05978_ _05961_ VGND VGND VPWR VPWR _05979_ sky130_fd_sc_hd__xor2_1
XFILLER_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12707_ _04956_ _05005_ VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__nand2_1
X_15426_ _07650_ VGND VGND VPWR VPWR _07651_ sky130_fd_sc_hd__inv_2
X_10899_ net202 net137 VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__nand2_1
X_12638_ _04696_ _04936_ VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15357_ _07579_ _07581_ _07584_ VGND VGND VPWR VPWR _07585_ sky130_fd_sc_hd__nand3_1
X_12569_ _04842_ _04814_ VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__and2_1
X_15288_ _07521_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__clkbuf_1
X_14308_ _06522_ _06548_ VGND VGND VPWR VPWR _06549_ sky130_fd_sc_hd__nand2_1
X_14239_ net153 net227 _06440_ VGND VGND VPWR VPWR _06480_ sky130_fd_sc_hd__mux2_1
XFILLER_7_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08800_ _00887_ _00889_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__nand2_1
X_09780_ _01916_ _01711_ _01913_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08731_ _00995_ _01028_ _01029_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__a21oi_1
X_08662_ _00960_ _00957_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__nand2_1
XFILLER_38_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08593_ _00886_ _00889_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__nand2_1
XFILLER_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09214_ _01497_ _01498_ _01510_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__nand3_1
XFILLER_14_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09145_ _01443_ _01420_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__nand2_1
X_09076_ _01373_ _01374_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__nand2_1
X_08027_ _07791_ _07793_ _07795_ VGND VGND VPWR VPWR _07798_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09978_ _02276_ _02272_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08929_ _01227_ _00943_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__nor2_1
XFILLER_92_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11940_ net190 VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__inv_2
XFILLER_91_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11871_ _03936_ _03905_ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__nand2_1
X_13610_ _05898_ _05899_ _05904_ VGND VGND VPWR VPWR _05905_ sky130_fd_sc_hd__or3_1
X_14590_ _06829_ _06722_ VGND VGND VPWR VPWR _06830_ sky130_fd_sc_hd__nand2_1
XFILLER_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10822_ _03119_ _03120_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__nor2_1
XFILLER_111_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13541_ _05664_ _05839_ VGND VGND VPWR VPWR _05840_ sky130_fd_sc_hd__nand2_1
X_10753_ _03050_ _03051_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__nand2_1
XFILLER_13_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10684_ _02438_ _02440_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__and2_1
X_15211_ _07454_ _06670_ VGND VGND VPWR VPWR _07467_ sky130_fd_sc_hd__nand2_1
X_13472_ _05770_ VGND VGND VPWR VPWR _05771_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_51_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12423_ net180 net132 net177 net135 VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__a22o_1
X_15142_ _07301_ _07387_ VGND VGND VPWR VPWR _07394_ sky130_fd_sc_hd__nand2_1
X_12354_ _04574_ _04570_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__and2b_1
XFILLER_99_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15073_ _06570_ _06572_ VGND VGND VPWR VPWR _07321_ sky130_fd_sc_hd__or2b_1
X_11305_ _03525_ _03526_ _03523_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__nand3_1
XFILLER_107_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14024_ _06192_ _06193_ _06287_ VGND VGND VPWR VPWR _06288_ sky130_fd_sc_hd__and3_1
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12285_ _04582_ _01663_ _04579_ _04583_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__o31ai_1
X_11236_ _03534_ _03176_ _03177_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__nand3_1
XFILLER_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11167_ net110 net238 net114 net235 VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__a22o_1
XFILLER_95_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10118_ _02399_ _02416_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__nor2_1
XFILLER_0_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15975_ clknet_leaf_8_clk net372 _00223_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_95_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11098_ _03339_ _03393_ _03396_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__nand3b_1
X_10049_ _02346_ _02347_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nand2_1
X_14926_ _07150_ _07165_ VGND VGND VPWR VPWR _07166_ sky130_fd_sc_hd__or2_1
XFILLER_63_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14857_ _07078_ _06949_ _07093_ VGND VGND VPWR VPWR _07094_ sky130_fd_sc_hd__o21ai_1
XFILLER_63_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13808_ net252 _06049_ VGND VGND VPWR VPWR _06083_ sky130_fd_sc_hd__nor2_2
X_14788_ _06556_ _06562_ VGND VGND VPWR VPWR _07027_ sky130_fd_sc_hd__nand2_1
XFILLER_63_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13739_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _06022_ sky130_fd_sc_hd__and4_1
XFILLER_44_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15409_ _07633_ VGND VGND VPWR VPWR _07634_ sky130_fd_sc_hd__inv_2
X_09901_ _02198_ _02199_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__nand2_1
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09832_ _02129_ _02130_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__nand2_1
X_09763_ net142 net246 VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__nand2_1
X_08714_ _00857_ _01012_ VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__xor2_1
XFILLER_39_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09694_ _01992_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__inv_2
XFILLER_27_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08645_ _00943_ _00750_ VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08576_ _00865_ _00873_ _00874_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__a21boi_1
XFILLER_42_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09128_ _00574_ _01426_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__nand2_1
XFILLER_108_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09059_ _01352_ _01357_ _01353_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_9_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12070_ _03580_ _03584_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__nand2_1
XFILLER_103_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11021_ _03308_ _03312_ _03317_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__nand3_1
XFILLER_106_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15760_ net280 VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__inv_2
XFILLER_64_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12972_ _05266_ _05270_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_86_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14711_ _06759_ _06515_ _06760_ VGND VGND VPWR VPWR _06951_ sky130_fd_sc_hd__nand3_1
X_15691_ net268 VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__inv_2
XFILLER_45_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11923_ _04221_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__inv_2
X_14642_ _06683_ _06516_ _06686_ VGND VGND VPWR VPWR _06882_ sky130_fd_sc_hd__nand3_1
XFILLER_60_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11854_ net112 net222 VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__nand2_1
XFILLER_33_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10805_ net188 net158 VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__nand2_1
XFILLER_32_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14573_ net223 _06802_ _06812_ VGND VGND VPWR VPWR _06813_ sky130_fd_sc_hd__o21ai_1
X_11785_ _04074_ _04083_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__nand2_1
XFILLER_25_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13524_ _05821_ _05822_ VGND VGND VPWR VPWR _05823_ sky130_fd_sc_hd__nand2_1
XFILLER_9_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10736_ _03033_ _03034_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__nand2_1
X_10667_ _02964_ _02962_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__nor2_1
X_13455_ _05379_ _05231_ VGND VGND VPWR VPWR _05754_ sky130_fd_sc_hd__nand2_1
XFILLER_9_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12406_ _04691_ _04703_ _04704_ VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__nand3b_1
X_10598_ _02853_ _02896_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_97_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15125_ _07374_ _07375_ VGND VGND VPWR VPWR _07376_ sky130_fd_sc_hd__nand2_1
X_13386_ _04543_ _05683_ _05684_ VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__o21ai_1
XFILLER_114_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12337_ _04633_ _04635_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__nand2_1
XFILLER_114_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15056_ _07294_ _07302_ _07020_ VGND VGND VPWR VPWR _07303_ sky130_fd_sc_hd__mux2_1
X_12268_ _04565_ _04566_ VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__nand2_1
X_14007_ adder_inst.sum_raw_r\[9\] net252 _06083_ adder_inst.sum_raw_r\[8\] VGND VGND
+ VPWR VPWR _06272_ sky130_fd_sc_hd__a22o_1
X_11219_ _03489_ _03487_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__nand2_1
XFILLER_110_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput90 net90 VGND VGND VPWR VPWR o_res[2] sky130_fd_sc_hd__buf_2
X_12199_ _03664_ _03669_ _04497_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__nand3_1
XFILLER_68_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15958_ clknet_leaf_3_clk net316 _00206_ VGND VGND VPWR VPWR adder_inst.man_a_r\[8\]
+ sky130_fd_sc_hd__dfrtp_4
X_14909_ _07147_ _07042_ VGND VGND VPWR VPWR _07148_ sky130_fd_sc_hd__nand2_1
X_15889_ clknet_leaf_6_clk net22 _00137_ VGND VGND VPWR VPWR adder_inst.exp_a\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08430_ _00563_ _00564_ _00728_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__nand3_1
XFILLER_36_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08361_ _00616_ _00617_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__nand2_1
X_08292_ _00588_ _00589_ _00590_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_34_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout302 net305 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_2
X_09815_ _01951_ _01923_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_70_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09746_ _02041_ _02043_ _02044_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__nand3_1
XFILLER_86_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09677_ _01974_ _01975_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__nand2_1
XFILLER_54_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08628_ _00924_ _00926_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08559_ net136 net232 VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11570_ _03866_ _03868_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__nand2_1
X_10521_ _02818_ _02819_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__nand2_1
XFILLER_50_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13240_ _05523_ _05524_ VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__nand2_1
X_10452_ _02747_ _02750_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__nand2_1
XFILLER_108_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10383_ _02643_ _02681_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__xor2_1
XFILLER_108_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13171_ _05414_ _05467_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__nand2_1
X_12122_ _04366_ _04420_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__nand2_1
XFILLER_2_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12053_ _04039_ _04021_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__nand2_1
XFILLER_104_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11004_ _03300_ _03302_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__nand2_1
XFILLER_77_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15812_ net298 VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__inv_2
XFILLER_65_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15743_ net278 VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__inv_2
X_12955_ _05167_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__inv_2
XFILLER_18_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11906_ _04032_ _04030_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__or2_1
X_15674_ net277 VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__inv_2
XFILLER_93_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12886_ _05183_ _05184_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__nand2_1
XFILLER_33_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14625_ _06447_ _06835_ VGND VGND VPWR VPWR _06865_ sky130_fd_sc_hd__or2_1
X_11837_ net216 VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__inv_2
XFILLER_33_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14556_ _06558_ net151 VGND VGND VPWR VPWR _06796_ sky130_fd_sc_hd__nand2_1
X_11768_ _04065_ _04059_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__nand2_1
X_13507_ _05787_ _05801_ _05805_ VGND VGND VPWR VPWR _05806_ sky130_fd_sc_hd__nand3_1
XFILLER_41_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10719_ _03010_ _03017_ _03013_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_31_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14487_ _06484_ _06526_ _06487_ _06532_ VGND VGND VPWR VPWR _06727_ sky130_fd_sc_hd__o211ai_1
X_11699_ _03822_ _03821_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__nand2_1
X_13438_ _05690_ _05720_ VGND VGND VPWR VPWR _05737_ sky130_fd_sc_hd__nand2_1
X_16157_ clknet_leaf_15_clk _00009_ _00405_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
X_13369_ _05667_ _05659_ _05664_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16088_ clknet_leaf_20_clk multiplier_inst.man_final\[14\] _00336_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[14\] sky130_fd_sc_hd__dfrtp_1
X_15108_ _07357_ VGND VGND VPWR VPWR _07358_ sky130_fd_sc_hd__inv_2
XFILLER_87_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15039_ _07278_ _07284_ VGND VGND VPWR VPWR _07285_ sky130_fd_sc_hd__nand2_1
X_07930_ _07465_ VGND VGND VPWR VPWR _07476_ sky130_fd_sc_hd__inv_2
XFILLER_96_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09600_ net225 net160 VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__nand2_1
XFILLER_68_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09531_ _01670_ _01449_ _01668_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_39_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09462_ _01738_ _01710_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__nor2_1
XFILLER_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09393_ _01691_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__inv_2
X_08413_ _00699_ _00707_ VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08344_ _00641_ _00642_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__nand2_1
XFILLER_20_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08275_ _00573_ VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_119_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout121 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_2
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_4
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_4
Xfanout154 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_4
XFILLER_87_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout143 net145 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__buf_4
Xfanout132 net133 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_4
Xfanout187 net188 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_2
Xfanout176 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_4
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_4
X_09729_ _02027_ _01991_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__nand2_1
XFILLER_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12740_ _05038_ _04926_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__nand2_1
XFILLER_15_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12671_ _00650_ _04134_ _04672_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__o21ai_1
X_14410_ _06648_ _06649_ VGND VGND VPWR VPWR _06650_ sky130_fd_sc_hd__nand2_2
X_15390_ _07615_ _07616_ VGND VGND VPWR VPWR _07618_ sky130_fd_sc_hd__and2_1
X_11622_ _03918_ _03920_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__nand2_1
XFILLER_30_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14341_ _06539_ _06528_ VGND VGND VPWR VPWR _06581_ sky130_fd_sc_hd__nand2_1
X_11553_ _03851_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__inv_2
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10504_ _02801_ _02802_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__nand2_1
X_14272_ _06507_ _06511_ _06512_ VGND VGND VPWR VPWR _06513_ sky130_fd_sc_hd__nand3_1
X_11484_ _03778_ _03781_ _03780_ VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__nand3_1
XFILLER_11_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_16011_ clknet_leaf_10_clk adder_inst.is_nan_a _00259_ VGND VGND VPWR VPWR adder_inst.is_nan_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_10435_ _02733_ _02730_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__nand2_1
X_13223_ _05521_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_94_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13154_ _05451_ _05452_ VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__nor2_1
X_10366_ _02664_ _02556_ VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__nand2_1
XFILLER_97_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12105_ _04400_ _04403_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__nand2_1
X_10297_ _02583_ _02594_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__nand2_1
XFILLER_97_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13085_ _05363_ _05383_ VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__nand2_1
XFILLER_2_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12036_ _04330_ _04333_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__nand2_1
XFILLER_77_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13987_ _06250_ _06251_ _06253_ VGND VGND VPWR VPWR _06254_ sky130_fd_sc_hd__o21ai_1
XFILLER_18_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15726_ net301 VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__inv_2
XFILLER_73_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12938_ _05236_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__inv_2
XFILLER_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15657_ net263 VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_103_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14608_ _06846_ _06847_ VGND VGND VPWR VPWR _06848_ sky130_fd_sc_hd__nand2_1
X_12869_ _05098_ _05099_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15588_ net270 VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__inv_2
X_14539_ _06684_ _06685_ _06487_ VGND VGND VPWR VPWR _06779_ sky130_fd_sc_hd__a21o_1
XFILLER_119_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08060_ net207 net152 VGND VGND VPWR VPWR _07831_ sky130_fd_sc_hd__nand2_1
XFILLER_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08962_ _01124_ _01256_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__nand2_1
X_08893_ _01174_ _01191_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__nand2_1
X_07913_ _07265_ VGND VGND VPWR VPWR _07296_ sky130_fd_sc_hd__inv_2
XFILLER_96_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09514_ _01639_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__inv_2
XFILLER_52_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09445_ _01741_ _01743_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__nand2_1
XFILLER_64_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09376_ _01662_ _01674_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__nor2_1
X_08327_ _00623_ _00624_ _00625_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__o21ai_1
XFILLER_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08258_ _07885_ _00523_ _00525_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__nand3_1
XFILLER_106_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10220_ _02518_ _02507_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__nand2_1
X_08189_ _00481_ _00484_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__nor2_1
X_10151_ _02178_ _02184_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__nand2_1
X_10082_ _02380_ _02377_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__nand2_1
X_13910_ adder_inst.sum_raw_r\[0\] adder_inst.sum_raw_r\[1\] net249 VGND VGND VPWR
+ VPWR _06185_ sky130_fd_sc_hd__mux2_1
XFILLER_59_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14890_ _07108_ _06970_ _07127_ VGND VGND VPWR VPWR _07129_ sky130_fd_sc_hd__o21ai_1
X_13841_ net253 _06100_ _06111_ _06066_ _06115_ VGND VGND VPWR VPWR _06116_ sky130_fd_sc_hd__a221oi_1
XFILLER_74_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13772_ adder_inst.exp_larger_r\[0\] adder_inst.exp_larger_r\[1\] VGND VGND VPWR
+ VPWR _06047_ sky130_fd_sc_hd__nand2_1
X_10984_ net129 net216 VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__nand2_1
X_15511_ add_res\[16\] net386 net259 VGND VGND VPWR VPWR _07715_ sky130_fd_sc_hd__mux2_1
X_12723_ _04671_ _04676_ _04674_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__o21ba_1
XFILLER_70_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15442_ _07662_ _07665_ VGND VGND VPWR VPWR _07666_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_13_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12654_ _04952_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__inv_2
XFILLER_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15373_ _07600_ _07601_ VGND VGND VPWR VPWR _07602_ sky130_fd_sc_hd__nand2_1
X_12585_ _04560_ _04882_ _04816_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_41_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11605_ _03902_ _03903_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__nand2_1
X_14324_ _06564_ _06555_ VGND VGND VPWR VPWR _06565_ sky130_fd_sc_hd__nand2_1
X_11536_ _03834_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__inv_2
X_14255_ net130 net203 _06491_ VGND VGND VPWR VPWR _06496_ sky130_fd_sc_hd__mux2_1
XFILLER_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13206_ _05448_ _05472_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__nand2_1
X_11467_ _03762_ _03759_ _03756_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__nand3_1
X_14186_ _06425_ _06427_ VGND VGND VPWR VPWR _06428_ sky130_fd_sc_hd__nand2_1
X_10418_ _02716_ _02602_ _02703_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__nand3_1
X_11398_ _03696_ VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__inv_2
XFILLER_112_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10349_ _02532_ net154 net247 VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__and3_1
XFILLER_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13137_ _05428_ _05435_ VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__or2_1
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13068_ _05355_ _05347_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__nand2_1
X_12019_ _04290_ _04315_ _04291_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__nand3_1
XFILLER_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15709_ net284 VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__inv_2
XFILLER_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09230_ _01526_ _01522_ _01523_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__nand3_1
X_09161_ net117 net232 VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__nand2_1
XFILLER_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09092_ _01383_ _01390_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__xnor2_1
X_08112_ _07881_ _07879_ VGND VGND VPWR VPWR _07883_ sky130_fd_sc_hd__nand2_1
XFILLER_107_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08043_ _07741_ VGND VGND VPWR VPWR _07814_ sky130_fd_sc_hd__inv_2
X_09994_ _02289_ _02291_ _02292_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__nand3_1
X_08945_ _01133_ _01242_ _01243_ VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__nand3b_1
XFILLER_96_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08876_ net133 net243 VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__nand2_1
XFILLER_57_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09428_ net219 net165 VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__nand2_1
XFILLER_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09359_ _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__inv_2
XFILLER_8_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12370_ _04667_ _04665_ VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_78_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11321_ _01437_ _01435_ _03619_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__a21o_1
XFILLER_4_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14040_ adder_inst.sum_raw_r\[10\] _06204_ adder_inst.sum_raw_r\[9\] _06252_ _06205_
+ VGND VGND VPWR VPWR _06302_ sky130_fd_sc_hd__o221a_1
XFILLER_4_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11252_ _03545_ _03550_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__nand2_1
X_10203_ adder_inst.man_b_r\[8\] net245 VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__nand2_1
X_11183_ _03435_ _03437_ _03481_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__nand3_1
X_10134_ _02142_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__inv_2
XFILLER_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15991_ clknet_leaf_6_clk net330 _00239_ VGND VGND VPWR VPWR adder_inst.man_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_94_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10065_ _02360_ _02363_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__nand2_1
XFILLER_85_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14942_ _06697_ _06692_ VGND VGND VPWR VPWR _07183_ sky130_fd_sc_hd__nand2_1
XFILLER_48_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14873_ _07110_ _07042_ VGND VGND VPWR VPWR _07111_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_89_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13824_ adder_inst.exp_larger_r\[2\] adder_inst.exp_larger_r\[3\] VGND VGND VPWR
+ VPWR _06099_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_89_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13755_ _06031_ _06032_ VGND VGND VPWR VPWR _06033_ sky130_fd_sc_hd__nand2_1
XFILLER_90_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10967_ _03265_ _03257_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__nand2_1
X_13686_ _05976_ _05977_ VGND VGND VPWR VPWR _05978_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_100_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10898_ net135 net205 VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12706_ _05004_ VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__inv_2
X_15425_ _07648_ _07649_ VGND VGND VPWR VPWR _07650_ sky130_fd_sc_hd__nand2_1
X_12637_ _04700_ _04697_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__nand2_1
XFILLER_31_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15356_ _07582_ _07583_ VGND VGND VPWR VPWR _07584_ sky130_fd_sc_hd__xor2_1
X_12568_ _04864_ _04865_ _04866_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__a21bo_1
XFILLER_116_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14307_ _06546_ _06547_ VGND VGND VPWR VPWR _06548_ sky130_fd_sc_hd__nand2_1
X_15287_ _07491_ multiplier_inst.man_final_r\[20\] _07493_ VGND VGND VPWR VPWR _07521_
+ sky130_fd_sc_hd__and3_1
X_12499_ _04796_ _04792_ _04793_ VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__nand3b_1
X_11519_ _03012_ _03182_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__nor2_1
XFILLER_116_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14238_ _03955_ _00589_ _06448_ VGND VGND VPWR VPWR _06479_ sky130_fd_sc_hd__mux2_1
XFILLER_112_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14169_ _05950_ _05975_ VGND VGND VPWR VPWR _06411_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_111_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08730_ _00993_ _00994_ _00991_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__a21oi_1
XFILLER_39_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08661_ _00953_ _00956_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__nor2_1
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08592_ _00887_ _00890_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__nand2_1
XFILLER_81_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09213_ _01499_ _01511_ VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__nand2_1
XFILLER_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09144_ _01441_ _01438_ VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__nand2_1
X_09075_ _07888_ _01371_ VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__nand2_1
XFILLER_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08026_ _07789_ _07796_ VGND VGND VPWR VPWR _07797_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09977_ _02274_ _02098_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__nand2_1
XFILLER_57_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08928_ net204 net176 VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__nand2_1
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08859_ _01003_ _01006_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__nand2_1
XFILLER_84_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11870_ _04167_ _04168_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__nand2_1
XFILLER_53_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10821_ _07190_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__inv_2
XFILLER_25_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13540_ _05651_ VGND VGND VPWR VPWR _05839_ sky130_fd_sc_hd__inv_2
X_10752_ net194 net155 VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__nand2_1
XFILLER_13_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13471_ _05768_ _05769_ VGND VGND VPWR VPWR _05770_ sky130_fd_sc_hd__nand2_1
XFILLER_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10683_ _02981_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__inv_2
X_15210_ _07462_ _07464_ VGND VGND VPWR VPWR _07466_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_23_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12422_ _04719_ _04720_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15141_ _07392_ _07178_ VGND VGND VPWR VPWR _07393_ sky130_fd_sc_hd__nand2_1
X_12353_ _03954_ _04651_ _04225_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__or3_1
X_15072_ _06593_ VGND VGND VPWR VPWR _07320_ sky130_fd_sc_hd__inv_2
X_11304_ _03419_ _03522_ _03428_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__nand3_1
X_12284_ _04239_ _01663_ _04561_ VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__o21ai_1
XFILLER_113_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14023_ _06184_ _06283_ _06286_ VGND VGND VPWR VPWR _06287_ sky130_fd_sc_hd__o21ai_1
XFILLER_4_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11235_ _03394_ _03533_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__nand2_1
XFILLER_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11166_ _03462_ _03464_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__nand2_1
X_15974_ clknet_leaf_11_clk _00035_ _00222_ VGND VGND VPWR VPWR adder_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_1
X_10117_ _02414_ _02415_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__nand2_1
X_11097_ _03395_ _03389_ _03390_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__nand3_1
XFILLER_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10048_ _02103_ _01921_ _01919_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__nand3_1
X_14925_ _07131_ _07162_ _07164_ VGND VGND VPWR VPWR _07165_ sky130_fd_sc_hd__a21o_1
Xhold90 add_res\[2\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14856_ _06942_ _06945_ VGND VGND VPWR VPWR _07093_ sky130_fd_sc_hd__or2_1
XFILLER_63_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13807_ adder_inst.sum_raw_r\[19\] _06055_ _06081_ VGND VGND VPWR VPWR _06082_ sky130_fd_sc_hd__o21bai_1
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14787_ _07025_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07026_ sky130_fd_sc_hd__nand2_1
XFILLER_63_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13738_ adder_inst.exp_b\[3\] adder_inst.exp_b\[2\] VGND VGND VPWR VPWR _06021_ sky130_fd_sc_hd__nand2_1
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11999_ _04297_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__inv_2
X_13669_ _05961_ VGND VGND VPWR VPWR _05962_ sky130_fd_sc_hd__inv_2
X_15408_ _05786_ _07630_ VGND VGND VPWR VPWR _07633_ sky130_fd_sc_hd__nor2_1
X_15339_ _02957_ _02888_ _07564_ VGND VGND VPWR VPWR _07565_ sky130_fd_sc_hd__a21o_1
XFILLER_8_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09900_ _02197_ _02192_ _02195_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__nand3b_1
XFILLER_116_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09831_ _01957_ _01963_ _02022_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__nand3_1
X_09762_ _02060_ _01980_ VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__or2_1
X_08713_ _00862_ _00859_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__nand2_1
X_09693_ _01991_ _01990_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__nand2_1
XFILLER_54_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08644_ net201 net170 VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__nand2_1
XFILLER_81_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08575_ _00855_ _00863_ _00690_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_1_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09127_ _01425_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__inv_2
XFILLER_108_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09058_ _01355_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__inv_2
X_08009_ _07774_ _07772_ _07775_ VGND VGND VPWR VPWR _07780_ sky130_fd_sc_hd__nand3_1
XFILLER_116_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11020_ _03308_ _03318_ VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__nand2b_1
XFILLER_49_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12971_ _05267_ _05269_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__nand2_1
X_14710_ _06933_ _06949_ VGND VGND VPWR VPWR _06950_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_86_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15690_ net268 VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__inv_2
XFILLER_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11922_ _04219_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14641_ _06878_ _06880_ VGND VGND VPWR VPWR _06881_ sky130_fd_sc_hd__nand2_2
XFILLER_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11853_ _00649_ _03261_ _03926_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__or3_1
X_10804_ _03043_ _03102_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__nand2_1
XFILLER_32_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14572_ _06811_ _06802_ VGND VGND VPWR VPWR _06812_ sky130_fd_sc_hd__nand2_1
X_11784_ _04081_ _04082_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__nand2_1
X_13523_ _05690_ _05810_ VGND VGND VPWR VPWR _05822_ sky130_fd_sc_hd__nand2_1
XFILLER_40_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10735_ net197 net149 VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__nand2_1
XFILLER_13_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10666_ _02962_ _02964_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__nand2_1
X_13454_ _05744_ _05224_ _05233_ VGND VGND VPWR VPWR _05753_ sky130_fd_sc_hd__nand3_1
XFILLER_40_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13385_ _05672_ _04057_ VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__nand2_1
X_12405_ _04701_ _04693_ _04694_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__nand3_1
X_10597_ _02854_ _02894_ _02895_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_97_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15124_ _07372_ _06609_ _07367_ VGND VGND VPWR VPWR _07375_ sky130_fd_sc_hd__nand3_1
X_12336_ _04634_ _04623_ _04624_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__nand3_1
X_15055_ _07293_ _07301_ VGND VGND VPWR VPWR _07302_ sky130_fd_sc_hd__xor2_1
XFILLER_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12267_ _04564_ _04559_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__nand2_1
X_14006_ adder_inst.sum_raw_r\[7\] _06052_ adder_inst.sum_raw_r\[6\] _06114_ _06155_
+ VGND VGND VPWR VPWR _06271_ sky130_fd_sc_hd__o221a_1
XFILLER_68_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11218_ _03504_ _03512_ _03516_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__a21oi_1
X_12198_ _03692_ _04496_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__nand2_1
Xoutput91 net91 VGND VGND VPWR VPWR o_res[30] sky130_fd_sc_hd__buf_2
Xoutput80 net80 VGND VGND VPWR VPWR o_res[20] sky130_fd_sc_hd__buf_2
X_11149_ _03444_ _03447_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__nand2_1
XFILLER_110_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15957_ clknet_leaf_5_clk net324 _00205_ VGND VGND VPWR VPWR adder_inst.man_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15888_ clknet_leaf_6_clk net21 _00136_ VGND VGND VPWR VPWR adder_inst.exp_a\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_14908_ _06818_ _07146_ VGND VGND VPWR VPWR _07147_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14839_ _07071_ _07074_ _07021_ VGND VGND VPWR VPWR _07075_ sky130_fd_sc_hd__mux2_1
XFILLER_91_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08360_ _00616_ _00617_ _00658_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__nand3_1
XFILLER_36_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08291_ net126 net234 VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__nand2_1
XFILLER_31_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout303 net305 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_4
XFILLER_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09814_ _02106_ _02111_ _02112_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_70_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09745_ _02039_ _01930_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__nand2_1
X_09676_ _01831_ _01973_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__nand2_1
XFILLER_54_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08627_ _00925_ _00795_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08558_ net133 net235 VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__nand2_1
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08489_ _00784_ _00505_ _00781_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__nand3_1
X_10520_ net159 net247 VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__nand2_1
XFILLER_10_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10451_ _02748_ _02749_ _02740_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__a21boi_1
XFILLER_108_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10382_ _02520_ _02680_ _02641_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13170_ _05468_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__inv_2
XFILLER_108_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12121_ _04417_ _04419_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__nand2_1
XFILLER_111_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12052_ _04049_ _04042_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__nand2_1
XFILLER_104_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11003_ _03301_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__inv_2
XFILLER_89_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15811_ net298 VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__inv_2
XFILLER_77_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15742_ net291 VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__inv_2
X_12954_ _05174_ _05175_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__nand2_1
XFILLER_18_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11905_ _04201_ _04203_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__nand2_1
X_15673_ net271 VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__inv_2
XFILLER_73_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12885_ _05115_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__inv_2
X_14624_ _06839_ _06447_ VGND VGND VPWR VPWR _06864_ sky130_fd_sc_hd__nand2_1
XFILLER_14_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11836_ _01042_ _04134_ _03912_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__or3_1
X_14555_ _06793_ _06794_ _06521_ VGND VGND VPWR VPWR _06795_ sky130_fd_sc_hd__nand3_1
X_11767_ _04059_ _04065_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__or2_1
XFILLER_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13506_ _05804_ VGND VGND VPWR VPWR _05805_ sky130_fd_sc_hd__inv_2
XFILLER_41_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10718_ _03015_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_31_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14486_ _06699_ _06725_ VGND VGND VPWR VPWR _06726_ sky130_fd_sc_hd__nor2_1
X_11698_ _03995_ _03996_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__nand2_1
X_10649_ _02917_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__inv_2
X_13437_ _05732_ _05735_ VGND VGND VPWR VPWR _05736_ sky130_fd_sc_hd__nor2_1
X_16156_ clknet_leaf_14_clk _00008_ _00404_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
X_13368_ _05666_ _05641_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_11_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16087_ clknet_leaf_20_clk multiplier_inst.man_final\[13\] _00335_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[13\] sky130_fd_sc_hd__dfrtp_1
X_15107_ _07321_ _07320_ _07356_ VGND VGND VPWR VPWR _07357_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12319_ _00622_ _04241_ _04617_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__or3_1
XFILLER_102_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15038_ _07283_ _07178_ VGND VGND VPWR VPWR _07284_ sky130_fd_sc_hd__nand2_1
X_13299_ net180 net108 net178 net111 VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__a22o_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09530_ _01828_ net136 net242 VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__nand3b_1
XFILLER_83_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09461_ _01758_ _01759_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__nand2_1
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09392_ _01688_ _01690_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__nor2_1
X_08412_ _00709_ _00644_ _00710_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_19_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08343_ _00639_ _00629_ _00628_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__nand3_1
X_08274_ net129 net226 VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_119_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout122 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_4
Xfanout111 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout133 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_4
Xfanout144 net145 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__clkbuf_2
Xfanout155 net157 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_4
Xfanout166 adder_inst.man_b_r\[3\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout199 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_2
Xfanout188 adder_inst.man_a_r\[20\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_4
Xfanout177 net179 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09728_ _02025_ _02026_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__nand2_1
XFILLER_47_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07989_ _07758_ _07759_ VGND VGND VPWR VPWR _07760_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09659_ _01951_ _01948_ _01923_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__nand3_1
XFILLER_42_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12670_ net107 net216 VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__nand2_1
XFILLER_70_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11621_ _03919_ _03915_ _03916_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__nand3_1
X_14340_ _06529_ _06539_ _06579_ VGND VGND VPWR VPWR _06580_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11552_ _03393_ _03339_ _03396_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__a21boi_2
X_10503_ _02749_ _02740_ _02748_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__nand3_1
X_14271_ _06461_ VGND VGND VPWR VPWR _06512_ sky130_fd_sc_hd__clkbuf_4
X_11483_ _03778_ _03780_ _03781_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__a21o_1
X_16010_ clknet_leaf_13_clk net309 _00258_ VGND VGND VPWR VPWR adder_inst.i_vld_r2
+ sky130_fd_sc_hd__dfrtp_1
X_10434_ _02732_ net168 net240 VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__nand3b_2
X_13222_ _05426_ _05423_ VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__nand2_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10365_ _02663_ _02542_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__nand2_1
XFILLER_109_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13153_ _05401_ _05404_ VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__nor2b_1
X_12104_ _04401_ _04402_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__nand2_1
X_10296_ _02583_ _02591_ _02594_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__nand3_1
XFILLER_97_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13084_ _05369_ _05374_ _05382_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__a21oi_1
XFILLER_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12035_ _04222_ _04330_ _04333_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__nand3_1
XFILLER_78_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13986_ adder_inst.sum_raw_r\[5\] _06052_ adder_inst.sum_raw_r\[4\] _06252_ _06155_
+ VGND VGND VPWR VPWR _06253_ sky130_fd_sc_hd__o221a_1
XFILLER_18_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15725_ net301 VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__inv_2
XFILLER_80_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12937_ _04311_ _04304_ _04301_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__o21ai_1
X_15656_ net262 VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__inv_2
X_12868_ _05165_ _05166_ VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__nand2_1
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14607_ _06585_ _06474_ _06547_ VGND VGND VPWR VPWR _06847_ sky130_fd_sc_hd__nand3_1
X_11819_ _04116_ _04117_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15587_ net269 VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12799_ _05094_ _05097_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__nand2_1
XFILLER_21_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14538_ _06461_ _06598_ VGND VGND VPWR VPWR _06778_ sky130_fd_sc_hd__or2_1
X_14469_ _06496_ _06482_ _06708_ VGND VGND VPWR VPWR _06709_ sky130_fd_sc_hd__o21ai_1
XFILLER_115_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16139_ clknet_leaf_19_clk _00000_ _00387_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
XFILLER_5_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08961_ _01147_ _01123_ _01014_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__nand3_1
XFILLER_68_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08892_ _01190_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__inv_2
X_07912_ _07180_ _07190_ _07233_ VGND VGND VPWR VPWR _07286_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_3_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09513_ _01811_ _01639_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__nand2_1
XFILLER_52_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09444_ _01742_ _01592_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09375_ _01666_ _01673_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__or2_1
XFILLER_33_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08326_ net121 net235 VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__nand2_1
XFILLER_20_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08257_ _00524_ _00527_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__nand2_1
X_08188_ _00481_ _00484_ _00486_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__o21ai_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10150_ _02447_ _02448_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__nand2_1
X_10081_ _02377_ _02378_ _02379_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__nand3_1
XFILLER_58_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13840_ _06099_ _06114_ VGND VGND VPWR VPWR _06115_ sky130_fd_sc_hd__nor2_1
X_13771_ _06045_ VGND VGND VPWR VPWR _06046_ sky130_fd_sc_hd__inv_2
XFILLER_74_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10983_ _03262_ _03281_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15510_ _07713_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12722_ _05019_ _05020_ VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__nand2_1
X_15441_ _07647_ _07664_ VGND VGND VPWR VPWR _07665_ sky130_fd_sc_hd__nand2_1
XFILLER_31_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12653_ _04949_ _04951_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__nor2_1
XFILLER_30_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15372_ _07596_ _05732_ VGND VGND VPWR VPWR _07601_ sky130_fd_sc_hd__nand2_1
X_12584_ _04560_ _04882_ _04816_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_41_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11604_ _03900_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__inv_2
X_14323_ _06549_ _06563_ VGND VGND VPWR VPWR _06564_ sky130_fd_sc_hd__nand2_1
X_11535_ _03832_ _03833_ VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__nand2_1
XFILLER_11_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14254_ _06482_ _06492_ _06494_ VGND VGND VPWR VPWR _06495_ sky130_fd_sc_hd__a21o_1
XFILLER_11_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13205_ _05503_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__inv_2
XFILLER_7_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11466_ _03761_ _03701_ VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__nand2_1
X_14185_ _05951_ _06426_ VGND VGND VPWR VPWR _06427_ sky130_fd_sc_hd__xor2_1
X_10417_ _02715_ _02700_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__nand2_1
X_11397_ _03695_ _03686_ VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__nand2_1
X_10348_ _02645_ _02536_ _02638_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__nand3b_1
X_13136_ _05433_ _05434_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__nand2_1
X_10279_ _02567_ _02568_ _02577_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_76_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13067_ _05360_ _05365_ VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__nand2_1
X_12018_ _04292_ _04316_ VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__nand2_1
XFILLER_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13969_ _06221_ _06200_ _06236_ _06205_ _06237_ VGND VGND VPWR VPWR _06238_ sky130_fd_sc_hd__a221o_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15708_ net281 VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__inv_2
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15639_ net269 VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__inv_2
XFILLER_21_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09160_ _00625_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__inv_2
XFILLER_9_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09091_ _01386_ _01389_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__nand2_1
X_08111_ _07871_ _07879_ _07881_ VGND VGND VPWR VPWR _07882_ sky130_fd_sc_hd__nand3b_1
XFILLER_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08042_ _07702_ _07714_ VGND VGND VPWR VPWR _07813_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_116_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09993_ _02286_ _02270_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__nand2_1
XFILLER_88_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08944_ _01135_ _00981_ _01143_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__nand3_1
XFILLER_111_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08875_ _01173_ _01074_ VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__nand2_1
XFILLER_56_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09427_ _01720_ _01725_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__nand2_1
XFILLER_40_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09358_ _01655_ _01635_ _01656_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__a21oi_2
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08309_ net126 net235 VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__nand2_1
X_09289_ _01586_ _01587_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__nand2_1
XFILLER_20_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11320_ _01432_ _01436_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__nor2_1
XFILLER_114_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11251_ _03548_ _03549_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__nand2_1
X_10202_ _02499_ _02500_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__nand2_1
X_11182_ _03480_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__inv_2
X_10133_ _02146_ _02431_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__nand2_1
XFILLER_69_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15990_ clknet_leaf_5_clk net332 _00238_ VGND VGND VPWR VPWR adder_inst.man_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_10064_ _02362_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__inv_2
X_14941_ _07165_ _06699_ VGND VGND VPWR VPWR _07182_ sky130_fd_sc_hd__nand2_1
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14872_ _06969_ _07109_ VGND VGND VPWR VPWR _07110_ sky130_fd_sc_hd__xor2_1
XFILLER_75_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13823_ _06096_ _06097_ _06078_ VGND VGND VPWR VPWR _06098_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_89_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13754_ _05655_ _05850_ VGND VGND VPWR VPWR _06032_ sky130_fd_sc_hd__nor2_1
XFILLER_71_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10966_ _03260_ _03263_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__nand2_1
X_13685_ _05956_ _05953_ VGND VGND VPWR VPWR _05977_ sky130_fd_sc_hd__nand2_1
XFILLER_71_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10897_ _03195_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__inv_2
XFILLER_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12705_ _05003_ _05002_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15424_ _07642_ _05804_ VGND VGND VPWR VPWR _07649_ sky130_fd_sc_hd__nand2_1
X_12636_ _04934_ _04710_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__nand2_1
X_15355_ _07559_ _02787_ _02633_ VGND VGND VPWR VPWR _07583_ sky130_fd_sc_hd__a21bo_1
X_14306_ _06519_ VGND VGND VPWR VPWR _06547_ sky130_fd_sc_hd__buf_2
X_12567_ _04828_ _04831_ _04833_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__o21ba_1
XFILLER_7_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15286_ _07520_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__clkbuf_1
X_12498_ _04794_ _04796_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__nand2_1
X_11518_ _03181_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__inv_2
X_14237_ _06475_ _06454_ _06477_ VGND VGND VPWR VPWR _06478_ sky130_fd_sc_hd__o21ai_1
X_11449_ net112 net227 VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__nand2_1
X_14168_ _06403_ _06404_ _06409_ _06401_ VGND VGND VPWR VPWR _06410_ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_84_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13119_ _05417_ _04874_ VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__or2_1
XFILLER_3_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14099_ adder_inst.sum_raw_r\[14\] net255 VGND VGND VPWR VPWR _06355_ sky130_fd_sc_hd__nand2_1
XFILLER_112_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08660_ _00953_ _00956_ _00958_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__o21ai_1
XFILLER_54_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08591_ _00889_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_62_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09212_ _01510_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__inv_2
XFILLER_22_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09143_ _01421_ _01438_ _01441_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__nand3_1
XFILLER_108_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09074_ _01370_ _01372_ VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__nand2_1
X_08025_ _07791_ _07793_ _07795_ VGND VGND VPWR VPWR _07796_ sky130_fd_sc_hd__a21o_1
XFILLER_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09976_ _02272_ _02098_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__nand3b_1
XFILLER_76_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08927_ _01225_ VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__inv_2
XFILLER_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08858_ _01156_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__inv_2
XFILLER_84_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08789_ _00840_ _00842_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__nand2_1
XFILLER_60_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10820_ net177 net169 VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__nand2_1
XFILLER_53_693 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10751_ net197 net152 VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__nand2_1
XFILLER_13_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13470_ _05646_ _05647_ _05764_ VGND VGND VPWR VPWR _05769_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_23_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10682_ _02980_ _02429_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__nand2_1
XFILLER_40_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12421_ _04711_ VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_51_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15140_ _07386_ _07390_ VGND VGND VPWR VPWR _07392_ sky130_fd_sc_hd__xor2_1
X_12352_ net140 VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__inv_2
X_15071_ _07304_ _07319_ VGND VGND VPWR VPWR adder_inst.sum_raw\[16\] sky130_fd_sc_hd__nand2_1
X_11303_ _03601_ _03528_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__nand2_1
X_12283_ net186 VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__inv_2
XFILLER_113_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14022_ _06194_ _06284_ _06285_ _06195_ VGND VGND VPWR VPWR _06286_ sky130_fd_sc_hd__o22a_1
X_11234_ _03086_ _03084_ _03087_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__nand3_1
XFILLER_106_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11165_ _03463_ _03317_ _03455_ VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__nand3_1
X_15973_ clknet_leaf_8_clk adder_inst.man_a\[23\] _00221_ VGND VGND VPWR VPWR adder_inst.man_a_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_10116_ _02406_ _02410_ _02412_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__nand3_1
XFILLER_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11096_ _03394_ _03059_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__nand2_1
X_10047_ _02102_ _01907_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__nand2_1
X_14924_ _06813_ _06815_ _07163_ VGND VGND VPWR VPWR _07164_ sky130_fd_sc_hd__o21ai_1
XFILLER_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold91 add_ovf VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 _07715_ VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14855_ _07091_ multiplier_inst.sign_res VGND VGND VPWR VPWR _07092_ sky130_fd_sc_hd__nand2_1
XFILLER_90_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13806_ _06051_ _06043_ VGND VGND VPWR VPWR _06081_ sky130_fd_sc_hd__nand2_1
XFILLER_90_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14786_ _07023_ _07024_ _07021_ VGND VGND VPWR VPWR _07025_ sky130_fd_sc_hd__mux2_1
XFILLER_51_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11998_ net115 net216 VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__nand2_1
X_13737_ _06019_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r _06020_ VGND VGND VPWR
+ VPWR _00034_ sky130_fd_sc_hd__a31o_1
XFILLER_50_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10949_ _03246_ _03243_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__nand2_1
XFILLER_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13668_ _05681_ _05960_ VGND VGND VPWR VPWR _05961_ sky130_fd_sc_hd__nand2_1
X_15407_ _07632_ VGND VGND VPWR VPWR multiplier_inst.man_final\[7\] sky130_fd_sc_hd__clkbuf_1
X_13599_ _05892_ _05894_ _05886_ VGND VGND VPWR VPWR _05895_ sky130_fd_sc_hd__a21o_1
X_12619_ _04914_ _04916_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__nand2_1
XFILLER_117_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15338_ _02912_ _02940_ VGND VGND VPWR VPWR _07564_ sky130_fd_sc_hd__nand2_1
XFILLER_8_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15269_ _07507_ multiplier_inst.man_final_r\[11\] _07508_ VGND VGND VPWR VPWR _07510_
+ sky130_fd_sc_hd__and3_1
XFILLER_112_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09830_ _02020_ _01998_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__nand2_1
X_09761_ net145 net242 VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__nand2_1
XFILLER_112_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08712_ _01008_ _00996_ _00998_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__nand3_1
XFILLER_94_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09692_ _01976_ _01989_ _01990_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__nand3_1
XFILLER_81_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08643_ _00941_ _00749_ VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__nand2_1
XFILLER_26_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08574_ _00872_ _00870_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09126_ net126 net225 VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__nand2_1
XFILLER_108_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09057_ _01354_ _01355_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__nand2_1
X_08008_ _07762_ _07764_ _07771_ VGND VGND VPWR VPWR _07779_ sky130_fd_sc_hd__nand3_1
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09959_ net159 net230 VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__nand2_1
XFILLER_89_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12970_ _05268_ _05251_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_86_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11921_ _04218_ _04213_ _04215_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_28_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14640_ _06879_ _06873_ VGND VGND VPWR VPWR _06880_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_56_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11852_ _04150_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__inv_2
XFILLER_72_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14571_ _06803_ _06810_ _06521_ VGND VGND VPWR VPWR _06811_ sky130_fd_sc_hd__nand3_1
XFILLER_60_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10803_ net181 net164 VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__nand2_1
XFILLER_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13522_ _05681_ _05820_ VGND VGND VPWR VPWR _05821_ sky130_fd_sc_hd__nand2_1
X_11783_ _04080_ _04075_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__nand2_1
X_10734_ _03031_ _03032_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__nand2_1
X_10665_ _02963_ _02957_ _02888_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__nand3_1
X_13453_ _05751_ VGND VGND VPWR VPWR _05752_ sky130_fd_sc_hd__inv_4
XFILLER_41_696 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13384_ _04542_ _03879_ VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__and2_1
X_12404_ _04695_ _04702_ VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__nand2_1
X_10596_ _02849_ _02845_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_97_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15123_ _07373_ _06626_ VGND VGND VPWR VPWR _07374_ sky130_fd_sc_hd__nand2_1
X_12335_ _04632_ _04627_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__nand2_1
XFILLER_31_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15054_ _07295_ _07300_ VGND VGND VPWR VPWR _07301_ sky130_fd_sc_hd__nand2_2
XFILLER_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12266_ _04559_ _04564_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__or2_1
X_14005_ _06056_ adder_inst.sum_raw_r\[3\] _06055_ adder_inst.sum_raw_r\[4\] _06269_
+ VGND VGND VPWR VPWR _06270_ sky130_fd_sc_hd__a221o_1
Xoutput70 net70 VGND VGND VPWR VPWR o_res[11] sky130_fd_sc_hd__buf_2
X_11217_ _03499_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__inv_2
X_12197_ _03675_ _03677_ _03680_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__nand3_1
Xoutput92 net92 VGND VGND VPWR VPWR o_res[31] sky130_fd_sc_hd__buf_2
Xoutput81 net81 VGND VGND VPWR VPWR o_res[21] sky130_fd_sc_hd__buf_2
XFILLER_95_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11148_ _03446_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__inv_2
X_15956_ clknet_leaf_3_clk net314 _00204_ VGND VGND VPWR VPWR adder_inst.man_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_76_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11079_ _03377_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__inv_2
X_15887_ clknet_leaf_6_clk net20 _00135_ VGND VGND VPWR VPWR adder_inst.exp_a\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_14907_ _07131_ _07003_ _07145_ VGND VGND VPWR VPWR _07146_ sky130_fd_sc_hd__a21oi_1
X_14838_ _06948_ _07073_ VGND VGND VPWR VPWR _07074_ sky130_fd_sc_hd__xor2_1
XFILLER_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14769_ _06572_ _06570_ VGND VGND VPWR VPWR _07009_ sky130_fd_sc_hd__or2_1
XFILLER_32_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08290_ net229 VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__inv_2
XFILLER_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout304 net305 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09813_ _02105_ _02101_ VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_70_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09744_ _02042_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__inv_2
X_09675_ _01973_ _01831_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__or2_1
XFILLER_39_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08626_ _00795_ _00770_ _00792_ VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_53_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08557_ _00855_ _00690_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__nand2_1
XFILLER_42_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08488_ _00779_ _00785_ _00786_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__nand3b_1
XFILLER_10_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10450_ _02737_ _02730_ _02733_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__nand3_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09109_ _01398_ _01399_ _01401_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__nand3_1
X_10381_ net165 net239 VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__nand2_1
X_12120_ _04418_ _04400_ _04403_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__nand3_1
XFILLER_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12051_ _04346_ _04349_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__nand2_1
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11002_ net117 net227 VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__nand2_1
X_15810_ net299 VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__inv_2
X_15741_ net290 VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__inv_2
XFILLER_92_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12953_ _05250_ _05251_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__nor2b_1
X_15672_ net277 VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__inv_2
XFILLER_73_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11904_ _04020_ _04036_ _04202_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__a21oi_1
XFILLER_60_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14623_ _06862_ _06488_ VGND VGND VPWR VPWR _06863_ sky130_fd_sc_hd__nand2_1
X_12884_ _05112_ _05113_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_25_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
X_11835_ net213 VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__inv_2
XFILLER_26_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14554_ _06514_ _06700_ VGND VGND VPWR VPWR _06794_ sky130_fd_sc_hd__nand2b_1
X_11766_ _04063_ _04064_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__nand2_1
XFILLER_14_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14485_ _06722_ _06724_ VGND VGND VPWR VPWR _06725_ sky130_fd_sc_hd__nand2_2
X_13505_ _05802_ _05803_ VGND VGND VPWR VPWR _05804_ sky130_fd_sc_hd__nand2_1
XFILLER_9_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10717_ _03010_ _03014_ _03015_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__o21ai_1
X_13436_ _05733_ _05734_ VGND VGND VPWR VPWR _05735_ sky130_fd_sc_hd__nand2_1
XFILLER_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11697_ _03993_ _03990_ _03991_ VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__nand3_1
X_10648_ _02945_ _02946_ _02935_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__nand3b_1
X_10579_ _02877_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__inv_2
X_16155_ clknet_leaf_15_clk _00007_ _00403_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
XFILLER_61_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13367_ _05640_ _05633_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_11_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15106_ _06588_ _06590_ VGND VGND VPWR VPWR _07356_ sky130_fd_sc_hd__nand2_1
X_16086_ clknet_leaf_21_clk multiplier_inst.man_final\[12\] _00334_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[12\] sky130_fd_sc_hd__dfrtp_1
X_13298_ net108 net179 VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__nand2_1
X_12318_ net119 net196 VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__nand2_1
X_15037_ _07281_ _07282_ VGND VGND VPWR VPWR _07283_ sky130_fd_sc_hd__nand2_1
X_12249_ _04545_ _04547_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__nand2_1
XFILLER_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15939_ clknet_leaf_17_clk adder_inst.sum_raw\[14\] _00187_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[14\]
+ sky130_fd_sc_hd__dfrtp_4
X_09460_ _01757_ _01746_ _01748_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__nand3b_1
X_08411_ _00698_ _00707_ VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__nand2_1
XFILLER_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_16_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
X_09391_ _01689_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08342_ _00630_ _00640_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__nand2_1
X_08273_ _00571_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_119_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout112 net114 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout156 net157 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_4
Xfanout145 adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_4
Xfanout134 net136 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_4
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_4
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net179 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_4
Xfanout189 net191 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
X_07988_ _07757_ _07748_ VGND VGND VPWR VPWR _07759_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09727_ _01976_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__inv_2
XFILLER_47_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09658_ _01952_ _01956_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__nand2_1
X_09589_ _01887_ _01886_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__nand2_1
XFILLER_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08609_ _00906_ _00907_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__nand2_1
XFILLER_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11620_ _03734_ _03738_ _03732_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__a21o_1
X_11551_ _03846_ _03849_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__nand2_1
X_10502_ _02800_ _02727_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__nand2_1
XFILLER_109_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14270_ _06454_ _06508_ _06446_ _06510_ VGND VGND VPWR VPWR _06511_ sky130_fd_sc_hd__a211o_1
X_11482_ _03129_ _03234_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__nor2_1
X_10433_ _02730_ _02731_ VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__nand2_1
X_13221_ _05518_ _05519_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__nand2_1
XFILLER_12_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10364_ _02554_ _02555_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_94_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13152_ _05449_ _05450_ VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__nand2_1
X_12103_ _04399_ _04396_ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__nand2_1
X_10295_ _02592_ _02593_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__nand2_1
X_13083_ _05380_ _05381_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__nand2_1
XFILLER_2_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12034_ _04331_ _04332_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__nand2_1
XFILLER_93_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13985_ _06114_ VGND VGND VPWR VPWR _06252_ sky130_fd_sc_hd__buf_2
XFILLER_65_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15724_ net300 VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__inv_2
XFILLER_33_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12936_ _04342_ _04337_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__and2_1
XFILLER_37_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15655_ net263 VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__inv_2
X_12867_ _05155_ _05156_ _05163_ VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__nand3_1
X_15586_ net272 VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_103_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14606_ _06844_ _06521_ _06845_ VGND VGND VPWR VPWR _06846_ sky130_fd_sc_hd__nand3_1
X_11818_ _04115_ _04111_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_16_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14537_ _06769_ _06776_ VGND VGND VPWR VPWR _06777_ sky130_fd_sc_hd__nand2_4
X_12798_ _05096_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__inv_2
XFILLER_119_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11749_ _04046_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__inv_2
XFILLER_119_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14468_ _06453_ _06524_ VGND VGND VPWR VPWR _06708_ sky130_fd_sc_hd__nand2_1
X_14399_ _06636_ _06638_ VGND VGND VPWR VPWR _06639_ sky130_fd_sc_hd__nand2_2
X_13419_ _05712_ _05717_ VGND VGND VPWR VPWR _05718_ sky130_fd_sc_hd__nand2_1
X_16138_ clknet_leaf_11_clk _00096_ _00386_ VGND VGND VPWR VPWR mul_res\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_5_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_16069_ clknet_leaf_11_clk adder_inst.is_zero_b _00317_ VGND VGND VPWR VPWR adder_inst.is_zero_b_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_114_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08960_ _01257_ _01148_ _01258_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__nand3_1
X_08891_ _01185_ _01189_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__nand2_1
X_07911_ _07254_ _07265_ VGND VGND VPWR VPWR _07275_ sky130_fd_sc_hd__nand2_1
XFILLER_68_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09512_ _01810_ _01607_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__nand2_1
XFILLER_56_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09443_ _01594_ _01740_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__nor2_1
XFILLER_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09374_ _01667_ _01672_ _01669_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_65_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08325_ net240 VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_104_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08256_ _00526_ _00528_ _00554_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__nand3_1
X_08187_ _00485_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__inv_2
X_10080_ _02250_ _02237_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__nand2_1
XFILLER_58_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13770_ adder_inst.exp_larger_r\[0\] adder_inst.exp_larger_r\[1\] VGND VGND VPWR
+ VPWR _06045_ sky130_fd_sc_hd__nor2_1
XFILLER_90_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10982_ net125 net216 VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__nand2_1
XFILLER_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12721_ _05018_ _05010_ _04955_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__nand3b_1
XFILLER_82_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15440_ _05772_ VGND VGND VPWR VPWR _07664_ sky130_fd_sc_hd__clkinvlp_2
X_12652_ _04950_ _04650_ VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__nand2_1
XFILLER_90_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11603_ _03898_ _03899_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__nand2_1
X_15371_ _05732_ _07596_ VGND VGND VPWR VPWR _07600_ sky130_fd_sc_hd__or2_1
X_12583_ net120 VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_41_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14322_ _06552_ VGND VGND VPWR VPWR _06563_ sky130_fd_sc_hd__buf_4
X_11534_ _03825_ _03828_ _03830_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__nand3_1
XFILLER_11_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14253_ _06493_ _06482_ VGND VGND VPWR VPWR _06494_ sky130_fd_sc_hd__nor2_1
X_11465_ _03699_ _03760_ _03763_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__nand3b_1
X_10416_ _02700_ _02651_ _02697_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__nand3_1
X_13204_ _05501_ _05502_ VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__nand2_1
X_14184_ _06419_ _06407_ _06413_ VGND VGND VPWR VPWR _06426_ sky130_fd_sc_hd__mux2_1
X_11396_ _03686_ _03691_ _03694_ VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__nand3_1
XFILLER_112_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10347_ _02639_ _02645_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__nand2_1
X_13135_ _05432_ _05429_ VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__nand2_1
XFILLER_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10278_ _02576_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__inv_2
XFILLER_97_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13066_ _05329_ _05364_ VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__nor2_1
XFILLER_78_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12017_ _04315_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__inv_2
XFILLER_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13968_ adder_inst.sum_raw_r\[5\] _06044_ VGND VGND VPWR VPWR _06237_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15707_ net281 VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__inv_2
X_12919_ _05214_ _05217_ VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__nand2_1
XFILLER_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13899_ _06042_ _06170_ _06124_ _06074_ _06173_ VGND VGND VPWR VPWR _06174_ sky130_fd_sc_hd__o311ai_2
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15638_ net271 VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__inv_2
XFILLER_61_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15569_ net274 VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__inv_2
X_09090_ _01387_ _01388_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__nand2_1
X_08110_ _07880_ _07875_ VGND VGND VPWR VPWR _07881_ sky130_fd_sc_hd__nand2_1
X_08041_ _07811_ _07797_ VGND VGND VPWR VPWR _07812_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_116_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09992_ _02290_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__inv_2
XFILLER_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08943_ _01136_ _01145_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__nand2_1
XFILLER_96_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08874_ _01172_ _01068_ _01072_ VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__nand3_1
XFILLER_57_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09426_ _01722_ _01724_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__nand2_1
XFILLER_44_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09357_ _01610_ _01615_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__nor2_1
XFILLER_100_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09288_ _01582_ _01132_ _01584_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__nand3_1
X_08308_ _00606_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08239_ _00537_ VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__inv_2
XFILLER_119_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11250_ _03486_ _03542_ _03537_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__a21boi_1
XFILLER_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10201_ _02217_ _02495_ _02497_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__nand3_1
X_11181_ _03479_ _03478_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__nand2_1
XFILLER_106_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10132_ _02430_ _02176_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__nand2_1
XFILLER_95_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10063_ _02325_ _02328_ _02361_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__a21oi_2
X_14940_ _07174_ _07179_ _07042_ VGND VGND VPWR VPWR _07181_ sky130_fd_sc_hd__a21o_1
XFILLER_75_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14871_ _07095_ _06989_ _07108_ VGND VGND VPWR VPWR _07109_ sky130_fd_sc_hd__a21bo_1
XFILLER_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13822_ _06095_ _06090_ VGND VGND VPWR VPWR _06097_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_89_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13753_ _05891_ _05897_ VGND VGND VPWR VPWR _06031_ sky130_fd_sc_hd__nor2_1
XFILLER_62_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10965_ _03257_ _03260_ _03263_ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__nand3b_1
X_12704_ _04978_ _05000_ _05002_ VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__nand3_1
X_13684_ _05971_ _05975_ VGND VGND VPWR VPWR _05976_ sky130_fd_sc_hd__xnor2_1
XFILLER_70_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10896_ _02993_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_26_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15423_ _07647_ VGND VGND VPWR VPWR _07648_ sky130_fd_sc_hd__inv_2
X_12635_ _04932_ _04933_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__nand2_1
X_15354_ _02790_ _02791_ VGND VGND VPWR VPWR _07582_ sky130_fd_sc_hd__nand2_1
X_12566_ _04844_ _04863_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__nand2_1
X_14305_ _06534_ _06545_ _06474_ VGND VGND VPWR VPWR _06546_ sky130_fd_sc_hd__nand3_1
X_11517_ _03814_ _03815_ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__nand2_1
X_15285_ _07507_ multiplier_inst.man_final_r\[19\] _07508_ VGND VGND VPWR VPWR _07520_
+ sky130_fd_sc_hd__and3_1
X_12497_ _04762_ _04765_ _04795_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__o21a_1
XFILLER_7_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14236_ _06454_ _06476_ VGND VGND VPWR VPWR _06477_ sky130_fd_sc_hd__nand2_1
XFILLER_50_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11448_ _00648_ _03746_ _03376_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__or3_1
X_14167_ _05951_ _05975_ VGND VGND VPWR VPWR _06409_ sky130_fd_sc_hd__or2_1
X_11379_ _03675_ _03677_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__nand2_1
XFILLER_98_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13118_ _04731_ net178 net124 VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_111_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14098_ _06354_ VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_86_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13049_ _05346_ _05347_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__nand2_1
XFILLER_78_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08590_ _00700_ _00888_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__nor2_1
XFILLER_81_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09211_ _01508_ _01509_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__nand2_1
XFILLER_10_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09142_ _01439_ _01440_ VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__nand2_1
X_09073_ _01371_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__inv_2
XFILLER_107_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08024_ _07794_ _07645_ VGND VGND VPWR VPWR _07795_ sky130_fd_sc_hd__nor2_1
XFILLER_103_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09975_ _02273_ _02084_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08926_ net207 net168 VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__nand2_1
XFILLER_111_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08857_ _01151_ _01153_ _01155_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08788_ _01031_ _01085_ _01086_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__a21oi_1
XFILLER_111_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10750_ _03048_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__inv_2
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10681_ _02979_ _02635_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__nand2_1
XFILLER_71_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09409_ _01706_ _01707_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__nand2_1
XFILLER_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12420_ _04656_ _04657_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12351_ _04648_ _04649_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__nand2_1
X_15070_ _07316_ _07317_ _06000_ VGND VGND VPWR VPWR _07319_ sky130_fd_sc_hd__a21o_1
X_11302_ _03515_ _03520_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__nand2_1
X_12282_ _04580_ net186 net125 VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__and3_1
X_14021_ adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR _06285_ sky130_fd_sc_hd__inv_2
X_11233_ _03531_ _03089_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__nand2_1
XFILLER_68_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11164_ _03461_ _03457_ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__nand2_1
XFILLER_95_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10115_ _02411_ _02413_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__nand2_1
XFILLER_67_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15972_ clknet_leaf_24_clk net321 _00220_ VGND VGND VPWR VPWR adder_inst.man_a_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_11095_ _03057_ _03059_ _03083_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__nand3_1
X_10046_ _02316_ _02100_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__nand2_1
X_14923_ _06818_ _07145_ VGND VGND VPWR VPWR _07163_ sky130_fd_sc_hd__nand2_1
Xhold92 _07694_ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 multiplier_inst.exp_final_r\[4\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 add_res\[11\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14854_ _07085_ _07090_ _07021_ VGND VGND VPWR VPWR _07091_ sky130_fd_sc_hd__mux2_1
XFILLER_75_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13805_ _06042_ _06061_ _06074_ _06079_ VGND VGND VPWR VPWR _06080_ sky130_fd_sc_hd__o211a_1
XFILLER_90_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14785_ _06566_ _07016_ VGND VGND VPWR VPWR _07024_ sky130_fd_sc_hd__xnor2_1
X_11997_ _04294_ _04295_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__xor2_1
X_13736_ adder_inst.is_nan_b_r net415 VGND VGND VPWR VPWR _06020_ sky130_fd_sc_hd__or2_1
XFILLER_50_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10948_ _03179_ _03243_ _03246_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__nand3_2
XFILLER_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13667_ _05921_ _05958_ _05959_ VGND VGND VPWR VPWR _05960_ sky130_fd_sc_hd__nor3_1
X_15406_ _07625_ _07631_ _05940_ VGND VGND VPWR VPWR _07632_ sky130_fd_sc_hd__mux2_1
X_10879_ _03089_ _03176_ _03177_ VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__nand3_1
X_13598_ _05842_ _07169_ VGND VGND VPWR VPWR _05894_ sky130_fd_sc_hd__nand2_1
X_12618_ _04860_ _04914_ _04916_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__nand3b_1
XFILLER_31_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15337_ net172 net248 _02920_ _02943_ VGND VGND VPWR VPWR _07563_ sky130_fd_sc_hd__a211o_1
X_12549_ _04800_ _04847_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__nand2_1
X_15268_ _07509_ VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__clkbuf_1
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 _03911_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14219_ _06439_ _06459_ VGND VGND VPWR VPWR _06460_ sky130_fd_sc_hd__nand2_1
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15199_ _07452_ _07453_ VGND VGND VPWR VPWR _07454_ sky130_fd_sc_hd__nand2_1
XFILLER_86_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09760_ _02057_ _02058_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__nand2_1
X_09691_ _01977_ _01987_ _01788_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__nand3_1
X_08711_ _00999_ _01009_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__nand2_1
XFILLER_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08642_ _00940_ _00747_ VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__nand2_1
XFILLER_94_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08573_ _00866_ _00870_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__nand3b_1
XFILLER_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09125_ _00588_ _01422_ _01423_ VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__o21ai_1
X_09056_ _07758_ _07753_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__nand2_1
X_08007_ _07747_ _07777_ VGND VGND VPWR VPWR _07778_ sky130_fd_sc_hd__nand2_1
X_09958_ _02256_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__inv_2
XFILLER_106_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08909_ _01205_ _01207_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__nand2_1
XFILLER_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09889_ _02187_ _02178_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__and2_1
XFILLER_66_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11920_ _04216_ _04218_ VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11851_ net106 net227 VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__nand2_1
XFILLER_72_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14570_ _06808_ _06474_ _06809_ VGND VGND VPWR VPWR _06810_ sky130_fd_sc_hd__nand3_1
X_10802_ _03098_ _03100_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__nand2_1
X_11782_ _04075_ _04080_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__or2_1
XFILLER_72_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13521_ _05818_ _05819_ VGND VGND VPWR VPWR _05820_ sky130_fd_sc_hd__nand2_1
XFILLER_53_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10733_ _03027_ _03029_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__nand2_1
XFILLER_41_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10664_ _02940_ _02912_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__nor2_1
X_13452_ _05748_ _05750_ VGND VGND VPWR VPWR _05751_ sky130_fd_sc_hd__nand2_1
XFILLER_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10595_ _02893_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__inv_2
X_13383_ _04362_ VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__inv_2
X_12403_ _04701_ VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_97_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15122_ _07372_ _06609_ VGND VGND VPWR VPWR _07373_ sky130_fd_sc_hd__nand2_1
X_12334_ _04625_ _04627_ _04632_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__nand3_1
X_15053_ _07193_ _06827_ _07299_ VGND VGND VPWR VPWR _07300_ sky130_fd_sc_hd__a21oi_1
XFILLER_99_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14004_ _06066_ _06268_ VGND VGND VPWR VPWR _06269_ sky130_fd_sc_hd__nand2_1
X_12265_ _04562_ _04563_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__nand2_1
X_11216_ _03491_ _03514_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__nand2_1
X_12196_ _04494_ _03683_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__nand2_1
Xoutput82 net82 VGND VGND VPWR VPWR o_res[22] sky130_fd_sc_hd__buf_2
XFILLER_110_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput71 net71 VGND VGND VPWR VPWR o_res[12] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR o_res[3] sky130_fd_sc_hd__buf_2
XFILLER_68_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11147_ _01383_ _03445_ _01386_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15955_ clknet_leaf_3_clk net318 _00203_ VGND VGND VPWR VPWR adder_inst.man_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_64_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11078_ _03324_ _03376_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__nor2_1
XFILLER_0_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15886_ clknet_leaf_6_clk net19 _00134_ VGND VGND VPWR VPWR adder_inst.exp_a\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_10029_ _02199_ _02192_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__nand2_1
X_14906_ _07144_ VGND VGND VPWR VPWR _07145_ sky130_fd_sc_hd__inv_2
XFILLER_48_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14837_ _07072_ _07058_ _06926_ VGND VGND VPWR VPWR _07073_ sky130_fd_sc_hd__o21ai_1
XFILLER_24_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14768_ _06833_ _07007_ VGND VGND VPWR VPWR _07008_ sky130_fd_sc_hd__nand2_2
X_13719_ _06003_ _06004_ _06005_ _06006_ VGND VGND VPWR VPWR _06007_ sky130_fd_sc_hd__or4_1
X_14699_ _06644_ _06547_ VGND VGND VPWR VPWR _06939_ sky130_fd_sc_hd__nand2_1
XFILLER_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout305 net306 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_4
XFILLER_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09812_ _02107_ _02110_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__nand2_1
XFILLER_86_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09743_ net151 net236 VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__nand2_1
XFILLER_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09674_ _01827_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__inv_2
XFILLER_54_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08625_ _00922_ _00923_ VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08556_ _00854_ _00684_ VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__nand2_1
XFILLER_14_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08487_ _00781_ _00505_ _00783_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__nand3_1
XFILLER_50_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09108_ _01367_ _01406_ VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__nand2_1
X_10380_ _02669_ _02678_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__nand2_1
X_09039_ _01336_ _01337_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__nand2_1
X_12050_ _04347_ _04348_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__nand2_1
XFILLER_2_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11001_ _03299_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__inv_2
XFILLER_77_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15740_ net290 VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__inv_2
XFILLER_100_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12952_ _05249_ _04265_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__nand2_1
XFILLER_18_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15671_ net273 VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__inv_2
XFILLER_18_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11903_ _04021_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__inv_2
X_14622_ _06484_ _06836_ _06861_ VGND VGND VPWR VPWR _06862_ sky130_fd_sc_hd__o21ai_1
X_12883_ _05134_ _05181_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__nor2_1
XFILLER_73_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11834_ _04130_ _04132_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__nand2_1
XFILLER_14_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14553_ _06534_ _06545_ _06700_ VGND VGND VPWR VPWR _06793_ sky130_fd_sc_hd__a21o_1
X_11765_ _03968_ _04061_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__nand2_1
XFILLER_14_664 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14484_ _06723_ _06718_ VGND VGND VPWR VPWR _06724_ sky130_fd_sc_hd__nand2_1
X_13504_ _05690_ _05798_ VGND VGND VPWR VPWR _05803_ sky130_fd_sc_hd__nand2_1
XFILLER_41_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11696_ _03992_ _03994_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__nand2_1
X_10716_ net202 net141 VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__nand2_1
X_10647_ _02933_ _02934_ _02876_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__a21o_1
X_13435_ _05646_ _05647_ _05678_ VGND VGND VPWR VPWR _05734_ sky130_fd_sc_hd__nand3_1
XFILLER_13_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10578_ _02876_ net163 net246 VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__and3_1
X_16154_ clknet_leaf_15_clk _00006_ _00402_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
X_13366_ _05659_ _05661_ _05664_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15105_ _07315_ _07354_ VGND VGND VPWR VPWR _07355_ sky130_fd_sc_hd__nand2_1
X_16085_ clknet_leaf_21_clk multiplier_inst.man_final\[11\] _00333_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[11\] sky130_fd_sc_hd__dfrtp_1
X_13297_ net181 net111 VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__nand2_1
X_12317_ net115 net198 VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__nand2_1
X_15036_ _07279_ _06789_ _07274_ VGND VGND VPWR VPWR _07282_ sky130_fd_sc_hd__nand3_1
X_12248_ _04546_ _04349_ _04346_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__a21boi_1
XFILLER_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12179_ _04451_ _04472_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__nand2_1
XFILLER_95_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15938_ clknet_leaf_17_clk adder_inst.sum_raw\[13\] _00186_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[13\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_64_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15869_ clknet_leaf_0_clk net32 _00117_ VGND VGND VPWR VPWR adder_inst.i_a\[9\] sky130_fd_sc_hd__dfrtp_1
X_08410_ _00699_ _00708_ VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__nand2_1
XFILLER_36_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09390_ _01661_ _01675_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__nand2_1
XFILLER_51_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08341_ _00639_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__inv_2
XFILLER_32_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08272_ net126 net229 VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__nand2_1
XFILLER_118_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout113 net114 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout124 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_2
Xfanout146 net148 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_4
Xfanout135 net136 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_2
Xfanout168 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
Xfanout157 adder_inst.man_b_r\[6\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_4
XFILLER_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout179 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_4
X_07987_ _07748_ _07757_ VGND VGND VPWR VPWR _07758_ sky130_fd_sc_hd__or2_1
XFILLER_101_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09726_ _01989_ _01990_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__nand2_1
XFILLER_28_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09657_ _01955_ _01887_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__nand2_1
X_09588_ _01886_ _01739_ _01760_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__nand3_1
X_08608_ _00904_ _00725_ _00729_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__nand3_1
XFILLER_42_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08539_ _00836_ _00837_ VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__nand2_1
X_11550_ _03847_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__nand2_1
XFILLER_23_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10501_ _02749_ _02740_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__nand2_1
XFILLER_7_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13220_ _05517_ _05512_ VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__nand2_1
XFILLER_10_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11481_ _03772_ _03779_ _03775_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__nand3_1
XFILLER_109_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10432_ _02672_ _02728_ VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__nand2_1
XFILLER_12_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10363_ _02661_ _02649_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_94_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13151_ net180 adder_inst.man_b_r\[20\] net178 net118 VGND VGND VPWR VPWR _05450_
+ sky130_fd_sc_hd__a22o_1
XFILLER_112_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13082_ _05037_ _04923_ _04920_ VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__o21a_1
XFILLER_2_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12102_ _01489_ _04367_ _01416_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__o21a_1
X_10294_ _02491_ _02514_ _02493_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__a21boi_1
XFILLER_2_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12033_ _04175_ _04177_ _04178_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__a21boi_1
XFILLER_88_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15723_ net298 VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__inv_2
X_13984_ adder_inst.sum_raw_r\[3\] net255 _06055_ adder_inst.sum_raw_r\[2\] _06067_
+ VGND VGND VPWR VPWR _06251_ sky130_fd_sc_hd__a221o_1
XFILLER_46_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12935_ _05041_ _05224_ _05233_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__nand3_1
XFILLER_18_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15654_ net263 VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__inv_2
X_12866_ _05157_ _05164_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__nand2_1
XFILLER_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15585_ net273 VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_103_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14605_ _06808_ _06516_ _06809_ VGND VGND VPWR VPWR _06845_ sky130_fd_sc_hd__nand3_1
X_11817_ _04111_ _04115_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_16_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14536_ _06772_ _06775_ VGND VGND VPWR VPWR _06776_ sky130_fd_sc_hd__nand2_1
X_12797_ _04245_ _05095_ _04240_ VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__o21ai_1
X_11748_ _04043_ _04046_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__nand2_1
X_14467_ _06706_ _06512_ VGND VGND VPWR VPWR _06707_ sky130_fd_sc_hd__nand2_1
X_11679_ _03974_ _03977_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__nand2_1
X_14398_ _06634_ _04582_ _06637_ VGND VGND VPWR VPWR _06638_ sky130_fd_sc_hd__mux2_1
X_13418_ _05646_ _05716_ _05647_ VGND VGND VPWR VPWR _05717_ sky130_fd_sc_hd__nand3_1
XFILLER_115_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16137_ clknet_leaf_13_clk _00095_ _00385_ VGND VGND VPWR VPWR mul_res\[30\] sky130_fd_sc_hd__dfrtp_1
X_13349_ adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__inv_2
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16068_ clknet_leaf_11_clk net310 _00316_ VGND VGND VPWR VPWR adder_inst.sign_a_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_114_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15019_ _06757_ _07237_ _07263_ VGND VGND VPWR VPWR _07264_ sky130_fd_sc_hd__a21o_1
X_08890_ _01186_ _01188_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__nand2_1
X_07910_ net188 net169 VGND VGND VPWR VPWR _07265_ sky130_fd_sc_hd__nand2_1
XFILLER_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09511_ _01808_ _01809_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__nand2_1
XFILLER_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09442_ _01594_ _01740_ _01591_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09373_ _01669_ _01671_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__nand2_1
XFILLER_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08324_ _00622_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__buf_6
XFILLER_20_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08255_ _00553_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__inv_2
X_08186_ net204 net158 VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__nand2_1
XFILLER_118_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09709_ _01836_ _01834_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__nand2_1
XFILLER_62_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10981_ net122 net222 VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__nand2_1
XFILLER_28_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12720_ _05017_ _05018_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__nand2_1
XFILLER_43_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12651_ _04649_ _04648_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_13_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11602_ _03898_ _03899_ _03900_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__nand3_1
X_15370_ _07530_ _07594_ _07598_ VGND VGND VPWR VPWR multiplier_inst.man_final\[0\]
+ sky130_fd_sc_hd__o21ai_1
X_12582_ adder_inst.man_b_r\[20\] VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_13_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14321_ _06552_ _06549_ _06559_ VGND VGND VPWR VPWR _06562_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_41_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11533_ _03829_ _03831_ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__nand2_1
XFILLER_109_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14252_ _04568_ _04134_ _06491_ VGND VGND VPWR VPWR _06493_ sky130_fd_sc_hd__mux2_1
X_11464_ _03761_ _03762_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__nand2_1
XFILLER_99_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10415_ _02710_ _02711_ _02713_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__nand3_1
X_13203_ _05496_ _05499_ _05497_ VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__nand3_1
X_14183_ _05904_ _06424_ VGND VGND VPWR VPWR _06425_ sky130_fd_sc_hd__xor2_1
X_11395_ _03692_ _03693_ VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__nand2_1
XFILLER_112_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10346_ _02641_ _02643_ _02644_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__a21oi_1
X_13134_ _05429_ _05432_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__or2_1
XFILLER_3_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10277_ _02574_ _02575_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__nand2_1
XFILLER_3_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13065_ _05327_ _05290_ VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__nor2_1
XFILLER_78_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12016_ _04313_ _04314_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__nand2_1
XFILLER_38_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13967_ _06231_ _06233_ _06234_ _06235_ VGND VGND VPWR VPWR _06236_ sky130_fd_sc_hd__a31o_1
XFILLER_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15706_ net284 VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__inv_2
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12918_ _05215_ _05216_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__nand2_1
X_15637_ net271 VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__inv_2
X_13898_ _06171_ net250 _06094_ _06172_ VGND VGND VPWR VPWR _06173_ sky130_fd_sc_hd__a31o_1
XFILLER_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12849_ _05147_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__inv_2
XFILLER_21_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15568_ net262 VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__inv_2
XFILLER_119_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15499_ net384 mul_res\[10\] net259 VGND VGND VPWR VPWR _07707_ sky130_fd_sc_hd__mux2_1
X_14519_ _06615_ _06460_ VGND VGND VPWR VPWR _06759_ sky130_fd_sc_hd__or2b_1
X_08040_ _07797_ _07799_ _07810_ VGND VGND VPWR VPWR _07811_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_116_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09991_ net228 net167 VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__nand2_1
XFILLER_88_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08942_ _01218_ _01240_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__nand2_1
XFILLER_111_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08873_ _01064_ _01061_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__nand2_1
XFILLER_29_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09425_ _01723_ _01558_ _01556_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__nand3_1
XFILLER_100_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09356_ _01615_ _01610_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__nand2_1
X_09287_ _01583_ _01585_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__nand2_1
X_08307_ _00605_ _00590_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__nor2_1
X_08238_ net140 net224 VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_78_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10200_ _02496_ _02498_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__nand2_1
XFILLER_69_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08169_ _00467_ _07792_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__nand2_1
XFILLER_109_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11180_ _03454_ _03477_ _03478_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__nand3_1
X_10131_ _02163_ _02013_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__nand2_1
X_10062_ _02326_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__inv_2
XFILLER_85_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14870_ _06980_ _06987_ VGND VGND VPWR VPWR _07108_ sky130_fd_sc_hd__nand2_1
XFILLER_75_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13821_ _06090_ _06095_ VGND VGND VPWR VPWR _06096_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_89_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13752_ net381 adder_inst.is_inf_a_r net385 adder_inst.is_inf_b_r _06020_ VGND VGND
+ VPWR VPWR _00070_ sky130_fd_sc_hd__a221o_1
XFILLER_90_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10964_ _01663_ _03261_ _03262_ VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__o21ai_1
X_12703_ _05001_ _04705_ _04980_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__nand3_1
X_13683_ _05973_ _05974_ VGND VGND VPWR VPWR _05975_ sky130_fd_sc_hd__nand2b_1
XFILLER_71_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10895_ net135 net202 VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_100_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15422_ _05804_ _07642_ VGND VGND VPWR VPWR _07647_ sky130_fd_sc_hd__nor2_1
XFILLER_43_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12634_ _04682_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__inv_2
XFILLER_31_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15353_ _07580_ _07543_ VGND VGND VPWR VPWR _07581_ sky130_fd_sc_hd__nand2_1
X_12565_ _04801_ _04843_ _04863_ VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__o21bai_1
X_14304_ _06544_ _06488_ VGND VGND VPWR VPWR _06545_ sky130_fd_sc_hd__nand2_1
X_11516_ _03813_ _03809_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__nand2_1
X_15284_ _07519_ VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__buf_1
X_12496_ _04763_ VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__inv_2
X_14235_ net160 net234 _06448_ VGND VGND VPWR VPWR _06476_ sky130_fd_sc_hd__mux2_1
X_11447_ net226 VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__inv_2
X_14166_ _06407_ _05949_ _05950_ VGND VGND VPWR VPWR _06408_ sky130_fd_sc_hd__a21bo_1
X_11378_ _03676_ _03614_ _03673_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__nand3_1
X_10329_ _02379_ _02378_ _02377_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__a21boi_1
X_13117_ _05414_ _05415_ VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__nand2_1
XFILLER_112_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14097_ _06183_ _06190_ _06353_ VGND VGND VPWR VPWR _06354_ sky130_fd_sc_hd__and3_1
XFILLER_78_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13048_ _05344_ _05341_ _05342_ VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__nand3_1
XFILLER_93_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14999_ _07202_ _06758_ VGND VGND VPWR VPWR _07242_ sky130_fd_sc_hd__nand2_1
XFILLER_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09210_ _01505_ _00646_ _01506_ VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__nand3_1
X_09141_ _01435_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__inv_2
X_09072_ net204 net146 VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__nand2_1
X_08023_ net194 net176 VGND VGND VPWR VPWR _07794_ sky130_fd_sc_hd__nand2_1
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09974_ _02097_ _02083_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__nand2_1
XFILLER_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08925_ _01223_ _00947_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__nand2_1
X_08856_ _01154_ _01001_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__nor2_1
XFILLER_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08787_ _01030_ _00932_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__nor2_1
XFILLER_45_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10680_ _02424_ _02428_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__nand2_1
XFILLER_71_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09408_ _01572_ _01570_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__nand2_1
XFILLER_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09339_ _01614_ _01617_ _01635_ VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_23_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12350_ _04225_ net177 net141 VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__and3_1
X_11301_ _03599_ _03580_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__nand2_1
X_12281_ _04579_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__inv_2
X_14020_ adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR _06284_ sky130_fd_sc_hd__inv_2
X_11232_ _03176_ _03177_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__nand2_1
X_11163_ _03456_ _03457_ _03461_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__nand3_1
X_10114_ _02412_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__inv_2
X_15971_ clknet_leaf_24_clk net329 _00219_ VGND VGND VPWR VPWR adder_inst.man_a_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11094_ _03391_ _03392_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__nand2_1
XFILLER_96_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10045_ _02343_ VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__inv_2
XFILLER_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14922_ _07161_ VGND VGND VPWR VPWR _07162_ sky130_fd_sc_hd__inv_2
XFILLER_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold82 mul_res\[29\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 multiplier_inst.exp_final_r\[5\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 adder_inst.exp_b\[0\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
X_14853_ _06990_ _07089_ VGND VGND VPWR VPWR _07090_ sky130_fd_sc_hd__xor2_1
XFILLER_36_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13804_ adder_inst.exp_larger_r\[1\] _06077_ _06078_ _06053_ VGND VGND VPWR VPWR
+ _06079_ sky130_fd_sc_hd__o22a_1
Xhold93 add_res\[14\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_63_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_692 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14784_ _06561_ _07016_ VGND VGND VPWR VPWR _07023_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_3_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11996_ net119 net208 VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__nand2_1
X_13735_ _05999_ VGND VGND VPWR VPWR _06019_ sky130_fd_sc_hd__buf_4
X_10947_ _03244_ _03245_ VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__nand2_1
X_13666_ _05839_ _05874_ _05878_ _05924_ VGND VGND VPWR VPWR _05959_ sky130_fd_sc_hd__or4_1
XFILLER_71_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15405_ _07629_ _07630_ VGND VGND VPWR VPWR _07631_ sky130_fd_sc_hd__and2_1
X_12617_ _04915_ _04848_ _04861_ VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__nand3_1
X_10878_ _03144_ _03172_ _03174_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__nand3_1
XFILLER_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13597_ _05848_ _05892_ VGND VGND VPWR VPWR _05893_ sky130_fd_sc_hd__nand2_1
X_15336_ _02907_ _02910_ _02967_ VGND VGND VPWR VPWR _07562_ sky130_fd_sc_hd__nand3b_1
X_12548_ _04781_ _04846_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__xor2_1
XFILLER_8_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_2 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15267_ _07507_ multiplier_inst.man_final_r\[10\] _07508_ VGND VGND VPWR VPWR _07509_
+ sky130_fd_sc_hd__and3_1
X_12479_ _04775_ _04771_ _04773_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__nand3_1
X_14218_ _06458_ VGND VGND VPWR VPWR _06459_ sky130_fd_sc_hd__inv_2
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15198_ _06641_ _06650_ _06648_ VGND VGND VPWR VPWR _07453_ sky130_fd_sc_hd__o21a_1
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14149_ _06395_ VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__inv_2
XFILLER_113_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09690_ _01978_ _01988_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__nand2_1
X_08710_ _01008_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__inv_2
XFILLER_94_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08641_ _00939_ _00742_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__nand2_1
XFILLER_81_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08572_ _00867_ _00685_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__nand2_1
XFILLER_35_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09124_ net126 net226 VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__nand2_1
X_09055_ _01352_ _01353_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__nand2_1
X_08006_ _07773_ _07776_ VGND VGND VPWR VPWR _07777_ sky130_fd_sc_hd__nand2_1
XFILLER_104_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09957_ _02255_ _02219_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__nand2_1
XFILLER_66_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08908_ _01206_ _00966_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__nand2_1
XFILLER_85_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09888_ _01867_ _02186_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__nand2_1
XFILLER_85_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08839_ _01137_ _00952_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11850_ _04147_ _04148_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__nand2_1
XFILLER_60_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10801_ _03092_ _03099_ _03095_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_0_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11781_ _04078_ _04079_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__nand2_1
XFILLER_82_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13520_ _05817_ _05814_ VGND VGND VPWR VPWR _05819_ sky130_fd_sc_hd__nand2_1
X_10732_ _03028_ _03030_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__nand2_1
XFILLER_13_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10663_ _02961_ _02893_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__nand2_1
X_13451_ _05690_ _05749_ VGND VGND VPWR VPWR _05750_ sky130_fd_sc_hd__nand2_1
XFILLER_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16170_ clknet_leaf_11_clk _00024_ _00418_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
X_10594_ _02845_ _02889_ _02892_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__nand3_1
X_13382_ _05671_ VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__buf_6
X_12402_ _04696_ _04698_ _04700_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__o21ai_1
X_15121_ _07339_ _07341_ VGND VGND VPWR VPWR _07372_ sky130_fd_sc_hd__nand2_1
XFILLER_5_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12333_ _04628_ _04631_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_97_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15052_ _07297_ _07298_ VGND VGND VPWR VPWR _07299_ sky130_fd_sc_hd__nand2_1
XFILLER_107_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14003_ adder_inst.sum_raw_r\[5\] net256 VGND VGND VPWR VPWR _06268_ sky130_fd_sc_hd__nand2_1
X_12264_ net183 net128 net187 net125 VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__a22o_1
X_11215_ _03513_ _03499_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__nand2_1
X_12195_ _03664_ _03669_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__nand2_1
Xoutput83 net83 VGND VGND VPWR VPWR o_res[23] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR o_res[13] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR o_res[4] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11146_ _01389_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__inv_2
X_15954_ clknet_leaf_6_clk net349 _00202_ VGND VGND VPWR VPWR adder_inst.man_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11077_ net112 net229 VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__nand2_1
X_10028_ _02325_ _02326_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__nand2_1
X_14905_ _07143_ _06797_ VGND VGND VPWR VPWR _07144_ sky130_fd_sc_hd__nand2_1
XFILLER_48_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15885_ clknet_leaf_6_clk net18 _00133_ VGND VGND VPWR VPWR adder_inst.exp_a\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_76_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14836_ _06931_ VGND VGND VPWR VPWR _07072_ sky130_fd_sc_hd__inv_2
XFILLER_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14767_ _07000_ _07006_ VGND VGND VPWR VPWR _07007_ sky130_fd_sc_hd__nand2_1
XFILLER_17_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13718_ adder_inst.i_b\[9\] adder_inst.i_b\[8\] adder_inst.i_b\[11\] adder_inst.i_b\[10\]
+ VGND VGND VPWR VPWR _06006_ sky130_fd_sc_hd__or4_1
X_11979_ _04276_ _04277_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__nand2_1
XFILLER_32_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14698_ _06936_ _06714_ _06937_ VGND VGND VPWR VPWR _06938_ sky130_fd_sc_hd__nand3_1
XFILLER_32_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13649_ _05888_ _05942_ _05932_ VGND VGND VPWR VPWR _05943_ sky130_fd_sc_hd__a21bo_1
X_15319_ _02978_ _02982_ VGND VGND VPWR VPWR _07543_ sky130_fd_sc_hd__nand2_1
XFILLER_8_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09811_ _02108_ _02046_ _02109_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__nand3_1
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_70_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09742_ _02040_ _01931_ VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_70_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09673_ _01971_ _01965_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__nand2_1
XFILLER_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08624_ _00519_ _00493_ _00734_ VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_53_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08555_ _00687_ _00689_ VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__nand2_1
XFILLER_42_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08486_ _00782_ _00784_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_81_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09107_ _01402_ _01405_ VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__nand2_1
X_09038_ _07423_ _07544_ _07413_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__a21boi_1
XFILLER_89_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11000_ net121 net225 VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__nand2_1
XFILLER_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12951_ _04265_ _05249_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__nor2_1
XFILLER_18_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15670_ net271 VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__inv_2
XFILLER_100_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12882_ _05179_ _05180_ VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__nand2_1
XFILLER_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11902_ _04198_ _04200_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__nand2_1
X_14621_ _06804_ _06805_ _06465_ VGND VGND VPWR VPWR _06861_ sky130_fd_sc_hd__o21ai_1
X_11833_ _04131_ _04128_ _04127_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__nand3_1
XFILLER_33_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14552_ _06726_ _06758_ _06791_ VGND VGND VPWR VPWR _06792_ sky130_fd_sc_hd__nand3_1
X_11764_ _04060_ _04062_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__nand2_1
XFILLER_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14483_ _06721_ VGND VGND VPWR VPWR _06723_ sky130_fd_sc_hd__inv_2
X_13503_ _05681_ _05749_ VGND VGND VPWR VPWR _05802_ sky130_fd_sc_hd__nand2_1
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11695_ _03993_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__inv_2
X_10715_ _03013_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__inv_2
XFILLER_14_676 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10646_ _02943_ _02944_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__nand2_1
X_13434_ _05663_ _05730_ VGND VGND VPWR VPWR _05733_ sky130_fd_sc_hd__nand2_1
XFILLER_42_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_16153_ clknet_leaf_15_clk _00005_ _00401_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
XFILLER_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10577_ _02875_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__inv_2
X_15104_ _07353_ VGND VGND VPWR VPWR _07354_ sky130_fd_sc_hd__inv_2
X_13365_ _05663_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_11_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16084_ clknet_leaf_20_clk multiplier_inst.man_final\[10\] _00332_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[10\] sky130_fd_sc_hd__dfrtp_1
X_13296_ _05593_ _05594_ VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__nand2_1
X_12316_ _04613_ _04614_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__nand2_1
X_15035_ _07280_ _06777_ VGND VGND VPWR VPWR _07281_ sky130_fd_sc_hd__nand2_1
X_12247_ _04358_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__inv_2
XFILLER_96_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12178_ _04403_ _04416_ _04476_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__a21oi_1
XFILLER_110_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11129_ _03427_ _03426_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_108_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15937_ clknet_leaf_17_clk adder_inst.sum_raw\[12\] _00185_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[12\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_83_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15868_ clknet_leaf_0_clk net31 _00116_ VGND VGND VPWR VPWR adder_inst.i_a\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_91_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14819_ _06933_ _06913_ VGND VGND VPWR VPWR _07055_ sky130_fd_sc_hd__xor2_1
XFILLER_24_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15799_ net281 VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__inv_2
XFILLER_17_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08340_ _00638_ _00635_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__nand2_1
X_08271_ net122 net232 VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout103 net104 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout136 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_4
Xfanout114 adder_inst.man_b_r\[21\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_2
Xfanout147 net148 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_2
Xfanout125 net127 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_2
XFILLER_101_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout169 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_4
X_07986_ _07753_ _07756_ VGND VGND VPWR VPWR _07757_ sky130_fd_sc_hd__nand2_1
Xfanout158 net160 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
X_09725_ _02023_ _01999_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__nand2_1
X_09656_ _01953_ _01954_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__nand2_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08607_ _00730_ _00905_ VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__nand2_1
XFILLER_82_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09587_ _01882_ _01885_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__nand2_1
XFILLER_63_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08538_ _00736_ _00519_ VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__nand2_1
XFILLER_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08469_ _00766_ _00767_ VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__nand2_1
X_10500_ _02798_ _02772_ VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__nand2_1
XFILLER_11_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11480_ _03777_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__inv_2
X_10431_ _02673_ _02729_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__nand2_1
XFILLER_6_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10362_ _02659_ _02660_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_94_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13150_ _03954_ _04881_ _05393_ VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__or3_1
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10293_ _02582_ _02306_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__nand2_1
XFILLER_88_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13081_ _05041_ _05379_ _05231_ VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__nand3_1
XFILLER_2_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12101_ _04368_ _04396_ _04399_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__nand3_1
X_12032_ _04327_ _04329_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__nand2_1
XFILLER_77_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13983_ _06207_ _06062_ VGND VGND VPWR VPWR _06250_ sky130_fd_sc_hd__nor2_1
X_15722_ net298 VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__inv_2
X_12934_ _05230_ _05232_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__nor2_1
XFILLER_37_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15653_ net263 VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__inv_2
XFILLER_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12865_ _05163_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__inv_2
XFILLER_33_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15584_ net271 VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_103_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14604_ _06838_ _06843_ _06700_ VGND VGND VPWR VPWR _06844_ sky130_fd_sc_hd__nand3_1
X_11816_ _03890_ _04112_ _04114_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_16_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12796_ _04243_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__inv_2
XFILLER_33_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14535_ _06773_ _06774_ VGND VGND VPWR VPWR _06775_ sky130_fd_sc_hd__nand2_1
X_11747_ _04044_ _04045_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__nor2_1
X_14466_ _06445_ _06702_ _06705_ VGND VGND VPWR VPWR _06706_ sky130_fd_sc_hd__o21ai_1
X_11678_ _03812_ _03975_ _03976_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__a21oi_1
X_10629_ _02872_ _02871_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__nand2b_1
X_14397_ _06553_ VGND VGND VPWR VPWR _06637_ sky130_fd_sc_hd__buf_4
X_13417_ _05714_ _05715_ VGND VGND VPWR VPWR _05716_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16136_ clknet_leaf_12_clk _00093_ _00384_ VGND VGND VPWR VPWR mul_res\[29\] sky130_fd_sc_hd__dfrtp_1
X_13348_ _05641_ _05638_ _05644_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__nand3_4
XFILLER_115_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16067_ clknet_leaf_11_clk adder_inst.is_zero_a _00315_ VGND VGND VPWR VPWR adder_inst.is_zero_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_15018_ _07262_ VGND VGND VPWR VPWR _07263_ sky130_fd_sc_hd__inv_2
X_13279_ _04917_ _04914_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__nand2_1
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09510_ _01802_ _01605_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09441_ _01590_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__inv_2
XFILLER_64_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09372_ _01670_ _01448_ _01179_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08323_ net117 VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__inv_4
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08254_ _00552_ _00543_ VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__nand2_1
X_08185_ _00483_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__inv_2
XFILLER_106_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_18_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09708_ _02001_ _02006_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__nand2_1
X_07969_ _07739_ _07736_ VGND VGND VPWR VPWR _07740_ sky130_fd_sc_hd__nand2_1
XFILLER_90_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10980_ _03060_ _03067_ _03063_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_27_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09639_ _01932_ _01934_ _01937_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__nand3_1
XFILLER_43_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12650_ _04938_ _04947_ _04948_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__a21oi_1
XFILLER_70_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11601_ _03713_ _03709_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__nand2_1
XFILLER_30_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14320_ _06556_ _06560_ VGND VGND VPWR VPWR _06561_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12581_ _04818_ _04821_ _04817_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_13_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11532_ _03830_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__inv_2
XFILLER_99_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14251_ net136 net209 _06491_ VGND VGND VPWR VPWR _06492_ sky130_fd_sc_hd__mux2_1
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11463_ _03208_ _03180_ _03700_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__a21oi_1
X_14182_ _06422_ _06423_ _06413_ VGND VGND VPWR VPWR _06424_ sky130_fd_sc_hd__mux2_1
XFILLER_99_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10414_ _02712_ _02620_ _02623_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__nand3_1
X_13202_ _05498_ _05500_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_36_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13133_ _05431_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__inv_2
X_11394_ _03671_ _03673_ VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__nand2_1
X_10345_ _02524_ _02640_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__nor2_1
XFILLER_3_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10276_ _02572_ _02571_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__nand2_1
XFILLER_97_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13064_ _04550_ _05362_ VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__nand2_1
XFILLER_3_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_12015_ _04301_ _04311_ _04303_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__nand3_1
XFILLER_78_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13966_ _06216_ net254 _06113_ _06209_ VGND VGND VPWR VPWR _06235_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_49_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13897_ _06122_ adder_inst.sum_raw_r\[23\] net250 VGND VGND VPWR VPWR _06172_ sky130_fd_sc_hd__a21oi_1
X_15705_ net284 VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__inv_2
XFILLER_46_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12917_ _05129_ _05117_ _05118_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__a21boi_1
X_15636_ net270 VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__inv_2
XFILLER_64_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12848_ _05146_ _05145_ VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_64_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15567_ net262 VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__inv_2
X_12779_ _05075_ _05077_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__nand2_1
X_15498_ _07706_ VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__clkbuf_1
X_14518_ _06741_ _06757_ VGND VGND VPWR VPWR _06758_ sky130_fd_sc_hd__nor2_1
X_14449_ _06688_ _06552_ VGND VGND VPWR VPWR _06689_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_54_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16119_ clknet_leaf_20_clk _00075_ _00367_ VGND VGND VPWR VPWR mul_res\[12\] sky130_fd_sc_hd__dfrtp_1
X_09990_ _02287_ _02288_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__nand2_1
XFILLER_115_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08941_ _01231_ _01236_ _01239_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__a21boi_1
X_08872_ _01168_ _01119_ _01078_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__nand3_1
XFILLER_111_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09424_ _01713_ _01551_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__nand2_1
XFILLER_64_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09355_ _01653_ _01194_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__nand2_1
XFILLER_40_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09286_ _01584_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__inv_2
X_08306_ net130 net235 VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__nand2_1
X_08237_ _00535_ _07868_ VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__nand2_1
XFILLER_119_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08168_ _00466_ _07791_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__nand2_1
XFILLER_109_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08099_ _07868_ _07869_ VGND VGND VPWR VPWR _07870_ sky130_fd_sc_hd__nor2_1
XFILLER_106_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10130_ _02417_ _02424_ _02428_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__nand3_1
XFILLER_79_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10061_ _02359_ _02072_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__nand2_1
XFILLER_0_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13820_ _06091_ _06094_ VGND VGND VPWR VPWR _06095_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_89_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13751_ _06030_ VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10963_ net129 net220 VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__nand2_1
XFILLER_28_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12702_ _04999_ _04989_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__nand2_1
X_13682_ _05972_ adder_inst.exp_a_r\[7\] VGND VGND VPWR VPWR _05974_ sky130_fd_sc_hd__nand2_1
X_15421_ _07646_ VGND VGND VPWR VPWR multiplier_inst.man_final\[9\] sky130_fd_sc_hd__clkbuf_1
XFILLER_43_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10894_ net131 net208 VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_100_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12633_ _04708_ _04709_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__nand2_1
X_15352_ _05707_ _02981_ VGND VGND VPWR VPWR _07580_ sky130_fd_sc_hd__nand2_1
X_12564_ _04835_ _04827_ _04826_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__o21ai_1
XFILLER_8_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15283_ _07507_ multiplier_inst.man_final_r\[18\] _07508_ VGND VGND VPWR VPWR _07519_
+ sky130_fd_sc_hd__and3_1
X_14303_ _06447_ _06537_ _06543_ VGND VGND VPWR VPWR _06544_ sky130_fd_sc_hd__o21ai_1
X_11515_ _03809_ _03813_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__or2_1
X_14234_ _02879_ _02804_ _06448_ VGND VGND VPWR VPWR _06475_ sky130_fd_sc_hd__mux2_1
X_12495_ _04792_ _04793_ VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__nand2_1
XFILLER_7_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11446_ _03744_ VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__inv_2
X_14165_ _06402_ _06405_ _06406_ VGND VGND VPWR VPWR _06407_ sky130_fd_sc_hd__a21o_1
X_11377_ _03614_ _03618_ _03644_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__nand3_1
XFILLER_112_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14096_ _06184_ _06351_ _06352_ VGND VGND VPWR VPWR _06353_ sky130_fd_sc_hd__o21ai_1
X_10328_ _02398_ _02397_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__nand2_1
X_13116_ _05413_ _04870_ VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_111_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13047_ _05343_ _05345_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__nand2_1
X_10259_ _02557_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__inv_2
XFILLER_66_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14998_ _07235_ _07241_ VGND VGND VPWR VPWR adder_inst.sum_raw\[13\] sky130_fd_sc_hd__nand2_1
XFILLER_53_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13949_ _06192_ _06193_ _06219_ VGND VGND VPWR VPWR _06220_ sky130_fd_sc_hd__and3_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15619_ net289 VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__inv_2
XFILLER_34_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09140_ _01434_ _01437_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__nand2_1
X_09071_ _07888_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__inv_2
X_08022_ _07792_ VGND VGND VPWR VPWR _07793_ sky130_fd_sc_hd__inv_2
XFILLER_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09973_ _02267_ _02269_ _02271_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__a21oi_1
X_08924_ net204 net173 VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__nand2_2
XFILLER_84_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08855_ net148 net230 VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__nand2_1
XFILLER_57_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08786_ _01081_ _01084_ VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_80_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09407_ _01565_ _01568_ _01569_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09338_ _01618_ _01636_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__nand2_1
XFILLER_9_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09269_ _01567_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__inv_2
X_11300_ _03580_ _03584_ _03598_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__nand3_1
XFILLER_112_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12280_ net189 net128 VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__nand2_1
XFILLER_4_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11231_ _03529_ _03515_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__nand2_1
XFILLER_20_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11162_ _03458_ _03460_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__or2_1
XFILLER_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10113_ _02057_ _02393_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__nor2_1
X_15970_ clknet_leaf_24_clk net326 _00218_ VGND VGND VPWR VPWR adder_inst.man_a_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_11093_ _03083_ _03057_ _03059_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__a21boi_1
X_10044_ _02319_ _02331_ _02342_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__a21oi_1
Xhold50 adder_inst.i_b\[9\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
X_14921_ _07003_ _06818_ VGND VGND VPWR VPWR _07161_ sky130_fd_sc_hd__nand2_1
XFILLER_75_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold83 _07730_ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 multiplier_inst.exp_final_r\[1\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
X_14852_ _07058_ _07083_ _07088_ VGND VGND VPWR VPWR _07089_ sky130_fd_sc_hd__a21o_1
Xhold61 adder_inst.i_b\[18\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_48_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13803_ net250 VGND VGND VPWR VPWR _06078_ sky130_fd_sc_hd__inv_2
Xhold94 _07712_ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_63_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14783_ _07022_ VGND VGND VPWR VPWR adder_inst.sign_sum sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_3_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11995_ net118 net212 VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__nand2_1
X_13734_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r _06018_ VGND VGND VPWR VPWR _00033_
+ sky130_fd_sc_hd__o21a_1
XFILLER_45_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10946_ _03215_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__inv_2
XFILLER_16_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13665_ _05956_ _05957_ VGND VGND VPWR VPWR _05958_ sky130_fd_sc_hd__nand2_1
X_10877_ _03145_ _03175_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__nand2_1
XFILLER_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15404_ _05740_ _07628_ VGND VGND VPWR VPWR _07630_ sky130_fd_sc_hd__nand2_1
X_12616_ _04913_ _04910_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__nand2_1
XFILLER_31_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13596_ _05876_ _05653_ VGND VGND VPWR VPWR _05892_ sky130_fd_sc_hd__xnor2_1
X_15335_ _07551_ _02975_ VGND VGND VPWR VPWR _07561_ sky130_fd_sc_hd__nand2_1
XFILLER_12_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12547_ _04844_ _04845_ VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__nand2b_1
X_15266_ _07493_ VGND VGND VPWR VPWR _07508_ sky130_fd_sc_hd__clkbuf_2
X_12478_ _04774_ _04776_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__nand2_1
XANTENNA_3 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14217_ _05866_ _06457_ VGND VGND VPWR VPWR _06458_ sky130_fd_sc_hd__xor2_1
X_15197_ _07398_ _06651_ VGND VGND VPWR VPWR _07452_ sky130_fd_sc_hd__nand2_1
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11429_ _03368_ _03364_ VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__nand2_1
X_14148_ _06393_ _06018_ _06187_ _06394_ VGND VGND VPWR VPWR _06395_ sky130_fd_sc_hd__a31o_1
XFILLER_98_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14079_ _06055_ adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR _06337_ sky130_fd_sc_hd__nand2_1
X_08640_ _00746_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__inv_2
X_08571_ _00868_ _00869_ VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__nand2_1
XFILLER_19_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09123_ net225 VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_20_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09054_ _01350_ _01340_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__nand2_1
X_08005_ _07774_ _07771_ _07775_ VGND VGND VPWR VPWR _07776_ sky130_fd_sc_hd__nand3_1
XFILLER_1_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09956_ _02253_ _02254_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__nand2_1
X_09887_ _01865_ _01702_ _01703_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__nand3_1
XFILLER_57_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08907_ _00966_ _00951_ _00962_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__nand3_1
XFILLER_66_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08838_ net213 net163 VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_86_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08769_ _00868_ _01067_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__nand2_1
X_10800_ _03097_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11780_ _03982_ _04076_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__nand2_1
XFILLER_26_663 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10731_ _03029_ VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__inv_2
XFILLER_15_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13450_ _05224_ _05744_ VGND VGND VPWR VPWR _05749_ sky130_fd_sc_hd__xnor2_1
X_10662_ _02960_ _02888_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__nand2_1
X_12401_ _04560_ _01670_ _04699_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__or3_1
X_10593_ _02890_ _02891_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__nand2_1
X_13381_ _05676_ _05679_ VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__nand2_1
X_15120_ _07369_ _07178_ VGND VGND VPWR VPWR _07371_ sky130_fd_sc_hd__nand2_1
XFILLER_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12332_ _04627_ _04630_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_97_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15051_ _07252_ _06791_ VGND VGND VPWR VPWR _07298_ sky130_fd_sc_hd__nand2_1
X_12263_ _04560_ _01663_ _04561_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__or3_1
XFILLER_107_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14002_ _06267_ VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__clkbuf_1
X_11214_ _03499_ _03504_ _03512_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__nand3_1
X_12194_ _04479_ _04445_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__nand2_1
Xoutput84 net84 VGND VGND VPWR VPWR o_res[24] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR o_res[14] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11145_ _03443_ _03275_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__nand2_1
X_15953_ clknet_leaf_3_clk net331 _00201_ VGND VGND VPWR VPWR adder_inst.man_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
Xoutput95 net95 VGND VGND VPWR VPWR o_res[5] sky130_fd_sc_hd__buf_2
X_11076_ net106 net237 VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__nand2_1
X_10027_ _02324_ _02321_ _02045_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__nand3b_1
XFILLER_88_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14904_ _06800_ VGND VGND VPWR VPWR _07143_ sky130_fd_sc_hd__inv_2
XFILLER_48_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15884_ clknet_leaf_7_clk net17 _00132_ VGND VGND VPWR VPWR adder_inst.exp_a\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_14835_ _06949_ _07070_ VGND VGND VPWR VPWR _07071_ sky130_fd_sc_hd__xor2_1
X_14766_ _06826_ _07005_ VGND VGND VPWR VPWR _07006_ sky130_fd_sc_hd__nor2_1
X_11978_ _04275_ _04271_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_106_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13717_ adder_inst.i_b\[13\] adder_inst.i_b\[12\] adder_inst.i_b\[15\] adder_inst.i_b\[14\]
+ VGND VGND VPWR VPWR _06005_ sky130_fd_sc_hd__or4_2
X_10929_ _03227_ _03126_ _03135_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__nand3_1
XFILLER_17_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14697_ _06742_ _06516_ _06745_ VGND VGND VPWR VPWR _06937_ sky130_fd_sc_hd__nand3_1
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13648_ _05926_ _05941_ VGND VGND VPWR VPWR _05942_ sky130_fd_sc_hd__or2_1
XFILLER_72_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13579_ _05870_ _05875_ VGND VGND VPWR VPWR _05876_ sky130_fd_sc_hd__nand2_2
X_15318_ _07536_ _07537_ _07541_ VGND VGND VPWR VPWR _07542_ sky130_fd_sc_hd__a21o_1
XFILLER_99_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15249_ _07492_ multiplier_inst.man_final_r\[2\] _07494_ VGND VGND VPWR VPWR _07497_
+ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09810_ _02029_ _01938_ _02037_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_70_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout307 net67 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_4
X_09741_ _02039_ VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__inv_2
XFILLER_39_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09672_ _01969_ _01795_ VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__nand2_1
XFILLER_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_19_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_27_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08623_ _00731_ _00513_ VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__nand2_1
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08554_ _00851_ _00852_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08485_ _00783_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_81_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09106_ _01403_ _01399_ _01404_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__nand3_1
XFILLER_108_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09037_ _01334_ _01335_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__nand2_1
XFILLER_2_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09939_ _02220_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__inv_2
XFILLER_100_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12950_ _05248_ _05146_ VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__nand2_1
XFILLER_93_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12881_ _05149_ _05150_ _05177_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__nand3_1
X_11901_ _04199_ _04181_ _04184_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__nand3_1
X_14620_ _06858_ _06859_ VGND VGND VPWR VPWR _06860_ sky130_fd_sc_hd__nand2_1
X_11832_ _03901_ _03899_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__nand2_1
X_14551_ _06777_ _06790_ VGND VGND VPWR VPWR _06791_ sky130_fd_sc_hd__nor2_1
X_11763_ _04061_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__inv_2
X_14482_ _06719_ _06721_ VGND VGND VPWR VPWR _06722_ sky130_fd_sc_hd__nand2_1
X_13502_ _05794_ _05800_ VGND VGND VPWR VPWR _05801_ sky130_fd_sc_hd__nor2_1
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11694_ _03788_ _03783_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__nand2_1
X_10714_ _03011_ _03012_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__nand2_1
XFILLER_14_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10645_ _02920_ net172 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__and3_1
X_13433_ _05728_ _05731_ VGND VGND VPWR VPWR _05732_ sky130_fd_sc_hd__nand2_1
X_16152_ clknet_leaf_15_clk _00004_ _00400_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
X_13364_ _05662_ VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__buf_6
XFILLER_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10576_ net166 net247 VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__nand2_1
X_15103_ _07010_ _06593_ VGND VGND VPWR VPWR _07353_ sky130_fd_sc_hd__nand2_1
XFILLER_5_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12315_ _04591_ _04593_ _04611_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__nand3_1
X_16083_ clknet_leaf_19_clk multiplier_inst.man_final\[9\] _00331_ VGND VGND VPWR
+ VPWR multiplier_inst.man_final_r\[9\] sky130_fd_sc_hd__dfrtp_1
X_13295_ _05483_ _05487_ _05485_ VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15034_ _07279_ _06789_ VGND VGND VPWR VPWR _07280_ sky130_fd_sc_hd__nand2_1
X_12246_ _04363_ _04544_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__nand2_1
XFILLER_5_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12177_ _04402_ _04401_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__nor2_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11128_ _03420_ _03425_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__nand3b_2
XFILLER_110_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15936_ clknet_leaf_17_clk adder_inst.sum_raw\[11\] _00184_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[11\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_67_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11059_ _03340_ _03354_ _03357_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__nand3_1
X_15867_ clknet_leaf_5_clk net30 _00115_ VGND VGND VPWR VPWR adder_inst.i_a\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_91_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14818_ _07049_ _07054_ VGND VGND VPWR VPWR adder_inst.sum_raw\[3\] sky130_fd_sc_hd__nand2_1
X_15798_ net284 VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__inv_2
XFILLER_17_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14749_ _06983_ _06988_ VGND VGND VPWR VPWR _06989_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_67_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08270_ _07852_ _07861_ _07857_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_30_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_8_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_8_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout104 net105 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_113_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout126 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_4
Xfanout115 net116 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_2
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_4
Xfanout159 net160 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_4
Xfanout148 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07985_ _07754_ _07755_ VGND VGND VPWR VPWR _07756_ sky130_fd_sc_hd__nand2_1
X_09724_ _02020_ _02022_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__nand2_1
XFILLER_103_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09655_ _01760_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__inv_2
XFILLER_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08606_ _00904_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__inv_2
X_09586_ _01883_ _01884_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__nand2_1
XFILLER_42_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08537_ _00834_ _00835_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__nand2_1
XFILLER_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08468_ _00747_ _00749_ _00751_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__a21o_1
XFILLER_50_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10430_ _02728_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__inv_2
X_08399_ _00638_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__nand2_1
XFILLER_7_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10361_ _02648_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_94_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10292_ _02590_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__inv_2
X_13080_ _05376_ _05378_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__nand2_1
X_12100_ _04397_ _04398_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__nand2_1
XFILLER_88_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12031_ _04223_ _04327_ _04329_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__nand3_1
XFILLER_104_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13982_ _06249_ VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_77_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15721_ net298 VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__inv_2
XFILLER_92_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12933_ _05231_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__inv_2
XFILLER_37_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15652_ net263 VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__inv_2
X_12864_ _05158_ _05162_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__xor2_1
X_15583_ net271 VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_103_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14603_ _06839_ _06484_ _06842_ VGND VGND VPWR VPWR _06843_ sky130_fd_sc_hd__a21o_1
X_11815_ _03889_ _04113_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__nand2_1
X_12795_ _05092_ _05093_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__nand2_1
XFILLER_33_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14534_ _06637_ net203 VGND VGND VPWR VPWR _06774_ sky130_fd_sc_hd__nand2_1
X_11746_ _03860_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_16_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14465_ _06704_ _06445_ VGND VGND VPWR VPWR _06705_ sky130_fd_sc_hd__nand2_1
X_11677_ _03183_ _03810_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__nor2_1
X_10628_ net167 net245 VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__nand2_1
X_14396_ _06635_ VGND VGND VPWR VPWR _06636_ sky130_fd_sc_hd__inv_2
X_13416_ _02989_ _05713_ VGND VGND VPWR VPWR _05715_ sky130_fd_sc_hd__nand2_1
X_16135_ clknet_leaf_13_clk _00092_ _00383_ VGND VGND VPWR VPWR mul_res\[28\] sky130_fd_sc_hd__dfrtp_1
X_10559_ _02833_ _02857_ _02832_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__o21bai_1
X_13347_ _05642_ _05645_ VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__nand2_4
X_16066_ clknet_leaf_11_clk adder_inst.sign_sum _00314_ VGND VGND VPWR VPWR adder_inst.sign_sum_r
+ sky130_fd_sc_hd__dfrtp_1
X_13278_ _05574_ _05576_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__nor2_1
XFILLER_5_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15017_ _06751_ _06753_ VGND VGND VPWR VPWR _07262_ sky130_fd_sc_hd__nand2_1
X_12229_ _04526_ _04527_ VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_114_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15919_ clknet_leaf_6_clk net52 _00167_ VGND VGND VPWR VPWR adder_inst.exp_b\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_69_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09440_ _01710_ _01738_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__nand2_1
XFILLER_25_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09371_ net136 VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__inv_2
XFILLER_40_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08322_ _00619_ _00620_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__or2_1
X_08253_ _00543_ _00550_ _00551_ VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__nand3_1
XFILLER_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08184_ _00482_ _07800_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__nand2_1
XFILLER_99_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07968_ _07726_ _07735_ VGND VGND VPWR VPWR _07739_ sky130_fd_sc_hd__nor2_1
XFILLER_114_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09707_ _02004_ _02005_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__nand2_1
XFILLER_28_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07899_ _07128_ _07076_ VGND VGND VPWR VPWR _07149_ sky130_fd_sc_hd__nand2_1
XFILLER_28_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09638_ _01935_ _01936_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__nand2_1
XFILLER_15_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09569_ _01697_ _01533_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__nand2_1
XFILLER_43_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12580_ _04877_ _04878_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__nand2_1
X_11600_ _03896_ _03893_ _03894_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__nand3_1
XFILLER_70_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11531_ _03203_ _03191_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__nand2_1
XFILLER_11_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14250_ _06440_ VGND VGND VPWR VPWR _06491_ sky130_fd_sc_hd__clkbuf_4
X_11462_ _03759_ _03756_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__nand2_1
XFILLER_23_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14181_ _06402_ _05912_ _05910_ VGND VGND VPWR VPWR _06423_ sky130_fd_sc_hd__a21oi_1
X_10413_ _02707_ _02706_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__nor2_1
X_13201_ _05499_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__inv_2
XFILLER_7_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11393_ _03678_ _03679_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__nand2_1
X_10344_ _02642_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__inv_2
X_13132_ _05399_ _05430_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__nand2_1
X_10275_ _02573_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__inv_2
XFILLER_78_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_13063_ _05234_ _05361_ VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__nor2_1
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12014_ _04304_ _04312_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__nand2_1
XFILLER_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_628 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_100_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13965_ adder_inst.sum_raw_r\[1\] net257 VGND VGND VPWR VPWR _06234_ sky130_fd_sc_hd__nand2_1
XFILLER_58_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13896_ _06145_ _06122_ VGND VGND VPWR VPWR _06171_ sky130_fd_sc_hd__nand2_1
X_15704_ net296 VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__inv_2
X_12916_ _05027_ _05213_ VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__nand2_1
X_15635_ net281 VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__inv_2
X_12847_ _05143_ _05144_ _05145_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__nand3_1
XFILLER_22_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15566_ net262 VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__inv_2
XFILLER_42_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12778_ _05076_ _05068_ _05072_ VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__nand3_1
XFILLER_119_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_15497_ net407 mul_res\[9\] net258 VGND VGND VPWR VPWR _07706_ sky130_fd_sc_hd__mux2_1
X_14517_ _06755_ _06756_ VGND VGND VPWR VPWR _06757_ sky130_fd_sc_hd__nand2_1
X_11729_ _04025_ _03742_ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nand2_1
X_14448_ _06474_ _06600_ _06521_ _06687_ VGND VGND VPWR VPWR _06688_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_116_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_16118_ clknet_leaf_20_clk _00074_ _00366_ VGND VGND VPWR VPWR mul_res\[11\] sky130_fd_sc_hd__dfrtp_1
X_14379_ _06547_ _06618_ VGND VGND VPWR VPWR _06619_ sky130_fd_sc_hd__or2_1
XFILLER_115_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16049_ clknet_leaf_10_clk adder_inst.exp_larger\[1\] _00297_ VGND VGND VPWR VPWR
+ adder_inst.exp_larger_r\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_69_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08940_ _01237_ _01238_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_75_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08871_ _01120_ _01169_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__nand2_1
XFILLER_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09423_ _01721_ _01557_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__nand2_1
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09354_ _01652_ _00888_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__nand2_1
XFILLER_13_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08305_ net122 net238 VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__nand2_1
X_09285_ _01567_ _01570_ _01565_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__a21oi_2
X_08236_ net143 net221 VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__nand2_1
X_08167_ _00465_ _07784_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__nand2_1
XFILLER_119_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08098_ net143 net214 VGND VGND VPWR VPWR _07869_ sky130_fd_sc_hd__nand2_1
XFILLER_79_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10060_ _02358_ _02059_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__nand2_1
XFILLER_0_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_13750_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r multiplier_inst.is_nan_r VGND
+ VGND VPWR VPWR _06030_ sky130_fd_sc_hd__o21ba_1
XFILLER_90_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10962_ net221 VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__inv_2
XFILLER_43_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_12701_ _04981_ _04989_ _04999_ VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__nand3_1
X_13681_ adder_inst.exp_a_r\[7\] _05972_ VGND VGND VPWR VPWR _05973_ sky130_fd_sc_hd__nor2_1
XFILLER_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15420_ _07644_ _07638_ _07604_ VGND VGND VPWR VPWR _07646_ sky130_fd_sc_hd__mux2_1
X_10893_ _03190_ _03191_ VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__nand2_1
XFILLER_31_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_12632_ _04930_ _04728_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__nand2_1
X_15351_ _02972_ _07553_ _07557_ _07558_ _07578_ VGND VGND VPWR VPWR _07579_ sky130_fd_sc_hd__o221a_1
X_12563_ _04848_ _04861_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__nand2_1
X_15282_ _07518_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__buf_1
X_14302_ _06542_ _06446_ VGND VGND VPWR VPWR _06543_ sky130_fd_sc_hd__nand2_1
X_12494_ _04791_ _04778_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__nand2b_1
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11514_ _03183_ _03810_ _03812_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__o21ai_1
X_14233_ _06473_ VGND VGND VPWR VPWR _06474_ sky130_fd_sc_hd__clkbuf_4
X_11445_ net106 net232 VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__nand2_1
XFILLER_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14164_ _05904_ _05910_ _05901_ VGND VGND VPWR VPWR _06406_ sky130_fd_sc_hd__a21o_1
X_11376_ _03671_ _03674_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__nand2_1
X_14095_ _06078_ _06112_ _06108_ _06077_ VGND VGND VPWR VPWR _06352_ sky130_fd_sc_hd__o22a_1
XFILLER_98_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10327_ _02622_ _02621_ VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__nor2_1
X_13115_ _04870_ _05413_ VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__or2_1
X_10258_ _02556_ _02555_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_111_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_13046_ _05344_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__inv_2
XFILLER_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10189_ _02475_ _02293_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__nand2_1
XFILLER_66_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_14997_ _07239_ _07240_ _06000_ VGND VGND VPWR VPWR _07241_ sky130_fd_sc_hd__a21o_1
XFILLER_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13948_ _06194_ adder_inst.sum_raw_r\[5\] adder_inst.sum_raw_r\[4\] _06195_ _06218_
+ VGND VGND VPWR VPWR _06219_ sky130_fd_sc_hd__o221a_1
XFILLER_81_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13879_ net253 _06100_ _06147_ _06151_ _06153_ VGND VGND VPWR VPWR _06154_ sky130_fd_sc_hd__a32o_1
X_15618_ net289 VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__inv_2
X_15549_ net269 VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__inv_2
X_09070_ _07877_ _07888_ _01368_ _07890_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__a2bb2oi_1
X_08021_ net197 net169 VGND VGND VPWR VPWR _07792_ sky130_fd_sc_hd__nand2_1
XFILLER_115_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09972_ _02270_ _02082_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__nor2_1
XFILLER_103_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08923_ _01221_ _00946_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__nand2_1
XFILLER_111_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08854_ _01152_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__inv_2
XFILLER_69_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08785_ _01082_ _01083_ _01079_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__nand3_1
XFILLER_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09406_ _01578_ _01563_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__nand2_1
X_09337_ _01635_ VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_23_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09268_ _01566_ _01141_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08219_ _00517_ _00491_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__nand2_1
X_09199_ _01495_ _01491_ _01492_ VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__nand3_1
XFILLER_4_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11230_ _03515_ _03520_ _03528_ VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__nand3_1
XFILLER_20_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11161_ _03457_ _03459_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__nand2_1
XFILLER_96_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10112_ _02406_ _02410_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__nand2_1
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11092_ _03389_ _03390_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__nand2_1
Xhold40 adder_inst.exp_b\[7\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
X_10043_ _02318_ _02317_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__nor2_1
X_14920_ _07158_ _07141_ VGND VGND VPWR VPWR _07160_ sky130_fd_sc_hd__nand2_1
Xhold51 adder_inst.exp_b\[3\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 multiplier_inst.exp_final_r\[3\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14851_ _07087_ _06946_ VGND VGND VPWR VPWR _07088_ sky130_fd_sc_hd__nand2_1
XFILLER_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold62 adder_inst.i_b\[19\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_48_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold84 add_res\[22\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 add_res\[31\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
X_13802_ _06076_ VGND VGND VPWR VPWR _06077_ sky130_fd_sc_hd__inv_2
XFILLER_75_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_14782_ adder_inst.sign_b_r adder_inst.sign_a_r _07021_ VGND VGND VPWR VPWR _07022_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11994_ _04143_ _04135_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__nand2_1
X_13733_ adder_inst.is_nan_r VGND VGND VPWR VPWR _06018_ sky130_fd_sc_hd__inv_2
XFILLER_71_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10945_ _03242_ _03239_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__nand2_1
X_13664_ _05920_ _05905_ _05955_ VGND VGND VPWR VPWR _05957_ sky130_fd_sc_hd__nand3_1
X_10876_ _03174_ _03172_ VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15403_ _07628_ _05740_ VGND VGND VPWR VPWR _07629_ sky130_fd_sc_hd__or2_1
X_12615_ _04862_ _04910_ _04913_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__nand3_1
X_13595_ _05891_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[3\] sky130_fd_sc_hd__inv_2
X_15334_ _02789_ _07559_ VGND VGND VPWR VPWR _07560_ sky130_fd_sc_hd__xor2_1
XFILLER_61_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12546_ _04843_ _04801_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__nand2_1
X_15265_ _07491_ VGND VGND VPWR VPWR _07507_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_12477_ _04775_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__inv_2
X_14216_ _06399_ _06414_ _06456_ VGND VGND VPWR VPWR _06457_ sky130_fd_sc_hd__o21ai_1
X_15196_ _07450_ _07178_ VGND VGND VPWR VPWR _07451_ sky130_fd_sc_hd__nand2_1
XANTENNA_4 net110 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11428_ _03725_ _03726_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__nand2_1
X_14147_ net103 VGND VGND VPWR VPWR _06394_ sky130_fd_sc_hd__inv_2
X_11359_ _03483_ _03484_ _03481_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__nand3_1
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14078_ _06336_ VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_72_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13029_ _05326_ _05294_ VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__nand2_1
XFILLER_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08570_ _00685_ VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__inv_2
XFILLER_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09122_ _01420_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__inv_2
X_09053_ _01351_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__inv_2
X_08004_ _07758_ _07759_ _07761_ VGND VGND VPWR VPWR _07775_ sky130_fd_sc_hd__nand3_1
XFILLER_1_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09955_ _02218_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__inv_2
XFILLER_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09886_ _02168_ _02178_ _02184_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__nand3_1
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08906_ _01203_ _01204_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__nand2_1
XFILLER_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08837_ _01135_ _00981_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_28_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08768_ _01066_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__inv_2
XFILLER_38_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08699_ _00997_ _00806_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_675 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10730_ net191 net155 VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__nand2_1
X_10661_ _02845_ _02892_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__nand2_1
XFILLER_41_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12400_ net186 net137 VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__nand2_1
X_10592_ _02829_ _02840_ _02837_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__a21boi_1
X_13380_ _05663_ _05678_ VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__nand2_1
X_12331_ _01042_ _04629_ _04617_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_97_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_15050_ _06788_ _06777_ _06776_ VGND VGND VPWR VPWR _07297_ sky130_fd_sc_hd__o21a_1
X_12262_ net187 net129 VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__nand2_1
X_14001_ _06192_ _06193_ _06266_ VGND VGND VPWR VPWR _06267_ sky130_fd_sc_hd__and3_1
X_11213_ _03508_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__nand2_1
XFILLER_5_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12193_ _04435_ _04491_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__nor2_1
Xoutput85 net85 VGND VGND VPWR VPWR o_res[25] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR o_res[15] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11144_ _03442_ _03271_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__nand2_1
X_15952_ clknet_leaf_5_clk net327 _00200_ VGND VGND VPWR VPWR adder_inst.man_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
Xoutput96 net96 VGND VGND VPWR VPWR o_res[6] sky130_fd_sc_hd__buf_2
X_11075_ _03371_ _03373_ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__nand2_1
X_10026_ _02322_ _02324_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__nand2_1
X_14903_ _07140_ _07141_ VGND VGND VPWR VPWR _07142_ sky130_fd_sc_hd__nand2_1
XFILLER_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_15883_ clknet_leaf_6_clk net16 _00131_ VGND VGND VPWR VPWR adder_inst.exp_a\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_76_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_14834_ _06913_ _06933_ _06926_ VGND VGND VPWR VPWR _07070_ sky130_fd_sc_hd__a21bo_1
X_14765_ _07004_ _06726_ VGND VGND VPWR VPWR _07005_ sky130_fd_sc_hd__nand2_1
X_11977_ _04271_ _04275_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__or2_1
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13716_ adder_inst.i_b\[1\] adder_inst.i_b\[2\] adder_inst.i_b\[4\] adder_inst.i_b\[7\]
+ VGND VGND VPWR VPWR _06004_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_106_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10928_ _03225_ _03223_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__nand2_1
XFILLER_17_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_14696_ _06934_ _06700_ _06935_ VGND VGND VPWR VPWR _06936_ sky130_fd_sc_hd__nand3_1
XFILLER_32_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_13647_ _05928_ _05879_ VGND VGND VPWR VPWR _05941_ sky130_fd_sc_hd__nor2_1
X_10859_ _07223_ _01304_ VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__nor2_1
X_13578_ _05869_ _07149_ VGND VGND VPWR VPWR _05875_ sky130_fd_sc_hd__nand2_1
XFILLER_31_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_15317_ _02458_ _07540_ VGND VGND VPWR VPWR _07541_ sky130_fd_sc_hd__xnor2_1
X_12529_ net107 net203 VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__nand2_1
X_15248_ _07496_ VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15179_ _07432_ _07042_ VGND VGND VPWR VPWR _07433_ sky130_fd_sc_hd__nand2_1
XFILLER_113_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09740_ net154 net233 VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__nand2_1
.ends
