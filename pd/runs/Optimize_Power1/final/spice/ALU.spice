* NGSPICE file created from ALU.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_16 abstract view
.subckt sky130_fd_sc_hd__clkinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_2 abstract view
.subckt sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_4 abstract view
.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41ai_1 abstract view
.subckt sky130_fd_sc_hd__o41ai_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

.subckt ALU VGND VPWR clk i_a[0] i_a[10] i_a[11] i_a[12] i_a[13] i_a[14] i_a[15] i_a[16]
+ i_a[17] i_a[18] i_a[19] i_a[1] i_a[20] i_a[21] i_a[22] i_a[23] i_a[24] i_a[25] i_a[26]
+ i_a[27] i_a[28] i_a[29] i_a[2] i_a[30] i_a[31] i_a[3] i_a[4] i_a[5] i_a[6] i_a[7]
+ i_a[8] i_a[9] i_b[0] i_b[10] i_b[11] i_b[12] i_b[13] i_b[14] i_b[15] i_b[16] i_b[17]
+ i_b[18] i_b[19] i_b[1] i_b[20] i_b[21] i_b[22] i_b[23] i_b[24] i_b[25] i_b[26] i_b[27]
+ i_b[28] i_b[29] i_b[2] i_b[30] i_b[31] i_b[3] i_b[4] i_b[5] i_b[6] i_b[7] i_b[8]
+ i_b[9] i_vld o_res[0] o_res[10] o_res[11] o_res[12] o_res[13] o_res[14] o_res[15]
+ o_res[16] o_res[17] o_res[18] o_res[19] o_res[1] o_res[20] o_res[21] o_res[22] o_res[23]
+ o_res[24] o_res[25] o_res[26] o_res[27] o_res[28] o_res[29] o_res[2] o_res[30] o_res[31]
+ o_res[3] o_res[4] o_res[5] o_res[6] o_res[7] o_res[8] o_res[9] o_res_vld opcode
+ overflow rst
XFILLER_79_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7963_ adder_inst.sum_raw_r\[8\] net496 _3555_ _3556_ _3473_ VGND VGND VPWR VPWR
+ _3557_ sky130_fd_sc_hd__a221o_1
XFILLER_54_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6914_ _2529_ _2542_ _2543_ VGND VGND VPWR VPWR _2544_ sky130_fd_sc_hd__or3b_1
X_7894_ _3384_ net116 VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__and2_1
X_6845_ _2440_ _2449_ _2473_ VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_81_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6776_ _2401_ _2404_ _2405_ VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_61_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8515_ _4082_ _4087_ VGND VGND VPWR VPWR _4088_ sky130_fd_sc_hd__or2_1
X_9495_ clknet_leaf_18_clk net647 _0405_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
X_5727_ _1322_ _1324_ _1323_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__o21bai_1
X_8446_ net124 _3937_ VGND VGND VPWR VPWR _4019_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_107_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5658_ _1285_ _1286_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__nand3_1
X_8377_ net125 _3901_ _3904_ _3677_ net121 VGND VGND VPWR VPWR _3950_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_79_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5589_ _1217_ _1218_ net240 net465 VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__and4bb_1
X_4609_ net206 net364 _4378_ VGND VGND VPWR VPWR _4380_ sky130_fd_sc_hd__and3_1
XFILLER_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7328_ _2750_ _2767_ VGND VGND VPWR VPWR _2958_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_92_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7259_ _2882_ _2884_ VGND VGND VPWR VPWR _2889_ sky130_fd_sc_hd__nor2_1
XFILLER_104_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_116_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4960_ _0584_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__xor2_1
XFILLER_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4891_ _0518_ _0519_ _0515_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21o_1
X_6630_ _2247_ _2259_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__nand2_1
XFILLER_20_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6561_ _2117_ _2190_ _2189_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__o21a_1
X_8300_ _3678_ net129 net121 _3871_ VGND VGND VPWR VPWR _3873_ sky130_fd_sc_hd__and4_1
X_5512_ _1139_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__nand2_1
XFILLER_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9280_ clknet_leaf_16_clk adder_inst.sum_raw\[17\] _0190_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_8_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6492_ _2047_ _2121_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__nand2b_1
X_8231_ net138 _3751_ _3800_ net144 VGND VGND VPWR VPWR _3804_ sky130_fd_sc_hd__a211o_1
X_5443_ _1072_ _1071_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nand2b_1
X_8162_ net261 net402 net159 VGND VGND VPWR VPWR _3736_ sky130_fd_sc_hd__mux2_1
X_5374_ _0999_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__xnor2_1
XFILLER_113_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7113_ net241 net431 _2741_ _2742_ VGND VGND VPWR VPWR _2743_ sky130_fd_sc_hd__nand4_1
X_8093_ _3342_ _3656_ _3664_ VGND VGND VPWR VPWR _3667_ sky130_fd_sc_hd__nand3_1
Xfanout127 _3728_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_2
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_1
Xfanout138 net141 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_2
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout149 _3704_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_2
X_7044_ _2672_ _2673_ VGND VGND VPWR VPWR _2674_ sky130_fd_sc_hd__or2_1
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8995_ net517 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__inv_2
XFILLER_82_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7946_ adder_inst.sum_raw_r\[4\] net177 VGND VGND VPWR VPWR _3542_ sky130_fd_sc_hd__or2_1
XFILLER_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7877_ net202 _3388_ VGND VGND VPWR VPWR _3483_ sky130_fd_sc_hd__xnor2_1
XFILLER_42_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6828_ net317 net324 net468 net473 VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__and4_1
XFILLER_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6759_ _2386_ _2387_ _2381_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__a21bo_1
XFILLER_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9478_ clknet_leaf_20_clk net666 _0388_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
XFILLER_10_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8429_ net163 _3998_ _4001_ VGND VGND VPWR VPWR _4002_ sky130_fd_sc_hd__a21oi_1
XFILLER_12_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold170 multiplier_inst.man_final_r\[17\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5090_ _0717_ _0718_ _0688_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8780_ _2548_ _2551_ VGND VGND VPWR VPWR _4287_ sky130_fd_sc_hd__or2_1
X_7800_ net203 adder_inst.exp_larger_r\[1\] VGND VGND VPWR VPWR _3406_ sky130_fd_sc_hd__or2_2
X_5992_ _1284_ _1620_ _1621_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__nor3_1
XFILLER_24_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7731_ _3351_ _3352_ VGND VGND VPWR VPWR adder_inst.man_b\[23\] sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_65_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4943_ _0530_ _0566_ _0565_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21o_1
X_7662_ _3154_ _3156_ _3284_ _3285_ VGND VGND VPWR VPWR _3290_ sky130_fd_sc_hd__and4_1
X_9401_ clknet_leaf_6_clk net558 _0311_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_6613_ _2241_ _2242_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__nor2_1
X_4874_ net391 net269 net273 net385 VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a22o_1
XFILLER_60_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7593_ _1153_ _3222_ _1082_ VGND VGND VPWR VPWR _3223_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9332_ clknet_leaf_0_clk net574 _0242_ VGND VGND VPWR VPWR adder_inst.man_b_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_6544_ _2155_ _2157_ _2171_ _2172_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__or4_1
X_9263_ clknet_leaf_16_clk adder_inst.sum_raw\[0\] _0173_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[0\]
+ sky130_fd_sc_hd__dfrtp_4
X_6475_ net257 net480 _1950_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__a21oi_1
X_8214_ _4358_ net156 net154 net153 _3765_ VGND VGND VPWR VPWR _3787_ sky130_fd_sc_hd__o41a_1
XTAP_TAPCELL_ROW_76_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5426_ _1054_ _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__xnor2_1
X_9194_ net539 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_76_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8145_ net326 net464 net161 VGND VGND VPWR VPWR _3719_ sky130_fd_sc_hd__mux2_1
X_5357_ _0436_ _0985_ _0984_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__a21o_1
X_8076_ adder_inst.is_zero_r _3439_ VGND VGND VPWR VPWR _3652_ sky130_fd_sc_hd__nor2_1
X_5288_ _0833_ _0834_ _0848_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__o21a_1
XFILLER_59_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7027_ net224 net454 VGND VGND VPWR VPWR _2657_ sky130_fd_sc_hd__nand2_1
XFILLER_55_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8978_ net508 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__inv_2
XFILLER_55_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7929_ net200 adder_inst.sum_raw_r\[23\] adder_inst.sum_raw_r\[7\] VGND VGND VPWR
+ VPWR _3528_ sky130_fd_sc_hd__and3_1
XFILLER_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout491 net492 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__buf_2
Xfanout480 net483 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__buf_2
XFILLER_19_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4590_ net207 net346 _4359_ VGND VGND VPWR VPWR _4361_ sky130_fd_sc_hd__and3_1
X_6260_ _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__inv_2
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5211_ _0836_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__xnor2_1
X_6191_ net411 net416 net320 net321 VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__and4_1
XFILLER_69_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5142_ _0771_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__inv_2
XFILLER_84_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5073_ net232 net238 net397 net402 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_71_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8901_ net516 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
X_8832_ _3270_ _4323_ _4324_ VGND VGND VPWR VPWR multiplier_inst.man_final\[14\] sky130_fd_sc_hd__and3_1
XFILLER_37_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8763_ net721 _4272_ _0104_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__a21o_1
X_5975_ _1466_ _1468_ _1603_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__a211oi_1
XFILLER_40_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7714_ _3334_ _3337_ VGND VGND VPWR VPWR _3338_ sky130_fd_sc_hd__and2_1
X_8694_ net372 net163 _4026_ _4028_ VGND VGND VPWR VPWR _4247_ sky130_fd_sc_hd__o211a_1
X_4926_ _0535_ _0537_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__or3_4
X_7645_ adder_inst.exp_b_r\[3\] adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR _3273_
+ sky130_fd_sc_hd__xor2_2
X_4857_ _0485_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__and2b_1
X_7576_ _3031_ _3205_ VGND VGND VPWR VPWR _3206_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9315_ clknet_leaf_7_clk net603 _0225_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_2
X_6527_ _2077_ _2154_ _2153_ _2139_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__o211a_1
X_4788_ _4417_ _4552_ _4551_ VGND VGND VPWR VPWR _4559_ sky130_fd_sc_hd__a21o_1
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9246_ clknet_leaf_3_clk net40 _0156_ VGND VGND VPWR VPWR adder_inst.i_b\[16\] sky130_fd_sc_hd__dfrtp_1
X_6458_ _2083_ _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__xnor2_1
X_9177_ net534 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__inv_2
XFILLER_69_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6389_ _1947_ _1949_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__xnor2_1
X_5409_ _0980_ _0981_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__xnor2_1
X_8128_ _3279_ _3701_ VGND VGND VPWR VPWR _3702_ sky130_fd_sc_hd__xor2_1
XFILLER_75_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8059_ net491 _3634_ _3636_ _3637_ VGND VGND VPWR VPWR _3638_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_89_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xwire133 _1703_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
XFILLER_50_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5760_ net277 net424 _1181_ _1180_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__a31o_1
X_4711_ net352 net241 net247 net345 VGND VGND VPWR VPWR _4482_ sky130_fd_sc_hd__a22oi_1
XFILLER_30_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5691_ _1302_ _1304_ _1303_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__a21bo_1
X_7430_ _4481_ _3058_ VGND VGND VPWR VPWR _3060_ sky130_fd_sc_hd__nor2_1
XFILLER_30_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4642_ net371 net243 _4394_ _4395_ VGND VGND VPWR VPWR _4413_ sky130_fd_sc_hd__a22o_1
XFILLER_116_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4573_ net202 VGND VGND VPWR VPWR _4345_ sky130_fd_sc_hd__inv_2
X_7361_ _2758_ _2765_ VGND VGND VPWR VPWR _2991_ sky130_fd_sc_hd__nor2_1
XFILLER_116_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7292_ net210 net217 net448 net454 VGND VGND VPWR VPWR _2922_ sky130_fd_sc_hd__and4_1
X_6312_ _1844_ _1845_ _1860_ _1861_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__o22a_1
X_9100_ net525 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__inv_2
X_9031_ net518 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_73_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6243_ _1791_ _1872_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__and2_1
XFILLER_103_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6174_ _1800_ _1801_ _1802_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__or3_1
XFILLER_111_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5125_ _0459_ _0602_ _0626_ _0742_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_69_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5056_ _0682_ _0683_ _0603_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__a21oi_1
XFILLER_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8815_ _3204_ _4314_ VGND VGND VPWR VPWR multiplier_inst.man_final\[7\] sky130_fd_sc_hd__and2_1
XFILLER_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8746_ net715 net186 net184 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and3_1
XFILLER_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5958_ net224 net464 VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__nand2_1
X_4909_ net239 net407 net411 net233 VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a22o_1
XFILLER_21_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8677_ net106 _4231_ VGND VGND VPWR VPWR _4232_ sky130_fd_sc_hd__nand2_1
XFILLER_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5889_ _1516_ _1517_ _1518_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_51_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7628_ _4370_ _4391_ _3151_ _3251_ VGND VGND VPWR VPWR _3258_ sky130_fd_sc_hd__a31o_1
X_7559_ _2983_ _3188_ VGND VGND VPWR VPWR _3189_ sky130_fd_sc_hd__xnor2_2
XFILLER_106_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9229_ clknet_leaf_10_clk net25 _0139_ VGND VGND VPWR VPWR adder_inst.i_a\[31\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_95_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold41 adder_inst.i_b\[7\] VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 adder_inst.i_a\[4\] VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold63 adder_inst.i_a\[10\] VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 _0010_ VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold52 adder_inst.i_a\[12\] VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold96 _0017_ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_63_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold85 _0025_ VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_5 net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6930_ _2559_ VGND VGND VPWR VPWR _2560_ sky130_fd_sc_hd__inv_2
XFILLER_47_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6861_ _2463_ _2465_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__xnor2_1
XFILLER_35_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6792_ _2419_ _2420_ _2421_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__or3_1
X_8600_ net180 _4164_ _4161_ VGND VGND VPWR VPWR _4165_ sky130_fd_sc_hd__a21oi_1
XFILLER_62_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5812_ _1439_ _1440_ _1435_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__a21o_1
XFILLER_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8531_ _3989_ _4103_ _4094_ VGND VGND VPWR VPWR _4104_ sky130_fd_sc_hd__a21o_1
X_5743_ _1370_ _1371_ _1356_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__a21o_1
X_8462_ net238 _3665_ VGND VGND VPWR VPWR _4035_ sky130_fd_sc_hd__or2_1
X_5674_ net374 net333 net339 net368 VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a22o_1
X_8393_ _3964_ _3965_ VGND VGND VPWR VPWR _3966_ sky130_fd_sc_hd__nand2b_1
X_7413_ _4484_ _4515_ _4531_ VGND VGND VPWR VPWR _3043_ sky130_fd_sc_hd__a21oi_1
X_4625_ net371 net242 _4394_ _4395_ VGND VGND VPWR VPWR _4396_ sky130_fd_sc_hd__nand4_1
X_7344_ _2968_ _2972_ VGND VGND VPWR VPWR _2974_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7275_ _2826_ _2903_ _2902_ VGND VGND VPWR VPWR _2905_ sky130_fd_sc_hd__a21o_1
X_9014_ net510 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
X_6226_ _1835_ _1839_ _1838_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__a21oi_1
XFILLER_112_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6157_ _1690_ _1786_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__and2b_1
XFILLER_111_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5108_ _0674_ _0681_ _0736_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nor3_1
XFILLER_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6088_ _1716_ _1717_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__nor2_1
XFILLER_45_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5039_ net355 net348 net285 net292 VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_56_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8729_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r net204 VGND VGND VPWR VPWR
+ _4269_ sky130_fd_sc_hd__nor3b_2
XTAP_TAPCELL_ROW_97_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput75 net75 VGND VGND VPWR VPWR o_res[16] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput86 net86 VGND VGND VPWR VPWR o_res[26] sky130_fd_sc_hd__buf_2
Xoutput97 net97 VGND VGND VPWR VPWR o_res[7] sky130_fd_sc_hd__buf_2
XFILLER_48_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5390_ _0987_ _1013_ _0986_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a21boi_1
Xfanout309 adder_inst.man_b_r\[6\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_2
X_7060_ _2687_ _2688_ _2689_ VGND VGND VPWR VPWR _2690_ sky130_fd_sc_hd__or3_1
X_6011_ _1640_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__inv_2
XFILLER_67_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7962_ adder_inst.sum_raw_r\[7\] _4341_ net177 adder_inst.sum_raw_r\[6\] net198 VGND
+ VGND VPWR VPWR _3556_ sky130_fd_sc_hd__o221a_1
X_6913_ _2517_ _2528_ VGND VGND VPWR VPWR _2543_ sky130_fd_sc_hd__or2_1
XFILLER_54_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7893_ adder_inst.is_nan_r net204 _3497_ _3498_ VGND VGND VPWR VPWR _3499_ sky130_fd_sc_hd__and4b_1
XFILLER_35_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6844_ _2440_ _2449_ _2473_ VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_81_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6775_ _2350_ _2373_ _2390_ _2400_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__o211a_1
XFILLER_22_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8514_ _4083_ _4084_ _4086_ VGND VGND VPWR VPWR _4087_ sky130_fd_sc_hd__o21ai_2
X_9494_ clknet_leaf_18_clk net630 _0404_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_61_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5726_ _1328_ _1333_ _1327_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a21bo_1
X_8445_ net127 _4013_ _4016_ net123 VGND VGND VPWR VPWR _4018_ sky130_fd_sc_hd__o31a_1
XFILLER_108_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5657_ net387 net332 net338 net381 VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__a22o_1
X_8376_ net257 net170 VGND VGND VPWR VPWR _3949_ sky130_fd_sc_hd__nor2_1
X_5588_ net252 net453 net459 net245 VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a22oi_1
X_4608_ net206 net364 _4378_ VGND VGND VPWR VPWR _4379_ sky130_fd_sc_hd__a21oi_1
X_7327_ _2954_ _2955_ VGND VGND VPWR VPWR _2957_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7258_ _2886_ _2887_ VGND VGND VPWR VPWR _2888_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_5_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6209_ _1740_ _1837_ _1836_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__a21o_1
XFILLER_98_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7189_ _0894_ _2805_ _2818_ VGND VGND VPWR VPWR _2819_ sky130_fd_sc_hd__or3b_2
XFILLER_100_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4890_ _0515_ _0518_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nand3_1
XFILLER_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6560_ _2040_ _2116_ _2115_ _2112_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_30_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5511_ _1128_ _1138_ _0750_ _0752_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__a211o_1
X_6491_ _2117_ _2119_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__xor2_2
X_8230_ net139 _3712_ _3802_ net142 VGND VGND VPWR VPWR _3803_ sky130_fd_sc_hd__a211o_1
X_5442_ _1006_ _1008_ _1005_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__o21ba_1
XFILLER_8_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8161_ net175 _3680_ net155 _3699_ _3734_ VGND VGND VPWR VPWR _3735_ sky130_fd_sc_hd__a41o_1
X_5373_ _1000_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__nor2_1
X_8092_ _3342_ _3664_ VGND VGND VPWR VPWR _3666_ sky130_fd_sc_hd__nand2_1
X_7112_ net253 net420 net425 net247 VGND VGND VPWR VPWR _2742_ sky130_fd_sc_hd__a22o_1
Xfanout128 net131 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_2
Xfanout106 net107 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_4
Xfanout117 _3499_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_2
X_7043_ _2655_ _2656_ _2671_ VGND VGND VPWR VPWR _2673_ sky130_fd_sc_hd__o21a_1
Xfanout139 net141 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_2
XFILLER_86_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8994_ net516 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__inv_2
XFILLER_82_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7945_ _3540_ _3541_ net115 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__o21a_1
XFILLER_70_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7876_ adder_inst.exp_larger_r\[6\] _3390_ VGND VGND VPWR VPWR _3482_ sky130_fd_sc_hd__xor2_1
XFILLER_23_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6827_ _2422_ _2451_ _2456_ VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__and3_1
X_6758_ _2381_ _2386_ _2387_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__nand3_1
XFILLER_10_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6689_ _2295_ _2301_ _2300_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__a21oi_1
X_5709_ net414 net293 _1166_ _1164_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__a31o_1
X_9477_ clknet_leaf_20_clk net643 _0387_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
X_8428_ net423 net163 VGND VGND VPWR VPWR _4001_ sky130_fd_sc_hd__nor2_1
X_8359_ net434 _3929_ net163 VGND VGND VPWR VPWR _3932_ sky130_fd_sc_hd__mux2_1
Xhold171 multiplier_inst.is_nan_r VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
Xhold160 add_res\[24\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5991_ _1618_ _1619_ _1510_ _1513_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__a211oi_1
X_7730_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] adder_inst.exp_b\[3\] adder_inst.exp_b\[2\]
+ VGND VGND VPWR VPWR _3352_ sky130_fd_sc_hd__or4_1
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4942_ _0568_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nand2b_1
X_7661_ _3280_ _3281_ net103 _3272_ VGND VGND VPWR VPWR _3289_ sky130_fd_sc_hd__and4bb_1
X_9400_ clknet_leaf_6_clk net573 _0310_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_6612_ _2158_ _2173_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__xnor2_1
X_4873_ net385 net391 net269 net273 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__and4_1
X_7592_ _1156_ _3214_ _1115_ _1135_ VGND VGND VPWR VPWR _3222_ sky130_fd_sc_hd__a211o_1
XFILLER_20_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6543_ _2171_ _2172_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__nor2_1
X_9331_ clknet_leaf_0_clk net559 _0241_ VGND VGND VPWR VPWR adder_inst.man_b_r\[9\]
+ sky130_fd_sc_hd__dfrtp_4
X_9262_ clknet_leaf_12_clk net66 _0172_ VGND VGND VPWR VPWR opcode_stage1 sky130_fd_sc_hd__dfrtp_1
X_6474_ _2027_ _2102_ _2101_ _2080_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__a211oi_2
X_8213_ _4358_ net156 net154 net153 _3762_ VGND VGND VPWR VPWR _3786_ sky130_fd_sc_hd__o41a_1
X_5425_ net209 net417 VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9193_ net544 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_76_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8144_ _3714_ _3717_ net144 VGND VGND VPWR VPWR _3718_ sky130_fd_sc_hd__mux2_1
X_5356_ _0436_ _0984_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nand3_1
X_8075_ _3628_ _3651_ net205 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__o21a_1
XFILLER_99_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5287_ _0896_ _0916_ _0810_ _0876_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a211o_1
XFILLER_59_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7026_ _2652_ _2653_ _2654_ VGND VGND VPWR VPWR _2656_ sky130_fd_sc_hd__a21oi_1
XFILLER_74_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8977_ net511 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7928_ adder_inst.sum_raw_r\[6\] net195 net176 adder_inst.sum_raw_r\[5\] net189 VGND
+ VGND VPWR VPWR _3527_ sky130_fd_sc_hd__o221a_1
X_7859_ net203 _3462_ _3464_ VGND VGND VPWR VPWR _3465_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_13_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout492 adder_inst.sum_raw_r\[21\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_2
Xfanout481 net483 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__buf_2
Xfanout470 adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__buf_2
XFILLER_65_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5210_ _0837_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nor2_1
XFILLER_89_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6190_ net422 net311 VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__nand2_1
XFILLER_96_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5141_ _0752_ _0753_ _0766_ _0769_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__o211a_1
X_5072_ _0697_ _0698_ _0699_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8900_ net513 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__inv_2
XFILLER_37_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8831_ _3235_ _3238_ _3241_ net102 VGND VGND VPWR VPWR _4324_ sky130_fd_sc_hd__or4b_1
XFILLER_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8762_ net718 _4272_ _0104_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__a21o_1
X_7713_ net114 _3335_ VGND VGND VPWR VPWR _3337_ sky130_fd_sc_hd__nand2_1
X_5974_ _1586_ _1587_ _1602_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__o21a_1
X_8693_ _4109_ net106 net180 VGND VGND VPWR VPWR _4246_ sky130_fd_sc_hd__o21ai_1
X_4925_ _0549_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__xnor2_1
XFILLER_40_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7644_ _3157_ net103 VGND VGND VPWR VPWR multiplier_inst.exp_final\[0\] sky130_fd_sc_hd__xnor2_1
X_4856_ net385 net268 net275 net379 VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a22o_1
X_7575_ _0976_ _3200_ VGND VGND VPWR VPWR _3205_ sky130_fd_sc_hd__nor2_1
XFILLER_20_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9314_ clknet_leaf_10_clk net562 _0224_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_6526_ _2139_ _2153_ _2154_ _2077_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__a211o_1
X_4787_ _4554_ _4557_ VGND VGND VPWR VPWR _4558_ sky130_fd_sc_hd__nand2b_1
XFILLER_106_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9245_ clknet_leaf_0_clk net39 _0155_ VGND VGND VPWR VPWR adder_inst.i_b\[15\] sky130_fd_sc_hd__dfrtp_1
X_6457_ _2084_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__nor2_1
X_6388_ _2012_ _2016_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__xnor2_1
X_9176_ net529 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__inv_2
X_5408_ _1027_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__nor2_1
X_8127_ _3653_ _3658_ net162 VGND VGND VPWR VPWR _3701_ sky130_fd_sc_hd__mux2_1
X_5339_ _0960_ _0967_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__nor3_1
XFILLER_102_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8058_ _4347_ _3408_ _3404_ VGND VGND VPWR VPWR _3637_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_89_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7009_ _2583_ _2638_ VGND VGND VPWR VPWR _2639_ sky130_fd_sc_hd__and2b_1
XFILLER_28_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xwire134 _1507_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
XFILLER_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4710_ net352 net345 net241 net247 VGND VGND VPWR VPWR _4481_ sky130_fd_sc_hd__and4_1
X_5690_ _1308_ _1313_ _1307_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__a21bo_1
X_4641_ net360 net262 _4410_ _4398_ net274 VGND VGND VPWR VPWR _4412_ sky130_fd_sc_hd__a32o_1
XFILLER_30_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4572_ net489 VGND VGND VPWR VPWR _4344_ sky130_fd_sc_hd__inv_2
X_7360_ _2738_ _2771_ _2769_ VGND VGND VPWR VPWR _2990_ sky130_fd_sc_hd__o21ai_1
X_7291_ _2920_ VGND VGND VPWR VPWR _2921_ sky130_fd_sc_hd__inv_2
X_6311_ _1924_ _1925_ _1939_ _1940_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__nand4_4
XFILLER_116_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9030_ net517 VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__inv_2
XFILLER_89_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6242_ _1790_ _1870_ _1871_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__and3_1
XFILLER_97_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6173_ _1800_ _1801_ _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__nor3_1
XFILLER_69_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5124_ _0661_ _0746_ _0748_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__o21a_1
X_5055_ _0614_ _0621_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__and2_1
XFILLER_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8814_ _3199_ _3203_ VGND VGND VPWR VPWR _4314_ sky130_fd_sc_hd__or2_1
XFILLER_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8745_ net675 net186 net184 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and3_1
X_5957_ _1583_ _1584_ _1585_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8676_ _4048_ _4055_ _4058_ _4216_ _4049_ VGND VGND VPWR VPWR _4231_ sky130_fd_sc_hd__a221oi_2
X_4908_ net233 net239 net407 net411 VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_23_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7627_ net110 _3230_ _3256_ VGND VGND VPWR VPWR _3257_ sky130_fd_sc_hd__o21ai_2
XFILLER_21_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5888_ net350 net333 net340 net344 VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_51_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4839_ net348 _0466_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a21bo_1
XFILLER_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7558_ _3003_ _3174_ _3002_ VGND VGND VPWR VPWR _3188_ sky130_fd_sc_hd__o21ba_1
X_6509_ _2061_ _2137_ _2138_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__nand3_2
X_7489_ _3117_ _3118_ VGND VGND VPWR VPWR _3119_ sky130_fd_sc_hd__nand2_1
X_9228_ clknet_leaf_6_clk net24 _0138_ VGND VGND VPWR VPWR adder_inst.exp_a\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_107_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9159_ net547 VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__inv_2
XFILLER_96_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold20 adder_inst.exp_b\[7\] VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold31 adder_inst.i_b\[14\] VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold64 adder_inst.exp_a\[5\] VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 adder_inst.exp_a\[6\] VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 adder_inst.i_b\[12\] VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold86 multiplier_inst.exp_final_r\[3\] VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 add_res\[21\] VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 add_res\[18\] VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_6 net225 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6860_ _2472_ _2489_ VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__nand2_1
XFILLER_34_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6791_ net336 net456 net341 net451 VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__a22oi_2
X_5811_ _1435_ _1439_ _1440_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__and3_1
X_8530_ _3996_ _4004_ _4010_ _4102_ _3995_ VGND VGND VPWR VPWR _4103_ sky130_fd_sc_hd__a221o_1
X_5742_ _1356_ _1370_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__nand3_2
X_8461_ net150 _3844_ _3845_ net126 net123 VGND VGND VPWR VPWR _4034_ sky130_fd_sc_hd__o2111a_1
X_5673_ net369 net374 net332 net339 VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nand4_1
X_8392_ _3962_ _3963_ VGND VGND VPWR VPWR _3965_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7412_ _3040_ _3041_ VGND VGND VPWR VPWR _3042_ sky130_fd_sc_hd__xor2_1
X_4624_ net365 net249 net256 net360 VGND VGND VPWR VPWR _4395_ sky130_fd_sc_hd__a22o_1
XFILLER_116_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7343_ _2968_ _2972_ VGND VGND VPWR VPWR _2973_ sky130_fd_sc_hd__nand2b_1
XFILLER_89_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9013_ net510 VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__inv_2
X_7274_ _2826_ _2902_ _2903_ VGND VGND VPWR VPWR _2904_ sky130_fd_sc_hd__nand3_1
X_6225_ _1852_ _1853_ _1854_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__nand3_2
X_6156_ net244 net478 _1688_ _1689_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__a22o_1
XFILLER_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5107_ _0674_ _0681_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__o21a_1
XFILLER_57_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6087_ _1622_ _1623_ _1713_ _1715_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__o211a_1
X_5038_ _0665_ _0666_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_56_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8728_ adder_inst.exp_a_r\[7\] adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR adder_inst.exp_larger\[7\]
+ sky130_fd_sc_hd__or2_1
XFILLER_80_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6989_ net403 net282 net288 net394 VGND VGND VPWR VPWR _2619_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_36_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8659_ _3967_ _4214_ _4215_ VGND VGND VPWR VPWR _4216_ sky130_fd_sc_hd__a21bo_1
XFILLER_21_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput76 net76 VGND VGND VPWR VPWR o_res[17] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput87 net87 VGND VGND VPWR VPWR o_res[27] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR o_res[8] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6010_ _1299_ _1638_ _1639_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7961_ adder_inst.sum_raw_r\[5\] net188 VGND VGND VPWR VPWR _3555_ sky130_fd_sc_hd__or2_1
XFILLER_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7892_ adder_inst.is_zero_r adder_inst.is_inf_r VGND VGND VPWR VPWR _3498_ sky130_fd_sc_hd__nor2_1
X_6912_ _2538_ _2540_ _2541_ VGND VGND VPWR VPWR _2542_ sky130_fd_sc_hd__nand3_1
XFILLER_54_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6843_ _2470_ _2471_ _2467_ VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_81_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6774_ _2402_ _2403_ VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_444 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8513_ _4083_ _4085_ VGND VGND VPWR VPWR _4086_ sky130_fd_sc_hd__nand2_1
X_9493_ clknet_leaf_18_clk net639 _0403_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_61_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5725_ _1209_ _1352_ _1353_ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__nand4_2
XFILLER_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8444_ net129 _3858_ _3939_ net124 VGND VGND VPWR VPWR _4017_ sky130_fd_sc_hd__a211o_1
X_5656_ net393 net328 VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and2_1
X_4607_ _4376_ _4377_ VGND VGND VPWR VPWR _4378_ sky130_fd_sc_hd__nor2_1
X_8375_ _3936_ _3947_ VGND VGND VPWR VPWR _3948_ sky130_fd_sc_hd__or2_1
X_5587_ net245 net252 net453 net459 VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__and4_1
XFILLER_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7326_ _2955_ _2954_ VGND VGND VPWR VPWR _2956_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_92_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7257_ _0974_ _2801_ _2881_ _2885_ VGND VGND VPWR VPWR _2887_ sky130_fd_sc_hd__a211o_1
XFILLER_104_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6208_ _1740_ _1836_ _1837_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__and3_1
X_7188_ _2808_ _2815_ _2816_ _2807_ VGND VGND VPWR VPWR _2818_ sky130_fd_sc_hd__a31o_1
X_6139_ _1760_ _1765_ _1767_ _1768_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__a211oi_2
XFILLER_93_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_39_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5510_ _0664_ _0667_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__nor2_1
XFILLER_9_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6490_ _2117_ _2119_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__nand2_1
X_5441_ _1068_ _1069_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_57_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8160_ _3733_ VGND VGND VPWR VPWR _3734_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_78_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5372_ _1000_ _1001_ net226 net402 VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__and4bb_1
X_8091_ _3341_ _3663_ VGND VGND VPWR VPWR _3665_ sky130_fd_sc_hd__nor2_2
X_7111_ net247 net253 net420 net425 VGND VGND VPWR VPWR _2741_ sky130_fd_sc_hd__nand4_1
XFILLER_101_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout107 _4114_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_2
Xfanout129 net131 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_2
XFILLER_86_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7042_ _2655_ _2656_ _2671_ VGND VGND VPWR VPWR _2672_ sky130_fd_sc_hd__nor3_1
XFILLER_99_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8993_ net516 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_66_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7944_ net484 adder_inst.sum_raw_r\[10\] _3538_ _3539_ VGND VGND VPWR VPWR _3541_
+ sky130_fd_sc_hd__a22o_1
XFILLER_70_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7875_ _3435_ _3479_ _3480_ VGND VGND VPWR VPWR _3481_ sky130_fd_sc_hd__or3_1
XFILLER_63_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6826_ _2453_ _2454_ _2452_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__o21bai_1
XFILLER_23_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6757_ _2326_ _2375_ _2380_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__a21o_1
XFILLER_11_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5708_ _1334_ _1335_ _1320_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__a21o_1
X_9476_ clknet_leaf_10_clk _0096_ _0386_ VGND VGND VPWR VPWR mul_res\[31\] sky130_fd_sc_hd__dfrtp_1
X_6688_ _2307_ _2317_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_75_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8427_ net170 _3998_ _3999_ VGND VGND VPWR VPWR _4000_ sky130_fd_sc_hd__a21o_1
X_5639_ _1261_ _1267_ _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__a21oi_2
X_8358_ net160 _3929_ _3930_ VGND VGND VPWR VPWR _3931_ sky130_fd_sc_hd__o21ai_1
Xhold161 _0016_ VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold150 multiplier_inst.exp_final_r\[0\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
X_7309_ _2856_ _2860_ VGND VGND VPWR VPWR _2939_ sky130_fd_sc_hd__nor2_1
Xhold172 multiplier_inst.exp_final_r\[5\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8289_ net138 _3771_ _3807_ net143 VGND VGND VPWR VPWR _3862_ sky130_fd_sc_hd__a211o_1
XFILLER_78_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5990_ _1510_ _1513_ _1618_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__o211a_4
XFILLER_91_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4941_ _0568_ _0569_ _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__or3_1
X_7660_ net114 _3286_ _3287_ VGND VGND VPWR VPWR _3288_ sky130_fd_sc_hd__a21boi_1
X_4872_ net259 net395 VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__nand2_1
XFILLER_60_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6611_ _2230_ _2240_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_43_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9330_ clknet_leaf_3_clk net577 _0240_ VGND VGND VPWR VPWR adder_inst.man_b_r\[8\]
+ sky130_fd_sc_hd__dfrtp_1
X_7591_ _3210_ _3213_ _3218_ _3220_ VGND VGND VPWR VPWR _3221_ sky130_fd_sc_hd__nor4_1
X_6542_ _2169_ _2170_ _2165_ _2167_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__o211a_1
X_9261_ clknet_leaf_10_clk net57 _0171_ VGND VGND VPWR VPWR adder_inst.i_b\[31\] sky130_fd_sc_hd__dfrtp_1
X_6473_ _2080_ _2101_ _2102_ _2027_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__o211a_2
X_9192_ net539 VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__inv_2
X_8212_ net149 net147 net140 _3761_ VGND VGND VPWR VPWR _3785_ sky130_fd_sc_hd__and4_1
X_5424_ _1052_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__nor2_1
X_8143_ _3715_ _3716_ net139 VGND VGND VPWR VPWR _3717_ sky130_fd_sc_hd__mux2_1
X_5355_ _0421_ _0422_ _0435_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__o21ai_1
X_8074_ adder_inst.is_zero_r _3443_ VGND VGND VPWR VPWR _3651_ sky130_fd_sc_hd__nor2_1
XFILLER_59_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5286_ _0896_ _0912_ _0913_ _0914_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__nand4_1
XFILLER_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7025_ _2652_ _2653_ _2654_ VGND VGND VPWR VPWR _2655_ sky130_fd_sc_hd__and3_1
XFILLER_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8976_ net511 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__inv_2
X_7927_ adder_inst.sum_raw_r\[4\] net493 _3521_ _3525_ _3414_ VGND VGND VPWR VPWR
+ _3526_ sky130_fd_sc_hd__a221o_1
XFILLER_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7858_ net498 _3445_ _3428_ VGND VGND VPWR VPWR _3464_ sky130_fd_sc_hd__o21a_1
X_6809_ _2388_ _2417_ _2432_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_83_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7789_ net202 adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _3395_ sky130_fd_sc_hd__or2_2
XFILLER_23_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9459_ clknet_leaf_19_clk _0077_ _0369_ VGND VGND VPWR VPWR mul_res\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout482 net483 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout493 net495 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__buf_2
XFILLER_19_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout471 net472 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__buf_2
Xfanout460 net464 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5140_ _0766_ _0769_ _0752_ _0753_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__a211oi_1
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5071_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__inv_2
XFILLER_56_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8830_ _3242_ net102 _3235_ VGND VGND VPWR VPWR _4323_ sky130_fd_sc_hd__a21bo_1
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8761_ net635 _4272_ _0104_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a21o_1
X_5973_ _1586_ _1587_ _1602_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__nor3_1
XFILLER_25_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7712_ _3335_ VGND VGND VPWR VPWR _3336_ sky130_fd_sc_hd__inv_2
X_4924_ _0552_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8692_ _4243_ _4244_ net106 VGND VGND VPWR VPWR _4245_ sky130_fd_sc_hd__o21a_1
XFILLER_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7643_ net103 _3272_ _3271_ _3155_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[1\]
+ sky130_fd_sc_hd__o2bb2a_1
X_4855_ net379 net385 net268 net274 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__and4_1
XFILLER_60_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7574_ _3199_ _3203_ VGND VGND VPWR VPWR _3204_ sky130_fd_sc_hd__nand2_2
X_4786_ _4554_ _4555_ _4556_ VGND VGND VPWR VPWR _4557_ sky130_fd_sc_hd__or3_1
XFILLER_20_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9313_ clknet_leaf_10_clk net561 _0223_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_2
X_6525_ _2139_ _2153_ _2154_ _2077_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__a211oi_1
XFILLER_20_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9244_ clknet_leaf_3_clk net38 _0154_ VGND VGND VPWR VPWR adder_inst.i_b\[14\] sky130_fd_sc_hd__dfrtp_1
X_6456_ _2084_ _2085_ net280 net475 VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__and4bb_1
X_9175_ net534 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__inv_2
X_6387_ _2016_ _2012_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__and2b_1
X_5407_ _1025_ _1026_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__and2_1
X_8126_ net156 _3694_ net153 VGND VGND VPWR VPWR _3700_ sky130_fd_sc_hd__or3_2
X_5338_ net152 _0875_ _0917_ _0959_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__o211a_1
X_8057_ net502 _4347_ _3401_ _3635_ _3398_ VGND VGND VPWR VPWR _3636_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_89_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7008_ _2615_ _2637_ VGND VGND VPWR VPWR _2638_ sky130_fd_sc_hd__xnor2_1
X_5269_ _0805_ _0897_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__nand3_2
XFILLER_56_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8959_ net532 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__inv_2
XFILLER_34_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout290 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_109_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4640_ net274 _4398_ _4410_ VGND VGND VPWR VPWR _4411_ sky130_fd_sc_hd__a21bo_1
XFILLER_30_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4571_ net493 VGND VGND VPWR VPWR _4343_ sky130_fd_sc_hd__inv_2
X_6310_ _1937_ _1938_ _1931_ _1934_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__a211o_1
XFILLER_115_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7290_ _2917_ _2918_ VGND VGND VPWR VPWR _2920_ sky130_fd_sc_hd__xor2_1
X_6241_ net255 net472 net479 net250 VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__a22o_1
X_6172_ net133 _1799_ _1798_ _1775_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__o211a_1
X_5123_ _0750_ _0751_ _0668_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o21a_1
XFILLER_84_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5054_ _0603_ _0682_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__and3_1
XFILLER_84_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8813_ _3194_ _3198_ VGND VGND VPWR VPWR multiplier_inst.man_final\[6\] sky130_fd_sc_hd__xnor2_1
XFILLER_111_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8744_ net674 net186 net184 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__and3_1
X_5956_ _1583_ _1584_ _1585_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__and3_1
X_8675_ _4050_ _4230_ VGND VGND VPWR VPWR adder_inst.sum_raw\[17\] sky130_fd_sc_hd__xnor2_1
X_4907_ _0522_ _0523_ _0534_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_23_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5887_ net350 net344 net334 net340 VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__nand4_1
X_4838_ adder_inst.man_a_r\[22\] net302 net306 net349 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__a22o_1
X_7626_ net110 _3255_ VGND VGND VPWR VPWR _3256_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_51_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4769_ _4474_ _4477_ _4538_ _4539_ VGND VGND VPWR VPWR _4540_ sky130_fd_sc_hd__o211ai_1
X_7557_ _2952_ _3186_ VGND VGND VPWR VPWR _3187_ sky130_fd_sc_hd__xor2_1
X_6508_ _2054_ _2055_ _2060_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__a21o_1
X_7488_ _3110_ _3113_ _3116_ VGND VGND VPWR VPWR _3118_ sky130_fd_sc_hd__or3_1
X_9227_ clknet_leaf_7_clk net22 _0137_ VGND VGND VPWR VPWR adder_inst.exp_a\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_107_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6439_ _2066_ _2068_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__and2b_1
X_9158_ net546 VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__inv_2
XFILLER_20_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8109_ _3303_ _3341_ _3663_ _3681_ VGND VGND VPWR VPWR _3683_ sky130_fd_sc_hd__or4_1
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9089_ net520 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__inv_2
Xhold32 adder_inst.i_b\[5\] VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 adder_inst.i_b\[9\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 adder_inst.i_a\[6\] VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_48_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold54 adder_inst.exp_a\[2\] VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 adder_inst.i_a\[21\] VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 adder_inst.i_b\[6\] VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 add_res\[30\] VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 _0013_ VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold98 _0009_ VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_104_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_7 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_20_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6790_ net330 net462 VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__nand2_1
X_5810_ _1437_ _1438_ _1436_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__a21bo_1
X_5741_ _1363_ _1364_ _1369_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21o_1
X_8460_ _4030_ _4032_ VGND VGND VPWR VPWR _4033_ sky130_fd_sc_hd__nand2_1
XFILLER_30_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7411_ net208 net384 _4527_ _4525_ VGND VGND VPWR VPWR _3041_ sky130_fd_sc_hd__a31o_1
X_5672_ net381 net328 VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__and2_1
X_8391_ _3962_ _3963_ VGND VGND VPWR VPWR _3964_ sky130_fd_sc_hd__nor2_1
X_4623_ net360 net365 net249 net256 VGND VGND VPWR VPWR _4394_ sky130_fd_sc_hd__nand4_1
X_7342_ _2969_ _2970_ VGND VGND VPWR VPWR _2972_ sky130_fd_sc_hd__xnor2_1
X_7273_ _2823_ _2824_ _2825_ VGND VGND VPWR VPWR _2903_ sky130_fd_sc_hd__a21o_1
XFILLER_116_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9012_ net509 VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__inv_2
X_6224_ _1782_ _1784_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6155_ net258 net466 _1783_ _1781_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__a31o_1
X_5106_ _0729_ _0734_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__xor2_1
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6086_ _1713_ _1715_ _1622_ _1623_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__a211oi_1
XFILLER_85_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5037_ _0666_ _0665_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_56_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8727_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] net169 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[6\] sky130_fd_sc_hd__mux2_1
XFILLER_15_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6988_ net394 net398 net282 net288 VGND VGND VPWR VPWR _2618_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_36_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5939_ _1545_ _1546_ _1568_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__and3_1
XFILLER_40_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8658_ _3954_ _3965_ _4012_ _4163_ _3955_ VGND VGND VPWR VPWR _4215_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_97_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8589_ _3925_ _4099_ _4115_ _3924_ VGND VGND VPWR VPWR _4155_ sky130_fd_sc_hd__o211a_1
X_7609_ _4370_ net136 _3151_ _3223_ _3233_ VGND VGND VPWR VPWR _3239_ sky130_fd_sc_hd__a311o_1
XFILLER_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput88 net88 VGND VGND VPWR VPWR o_res[28] sky130_fd_sc_hd__buf_2
XFILLER_95_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput77 net77 VGND VGND VPWR VPWR o_res[18] sky130_fd_sc_hd__buf_2
Xoutput99 net99 VGND VGND VPWR VPWR o_res[9] sky130_fd_sc_hd__buf_2
XFILLER_88_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7960_ net116 _3554_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__and2_1
X_6911_ net335 net341 net474 net482 VGND VGND VPWR VPWR _2541_ sky130_fd_sc_hd__and4_1
X_7891_ _3389_ _3496_ _3495_ VGND VGND VPWR VPWR _3497_ sky130_fd_sc_hd__a21boi_1
X_6842_ _2467_ _2470_ _2471_ VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__or3_1
XFILLER_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6773_ net291 net481 _2393_ _2396_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_33_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8512_ net349 net172 _4084_ VGND VGND VPWR VPWR _4085_ sky130_fd_sc_hd__a21o_1
X_9492_ clknet_leaf_18_clk net632 _0402_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_61_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5724_ _1193_ _1208_ _1207_ _1200_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__a211o_1
XFILLER_50_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8443_ net145 _3794_ _4014_ _4015_ net131 VGND VGND VPWR VPWR _4016_ sky130_fd_sc_hd__o221a_1
X_5655_ net381 net387 net332 net338 VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__nand4_1
X_8374_ _3945_ _3946_ VGND VGND VPWR VPWR _3947_ sky130_fd_sc_hd__nand2b_2
X_4606_ net352 net219 net358 net213 VGND VGND VPWR VPWR _4377_ sky130_fd_sc_hd__a22oi_1
XFILLER_116_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5586_ _1210_ _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__nand2b_1
XFILLER_7_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7325_ _2900_ _2908_ VGND VGND VPWR VPWR _2955_ sky130_fd_sc_hd__xnor2_1
XFILLER_89_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7256_ _2881_ _2885_ _0974_ _2801_ VGND VGND VPWR VPWR _2886_ sky130_fd_sc_hd__o211a_1
XFILLER_104_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7187_ _2815_ _2816_ VGND VGND VPWR VPWR _2817_ sky130_fd_sc_hd__and2_1
X_6207_ _1737_ _1739_ _1738_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__o21ai_1
XFILLER_98_670 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6138_ _1745_ _1747_ _1766_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__and3_1
X_6069_ _1671_ _1673_ _1698_ _1279_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__a211oi_2
XFILLER_38_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_103_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5440_ _1042_ _1061_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__a21o_1
XFILLER_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5371_ net237 net392 net397 net232 VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a22oi_1
X_8090_ _3327_ _3661_ _3662_ _3343_ _3326_ VGND VGND VPWR VPWR _3664_ sky130_fd_sc_hd__a311o_4
XTAP_TAPCELL_ROW_78_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7110_ net263 net420 _2627_ _2626_ VGND VGND VPWR VPWR _2740_ sky130_fd_sc_hd__a31o_1
XFILLER_113_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7041_ _2664_ _2669_ VGND VGND VPWR VPWR _2671_ sky130_fd_sc_hd__xnor2_1
XFILLER_101_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8992_ net517 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_38_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7943_ net200 adder_inst.sum_raw_r\[23\] adder_inst.sum_raw_r\[9\] VGND VGND VPWR
+ VPWR _3540_ sky130_fd_sc_hd__and3_1
XFILLER_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7874_ adder_inst.exp_larger_r\[1\] _3383_ _3474_ net486 VGND VGND VPWR VPWR _3480_
+ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_18_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6825_ _2452_ _2454_ VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__nor2_1
X_6756_ _2384_ _2385_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5707_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__inv_2
X_9475_ clknet_leaf_11_clk _0095_ _0385_ VGND VGND VPWR VPWR mul_res\[30\] sky130_fd_sc_hd__dfrtp_1
X_6687_ _2304_ _2306_ _2298_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__a21oi_1
X_8426_ net286 net170 VGND VGND VPWR VPWR _3999_ sky130_fd_sc_hd__nor2_1
X_5638_ _1220_ _1221_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__xnor2_1
X_8357_ net296 net168 VGND VGND VPWR VPWR _3930_ sky130_fd_sc_hd__or2_1
X_5569_ _1177_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_1
Xhold151 adder_inst.is_zero_a_r VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
Xhold162 multiplier_inst.man_final_r\[11\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 add_res\[6\] VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
X_7308_ _2894_ _2936_ VGND VGND VPWR VPWR _2938_ sky130_fd_sc_hd__xor2_1
X_8288_ net148 _3858_ _3860_ net127 VGND VGND VPWR VPWR _3861_ sky130_fd_sc_hd__a211o_1
Xhold173 multiplier_inst.man_final_r\[21\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
X_7239_ _2865_ _2867_ _2868_ VGND VGND VPWR VPWR _2869_ sky130_fd_sc_hd__nand3_1
XFILLER_104_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4940_ net255 net405 net411 net250 VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a22oi_1
X_4871_ _0480_ _0494_ _0499_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a21o_1
X_6610_ _2229_ _2238_ _2239_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__and3_1
X_7590_ net111 _3200_ _3201_ _3219_ VGND VGND VPWR VPWR _3220_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_43_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6541_ _2165_ _2167_ _2169_ _2170_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__a211oi_1
X_9260_ clknet_leaf_5_clk net56 _0170_ VGND VGND VPWR VPWR adder_inst.exp_b\[7\] sky130_fd_sc_hd__dfrtp_1
X_6472_ _2009_ _2010_ _2024_ _2025_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__a2bb2o_1
X_9191_ net547 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__inv_2
X_8211_ net140 _3761_ VGND VGND VPWR VPWR _3784_ sky130_fd_sc_hd__and2_1
X_5423_ net222 net408 net413 net216 VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a22oi_1
X_8142_ net319 adder_inst.man_a_r\[4\] net161 VGND VGND VPWR VPWR _3716_ sky130_fd_sc_hd__mux2_1
X_5354_ _0724_ _0982_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__o21a_1
XFILLER_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8073_ net204 _3650_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and2_1
X_5285_ _0896_ _0912_ _0913_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__and4_1
XFILLER_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7024_ _1574_ _1582_ _1581_ VGND VGND VPWR VPWR _2654_ sky130_fd_sc_hd__a21bo_1
XFILLER_101_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8975_ net511 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__inv_2
XFILLER_28_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7926_ adder_inst.sum_raw_r\[2\] _3405_ _3524_ adder_inst.sum_raw_r\[1\] _3522_ VGND
+ VGND VPWR VPWR _3525_ sky130_fd_sc_hd__o221a_1
XFILLER_82_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7857_ net492 net196 VGND VGND VPWR VPWR _3463_ sky130_fd_sc_hd__nand2_1
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6808_ _2434_ _2436_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7788_ net484 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3394_ sky130_fd_sc_hd__or2_2
XFILLER_23_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6739_ _2314_ _2367_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__xnor2_1
X_9458_ clknet_leaf_19_clk _0076_ _0368_ VGND VGND VPWR VPWR mul_res\[13\] sky130_fd_sc_hd__dfrtp_1
X_8409_ net268 net163 _3978_ _3981_ VGND VGND VPWR VPWR _3982_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_21_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9389_ clknet_leaf_11_clk adder_inst.exp_larger\[3\] _0299_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
Xfanout450 net451 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__buf_2
Xfanout461 net463 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__buf_2
Xfanout483 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__clkbuf_4
Xfanout472 net477 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__buf_2
Xfanout494 net495 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__buf_2
XFILLER_59_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5070_ _0697_ _0698_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__and3_1
XFILLER_96_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8760_ net692 _4272_ _0104_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a21o_1
XFILLER_92_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5972_ _1595_ _1600_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__xnor2_2
X_7711_ _3317_ _3333_ VGND VGND VPWR VPWR _3335_ sky130_fd_sc_hd__and2_1
XFILLER_64_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4923_ net209 net434 VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
XFILLER_52_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8691_ _4044_ _4231_ VGND VGND VPWR VPWR _4244_ sky130_fd_sc_hd__nor2_1
XFILLER_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7642_ _4354_ _3157_ VGND VGND VPWR VPWR _3272_ sky130_fd_sc_hd__nor2_1
X_4854_ net391 net260 VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand2_1
X_7573_ _3197_ _3202_ net111 VGND VGND VPWR VPWR _3203_ sky130_fd_sc_hd__mux2_1
X_4785_ net378 net249 net256 net371 VGND VGND VPWR VPWR _4556_ sky130_fd_sc_hd__a22oi_1
X_9312_ clknet_leaf_11_clk _0035_ _0222_ VGND VGND VPWR VPWR adder_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_4
X_6524_ _2064_ _2065_ _2076_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9243_ clknet_leaf_3_clk net37 _0153_ VGND VGND VPWR VPWR adder_inst.i_b\[13\] sky130_fd_sc_hd__dfrtp_1
X_6455_ net291 net463 net470 net286 VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__a22oi_1
X_9174_ net534 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__inv_2
X_6386_ _2013_ _2015_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__nor2_1
X_5406_ _1030_ _1031_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__xor2_1
XFILLER_114_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8125_ _3696_ _3697_ VGND VGND VPWR VPWR _3699_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5337_ _0964_ _0965_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__xor2_1
X_8056_ net502 net201 _3399_ VGND VGND VPWR VPWR _3635_ sky130_fd_sc_hd__nand3_1
XFILLER_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5268_ _0802_ _0803_ _0804_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__a21o_1
XFILLER_102_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7007_ _2635_ _2636_ VGND VGND VPWR VPWR _2637_ sky130_fd_sc_hd__and2_1
XFILLER_75_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5199_ _0825_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand2b_1
XFILLER_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8958_ net532 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__inv_2
XFILLER_28_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7909_ adder_inst.sum_raw_r\[0\] net497 _3472_ _3510_ VGND VGND VPWR VPWR _3511_
+ sky130_fd_sc_hd__a31o_1
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8889_ net508 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_26_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout280 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_109_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4570_ net491 VGND VGND VPWR VPWR _4342_ sky130_fd_sc_hd__inv_2
XFILLER_115_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6240_ net260 net472 _1868_ _1866_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__a31o_1
X_6171_ _1778_ _1796_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__nor2_1
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5122_ _0668_ _0750_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nor3_2
XFILLER_111_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5053_ _0674_ _0675_ _0680_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__o21bai_1
XFILLER_65_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8812_ _3191_ _4312_ _3194_ VGND VGND VPWR VPWR multiplier_inst.man_final\[5\] sky130_fd_sc_hd__o21ba_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8743_ net693 net186 net184 VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__and3_1
X_5955_ _1475_ _1483_ _1482_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__a21bo_1
XFILLER_25_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8674_ net180 _4224_ _4225_ _4228_ _4229_ VGND VGND VPWR VPWR _4230_ sky130_fd_sc_hd__o32a_1
X_4906_ _0522_ _0523_ _0534_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand3_1
XFILLER_21_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5886_ net356 net328 VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__and2_1
X_4837_ net349 _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__and2_1
X_7625_ _3076_ _3254_ VGND VGND VPWR VPWR _3255_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_51_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4768_ net120 _4537_ _4509_ VGND VGND VPWR VPWR _4539_ sky130_fd_sc_hd__o21bai_1
X_7556_ _2983_ _3004_ _3175_ _3023_ VGND VGND VPWR VPWR _3186_ sky130_fd_sc_hd__a31o_1
X_6507_ _2130_ _2135_ _2129_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__a21bo_1
X_7487_ _3113_ _3116_ _3110_ VGND VGND VPWR VPWR _3117_ sky130_fd_sc_hd__o21ai_1
X_4699_ _4468_ _4469_ VGND VGND VPWR VPWR _4470_ sky130_fd_sc_hd__nand2_1
X_9226_ clknet_leaf_6_clk net21 _0136_ VGND VGND VPWR VPWR adder_inst.exp_a\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6438_ net309 net444 net451 net301 VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__a22o_1
X_9157_ net545 VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_95_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8108_ _3304_ _3660_ _3303_ VGND VGND VPWR VPWR _3682_ sky130_fd_sc_hd__o21ba_1
X_6369_ net295 net451 _1997_ _1995_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__a31o_1
XFILLER_29_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9088_ net519 VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__inv_2
Xhold11 adder_inst.i_a\[2\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 adder_inst.i_a\[1\] VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold55 adder_inst.exp_a\[4\] VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 adder_inst.i_a\[18\] VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd3_1
X_8039_ net502 net500 VGND VGND VPWR VPWR _3623_ sky130_fd_sc_hd__nand2b_1
Xhold33 adder_inst.i_b\[19\] VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold88 _0023_ VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 add_res\[23\] VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 add_res\[22\] VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 adder_inst.i_a\[20\] VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_104_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_8 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5740_ _1363_ _1364_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__nand3_1
XFILLER_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7410_ _4534_ _3038_ VGND VGND VPWR VPWR _3040_ sky130_fd_sc_hd__xnor2_1
X_5671_ _1290_ _1292_ _1291_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__o21bai_1
X_8390_ net402 _3960_ net164 VGND VGND VPWR VPWR _3963_ sky130_fd_sc_hd__mux2_1
X_4622_ net136 _4392_ VGND VGND VPWR VPWR _4393_ sky130_fd_sc_hd__nand2_1
X_7341_ _2919_ _2927_ _2969_ VGND VGND VPWR VPWR _2971_ sky130_fd_sc_hd__o21ai_1
X_7272_ _2699_ _2707_ _2706_ VGND VGND VPWR VPWR _2902_ sky130_fd_sc_hd__a21o_1
XFILLER_116_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9011_ net518 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__inv_2
X_6223_ _1758_ _1846_ _1851_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__a21o_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6154_ _1781_ _1783_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__and2b_1
X_5105_ _0729_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__nand2_1
X_6085_ _1708_ _1713_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__nand3b_2
X_5036_ _0651_ _0653_ _0650_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_56_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6987_ net406 net278 VGND VGND VPWR VPWR _2617_ sky130_fd_sc_hd__nand2_1
X_8726_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] net169 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[5\] sky130_fd_sc_hd__mux2_1
XFILLER_53_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5938_ _1566_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_36_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8657_ _3988_ _4213_ _4200_ VGND VGND VPWR VPWR _4214_ sky130_fd_sc_hd__o21ai_1
X_5869_ _1498_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_97_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8588_ _3921_ _3923_ VGND VGND VPWR VPWR _4154_ sky130_fd_sc_hd__or2_1
X_7608_ _3217_ _3237_ net113 VGND VGND VPWR VPWR _3238_ sky130_fd_sc_hd__mux2_1
XFILLER_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7539_ net111 _3160_ _3168_ VGND VGND VPWR VPWR _3169_ sky130_fd_sc_hd__a21o_1
X_9209_ clknet_leaf_6_clk net3 _0119_ VGND VGND VPWR VPWR adder_inst.i_a\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_8_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput89 net89 VGND VGND VPWR VPWR o_res[29] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR o_res[19] sky130_fd_sc_hd__buf_2
XFILLER_103_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6910_ _2524_ _2539_ VGND VGND VPWR VPWR _2540_ sky130_fd_sc_hd__nor2_1
X_7890_ adder_inst.exp_larger_r\[0\] adder_inst.exp_larger_r\[6\] adder_inst.exp_larger_r\[7\]
+ net486 VGND VGND VPWR VPWR _3496_ sky130_fd_sc_hd__and4b_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6841_ _2431_ _2450_ _2466_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_81_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8511_ _3904_ _3979_ net125 VGND VGND VPWR VPWR _4084_ sky130_fd_sc_hd__and3b_1
X_6772_ _2393_ _2396_ net291 net481 VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_33_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9491_ clknet_leaf_18_clk net682 _0401_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_61_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5723_ _1350_ _1351_ _1316_ _1319_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__o211ai_2
XFILLER_31_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8442_ net137 _3723_ net144 VGND VGND VPWR VPWR _4015_ sky130_fd_sc_hd__o21ai_1
X_5654_ _1282_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__or2_1
X_8373_ _3942_ _3944_ VGND VGND VPWR VPWR _3946_ sky130_fd_sc_hd__nand2_1
X_4605_ net352 net210 net219 net359 VGND VGND VPWR VPWR _4376_ sky130_fd_sc_hd__and4_1
X_5585_ _1211_ _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__xnor2_1
X_7324_ _2712_ _2734_ _2711_ VGND VGND VPWR VPWR _2954_ sky130_fd_sc_hd__a21o_1
XFILLER_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7255_ _2882_ _2884_ VGND VGND VPWR VPWR _2885_ sky130_fd_sc_hd__and2_1
X_7186_ _2813_ _2814_ _2810_ VGND VGND VPWR VPWR _2816_ sky130_fd_sc_hd__a21o_1
X_6206_ _1820_ _1822_ _1821_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__o21bai_1
XFILLER_98_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6137_ _1745_ _1747_ _1766_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__a21oi_2
XFILLER_112_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6068_ _1269_ _1270_ _1278_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__o21a_1
X_5019_ _0646_ _0647_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__xor2_1
XFILLER_26_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8709_ _4069_ _4070_ VGND VGND VPWR VPWR _4260_ sky130_fd_sc_hd__and2_1
XFILLER_13_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5370_ net232 net237 net392 net397 VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__and4_1
XFILLER_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout109 net111 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_6
X_7040_ _2664_ _2669_ VGND VGND VPWR VPWR _2670_ sky130_fd_sc_hd__and2_1
XFILLER_113_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8991_ net516 VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__inv_2
XFILLER_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7942_ adder_inst.sum_raw_r\[8\] net195 _3463_ adder_inst.sum_raw_r\[7\] net189 VGND
+ VGND VPWR VPWR _3539_ sky130_fd_sc_hd__o221a_1
X_7873_ net489 _3476_ _3478_ net191 VGND VGND VPWR VPWR _3479_ sky130_fd_sc_hd__o211a_1
X_6824_ net456 net341 net461 net336 VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_18_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6755_ net313 net468 VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__nand2_1
X_9474_ clknet_leaf_11_clk _0093_ _0384_ VGND VGND VPWR VPWR mul_res\[29\] sky130_fd_sc_hd__dfrtp_1
X_5706_ _1320_ _1334_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__nand3_1
X_8425_ _3678_ _3842_ _3846_ _3728_ net121 VGND VGND VPWR VPWR _3998_ sky130_fd_sc_hd__a221o_1
X_6686_ _2261_ _2308_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__xnor2_2
X_5637_ _1265_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__nand2_1
X_8356_ _3677_ _3759_ _3775_ net126 net122 VGND VGND VPWR VPWR _3929_ sky130_fd_sc_hd__o221a_1
X_5568_ net277 net430 _1175_ _1176_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__o2bb2a_1
Xhold152 _0071_ VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
X_8287_ net145 _3797_ _3859_ net148 VGND VGND VPWR VPWR _3860_ sky130_fd_sc_hd__a211oi_1
Xhold141 _0028_ VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 multiplier_inst.man_final_r\[8\] VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dlygate4sd3_1
X_7307_ _2894_ _2936_ VGND VGND VPWR VPWR _2937_ sky130_fd_sc_hd__nor2_1
Xhold174 multiplier_inst.man_final_r\[19\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
X_5499_ _1119_ _1128_ _1106_ _1117_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a211oi_2
Xhold163 add_res\[7\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
X_7238_ _0953_ _2866_ _2832_ _2830_ VGND VGND VPWR VPWR _2868_ sky130_fd_sc_hd__o211ai_2
XFILLER_86_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7169_ _2797_ _2798_ VGND VGND VPWR VPWR _2799_ sky130_fd_sc_hd__nor2_4
XFILLER_18_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_21_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4870_ _0480_ _0494_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_15_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6540_ _2148_ _2150_ _2168_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__and3_1
XFILLER_20_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6471_ _2080_ _2081_ _2099_ _2100_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__and4bb_1
X_9190_ net546 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__inv_2
X_8210_ _3782_ _3783_ VGND VGND VPWR VPWR adder_inst.sum_raw\[0\] sky130_fd_sc_hd__nand2_1
X_5422_ net216 net222 net408 net412 VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and4_1
X_8141_ net313 net452 net161 VGND VGND VPWR VPWR _3715_ sky130_fd_sc_hd__mux2_1
X_5353_ _4409_ _4411_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__xor2_1
X_8072_ _3643_ _3648_ _3649_ _3628_ VGND VGND VPWR VPWR _3650_ sky130_fd_sc_hd__a31o_1
X_5284_ _0789_ _0895_ _0894_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a21o_1
XFILLER_68_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7023_ _2650_ _2651_ _2643_ VGND VGND VPWR VPWR _2653_ sky130_fd_sc_hd__a21o_1
XFILLER_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8974_ net511 VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__inv_2
X_7925_ net199 _3445_ VGND VGND VPWR VPWR _3524_ sky130_fd_sc_hd__nand2_1
X_7856_ _4342_ net490 VGND VGND VPWR VPWR _3462_ sky130_fd_sc_hd__nor2_2
XFILLER_63_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6807_ _2436_ _2434_ VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__and2b_1
XFILLER_23_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7787_ net486 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3393_ sky130_fd_sc_hd__nor2_1
X_4999_ net242 net551 VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nand2_1
XFILLER_11_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6738_ _2315_ _2367_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__nor2_1
XFILLER_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6669_ _2283_ _2290_ _2297_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__and3_1
X_9457_ clknet_leaf_19_clk _0075_ _0367_ VGND VGND VPWR VPWR mul_res\[12\] sky130_fd_sc_hd__dfrtp_1
X_9388_ clknet_leaf_11_clk adder_inst.exp_larger\[2\] _0298_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_8408_ net165 _3732_ VGND VGND VPWR VPWR _3981_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_21_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8339_ net148 _3833_ VGND VGND VPWR VPWR _3912_ sky130_fd_sc_hd__nor2_1
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout440 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__buf_4
XFILLER_48_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout473 net476 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__buf_2
Xfanout484 net487 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__buf_2
Xfanout462 net463 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_2
Xfanout451 net452 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__clkbuf_4
Xfanout495 adder_inst.sum_raw_r\[20\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5971_ _1595_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__and2_1
X_7710_ net114 _3317_ _3333_ VGND VGND VPWR VPWR _3334_ sky130_fd_sc_hd__a21o_1
X_8690_ _4031_ _4041_ _4032_ VGND VGND VPWR VPWR _4243_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_86_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4922_ _0550_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nor2_1
XFILLER_52_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7641_ _3157_ _3270_ VGND VGND VPWR VPWR _3271_ sky130_fd_sc_hd__nor2_1
XFILLER_33_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4853_ _0475_ _0476_ _0481_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__a21o_1
XFILLER_60_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7572_ _3200_ _3201_ VGND VGND VPWR VPWR _3202_ sky130_fd_sc_hd__nor2_1
X_4784_ net242 net384 VGND VGND VPWR VPWR _4555_ sky130_fd_sc_hd__nand2_1
X_9311_ clknet_leaf_10_clk adder_inst.man_a\[23\] _0221_ VGND VGND VPWR VPWR adder_inst.man_a_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_6523_ _2139_ _2140_ _2151_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__nand3_1
XFILLER_109_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6454_ net284 net292 net463 net470 VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__and4_1
X_9242_ clknet_leaf_0_clk net36 _0152_ VGND VGND VPWR VPWR adder_inst.i_b\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5405_ _1033_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__or2_1
X_6385_ _2013_ _2014_ net280 net470 VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__and4bb_1
X_9173_ net529 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__inv_2
X_8124_ _3696_ _3697_ VGND VGND VPWR VPWR _3698_ sky130_fd_sc_hd__xor2_1
XFILLER_0_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5336_ _0965_ _0964_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nand2b_1
X_8055_ _3395_ _3411_ _3470_ VGND VGND VPWR VPWR _3634_ sky130_fd_sc_hd__o21ba_1
X_5267_ _0884_ _0889_ _0883_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a21bo_1
X_7006_ _2632_ _2634_ _1555_ _1562_ VGND VGND VPWR VPWR _2636_ sky130_fd_sc_hd__o211ai_1
X_5198_ _0825_ _0826_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or3_1
XFILLER_56_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8957_ net532 VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__inv_2
XFILLER_83_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7908_ adder_inst.sum_raw_r\[1\] net494 _3413_ _3509_ VGND VGND VPWR VPWR _3510_
+ sky130_fd_sc_hd__a31o_1
XFILLER_24_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8888_ net508 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__inv_2
XFILLER_24_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7839_ net502 _4341_ VGND VGND VPWR VPWR _3445_ sky130_fd_sc_hd__and2_1
XFILLER_24_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload0 clknet_1_0__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_6
XFILLER_50_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout292 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout270 net271 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__buf_2
Xfanout281 net283 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_2
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6170_ _1775_ _1798_ _1799_ net132 VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__a211oi_4
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5121_ _0740_ _0741_ _0745_ _0749_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a211oi_1
XFILLER_84_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5052_ _0674_ _0675_ _0680_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or3b_1
XFILLER_53_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8811_ _4312_ _4313_ VGND VGND VPWR VPWR multiplier_inst.man_final\[4\] sky130_fd_sc_hd__nor2_1
XFILLER_25_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8742_ net711 _4269_ net184 VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__and3_1
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5954_ _1581_ _1582_ _1574_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__a21o_1
XFILLER_52_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8673_ _4054_ _4115_ _4226_ net193 VGND VGND VPWR VPWR _4229_ sky130_fd_sc_hd__a31o_1
X_4905_ _0522_ _0523_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__and3_1
XFILLER_21_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5885_ _1417_ _1420_ _1419_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__o21bai_1
X_4836_ adder_inst.man_a_r\[22\] net302 net307 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and3_1
XFILLER_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7624_ _4542_ _0456_ _3036_ VGND VGND VPWR VPWR _3254_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_51_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7555_ _3173_ _3184_ VGND VGND VPWR VPWR _3185_ sky130_fd_sc_hd__or2_1
X_6506_ _2129_ _2130_ _2135_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__nand3_1
X_4767_ net120 _4537_ _4509_ VGND VGND VPWR VPWR _4538_ sky130_fd_sc_hd__or3b_1
XFILLER_107_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7486_ _3114_ _3115_ VGND VGND VPWR VPWR _3116_ sky130_fd_sc_hd__and2_1
X_4698_ _4462_ _4467_ VGND VGND VPWR VPWR _4469_ sky130_fd_sc_hd__or2_1
X_9225_ clknet_leaf_6_clk net20 _0135_ VGND VGND VPWR VPWR adder_inst.exp_a\[4\] sky130_fd_sc_hd__dfrtp_1
X_6437_ net295 net458 VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__nand2_1
XFILLER_115_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9156_ net543 VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__inv_2
X_6368_ _1995_ _1997_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__and2b_1
X_8107_ _3304_ _3656_ VGND VGND VPWR VPWR _3681_ sky130_fd_sc_hd__nor2_1
X_5319_ net207 net448 VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__nand2_1
Xhold12 adder_inst.exp_a\[0\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
X_9087_ net519 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__inv_2
Xhold23 adder_inst.i_b\[4\] VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__dlygate4sd3_1
X_6299_ _1927_ _1928_ net280 net463 VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__and4bb_1
Xhold56 adder_inst.exp_a\[3\] VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 adder_inst.i_b\[1\] VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlygate4sd3_1
X_8038_ net492 _3621_ _3428_ VGND VGND VPWR VPWR _3622_ sky130_fd_sc_hd__o21ai_1
Xhold34 adder_inst.i_b\[15\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 _0014_ VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold67 adder_inst.i_b\[22\] VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 add_res\[16\] VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_104_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_9 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_72_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5670_ _1296_ _1298_ _1295_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a21bo_1
XFILLER_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4621_ _4371_ _4388_ _4390_ VGND VGND VPWR VPWR _4392_ sky130_fd_sc_hd__or3_1
X_7340_ _2919_ _2927_ VGND VGND VPWR VPWR _2970_ sky130_fd_sc_hd__nor2_1
X_7271_ _2720_ _2727_ VGND VGND VPWR VPWR _2901_ sky130_fd_sc_hd__nand2_1
X_9010_ net518 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__inv_2
XFILLER_89_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6222_ _1758_ _1846_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__nand3_2
XFILLER_106_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6153_ net270 net455 net460 net265 VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__a22o_1
XFILLER_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5104_ _0730_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__xnor2_1
X_6084_ _1513_ _1712_ _1711_ _1706_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__o211ai_2
X_5035_ _0663_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_56_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6986_ _1532_ _1540_ _1539_ VGND VGND VPWR VPWR _2616_ sky130_fd_sc_hd__a21o_1
XFILLER_26_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8725_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] net169 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[4\] sky130_fd_sc_hd__mux2_1
XFILLER_80_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5937_ _1564_ _1565_ _1547_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_36_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8656_ _4009_ _4176_ _4185_ VGND VGND VPWR VPWR _4213_ sky130_fd_sc_hd__o21a_1
X_7607_ _1115_ _3236_ VGND VGND VPWR VPWR _3237_ sky130_fd_sc_hd__xnor2_1
X_5868_ _1496_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_97_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8587_ _4146_ _4147_ _3926_ VGND VGND VPWR VPWR _4153_ sky130_fd_sc_hd__a21o_1
X_5799_ _1425_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4819_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nor2_1
XFILLER_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7538_ _4370_ net136 _3151_ _3167_ VGND VGND VPWR VPWR _3168_ sky130_fd_sc_hd__and4_1
X_7469_ _4375_ _4381_ VGND VGND VPWR VPWR _3099_ sky130_fd_sc_hd__xnor2_1
X_9208_ clknet_leaf_4_clk net2 _0118_ VGND VGND VPWR VPWR adder_inst.i_a\[10\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_8_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_652 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9139_ net528 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__inv_2
Xoutput79 net79 VGND VGND VPWR VPWR o_res[1] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR o_res[0] sky130_fd_sc_hd__buf_2
XFILLER_103_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6840_ _2468_ _2469_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__or2_1
X_6771_ _2390_ _2400_ _2350_ _2373_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__a211oi_2
XFILLER_23_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8510_ net209 net166 VGND VGND VPWR VPWR _4083_ sky130_fd_sc_hd__nand2_1
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5722_ _1316_ _1319_ _1350_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_33_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9490_ clknet_leaf_20_clk net703 _0400_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_61_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8441_ net137 _3720_ VGND VGND VPWR VPWR _4014_ sky130_fd_sc_hd__and2_1
X_5653_ net220 net478 _1248_ _1247_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a31oi_2
X_8372_ _3942_ _3944_ VGND VGND VPWR VPWR _3945_ sky130_fd_sc_hd__nor2_1
X_5584_ _1212_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__nor2_1
X_4604_ _4374_ net225 net345 VGND VGND VPWR VPWR _4375_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7323_ _2947_ _2948_ VGND VGND VPWR VPWR _2953_ sky130_fd_sc_hd__xor2_1
XFILLER_116_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7254_ _2881_ _2883_ VGND VGND VPWR VPWR _2884_ sky130_fd_sc_hd__nor2_1
X_7185_ _2810_ _2813_ _2814_ VGND VGND VPWR VPWR _2815_ sky130_fd_sc_hd__nand3_1
X_6205_ _1831_ _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__nand2b_1
XFILLER_97_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6136_ _1666_ _1668_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__xnor2_1
XFILLER_85_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6067_ _1273_ _1694_ _1695_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__nand4_2
X_5018_ _0646_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__and2_1
XFILLER_73_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6969_ _2585_ _2598_ VGND VGND VPWR VPWR _2599_ sky130_fd_sc_hd__and2_1
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8708_ _4110_ _4115_ _4258_ VGND VGND VPWR VPWR _4259_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_101_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8639_ net181 _4196_ _4197_ _4198_ VGND VGND VPWR VPWR _4199_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_422 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8990_ net513 VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_38_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7941_ adder_inst.sum_raw_r\[6\] net493 _3414_ _3537_ VGND VGND VPWR VPWR _3538_
+ sky130_fd_sc_hd__a211o_1
XFILLER_82_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7872_ net489 _3474_ _3477_ _3472_ VGND VGND VPWR VPWR _3478_ sky130_fd_sc_hd__a22oi_1
XFILLER_82_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6823_ net330 net469 VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_18_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6754_ _2382_ _2383_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__and2b_1
XFILLER_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9473_ clknet_leaf_12_clk _0092_ _0383_ VGND VGND VPWR VPWR mul_res\[28\] sky130_fd_sc_hd__dfrtp_1
X_6685_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__inv_2
X_5705_ _1327_ _1328_ _1333_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a21o_1
X_8424_ _3995_ _3996_ VGND VGND VPWR VPWR _3997_ sky130_fd_sc_hd__nand2b_1
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5636_ _1258_ _1260_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8355_ _3856_ _3896_ _3927_ VGND VGND VPWR VPWR _3928_ sky130_fd_sc_hd__or3_1
X_5567_ _1194_ _1196_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nor2_1
Xhold120 mul_res\[29\] VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 multiplier_inst.exp_final_r\[7\] VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlygate4sd3_1
X_8286_ net139 _3712_ _3802_ net144 VGND VGND VPWR VPWR _3859_ sky130_fd_sc_hd__a211oi_1
Xhold153 add_res\[13\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
X_5498_ _1119_ _1126_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__nand3_2
Xhold142 multiplier_inst.man_final_r\[10\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7306_ _2911_ _2935_ _2910_ VGND VGND VPWR VPWR _2936_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_44_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold164 _0029_ VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
X_7237_ _2830_ _2832_ _2866_ _0953_ VGND VGND VPWR VPWR _2867_ sky130_fd_sc_hd__a211o_1
XFILLER_77_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7168_ _1620_ net119 _2796_ VGND VGND VPWR VPWR _2798_ sky130_fd_sc_hd__nor3_1
XFILLER_86_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7099_ _2713_ _2727_ _2728_ VGND VGND VPWR VPWR _2729_ sky130_fd_sc_hd__and3_1
X_6119_ _1735_ _1736_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__nand3_4
XFILLER_100_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_53_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6470_ _2097_ _2098_ _2095_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__a21o_1
XFILLER_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5421_ _1049_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__xnor2_1
X_8140_ _3712_ _3713_ net139 VGND VGND VPWR VPWR _3714_ sky130_fd_sc_hd__mux2_1
X_5352_ _0980_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__and2_1
X_8071_ adder_inst.exp_larger_r\[5\] net192 _3645_ _3391_ VGND VGND VPWR VPWR _3649_
+ sky130_fd_sc_hd__o31a_1
X_7022_ _2643_ _2650_ _2651_ VGND VGND VPWR VPWR _2652_ sky130_fd_sc_hd__nand3_1
X_5283_ _0899_ _0900_ _0911_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__a21o_1
X_8973_ net545 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__inv_2
X_7924_ net497 net177 VGND VGND VPWR VPWR _3523_ sky130_fd_sc_hd__nor2_1
XFILLER_83_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7855_ net191 _3459_ _3460_ VGND VGND VPWR VPWR _3461_ sky130_fd_sc_hd__a21o_1
XFILLER_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6806_ _2395_ _2435_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__or2_1
X_7786_ net486 adder_inst.exp_larger_r\[6\] _3390_ VGND VGND VPWR VPWR _3392_ sky130_fd_sc_hd__and3_1
X_4998_ net385 net261 _0618_ _0617_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a31o_1
XFILLER_11_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6737_ _2316_ _2366_ VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__or2_1
X_6668_ _2283_ _2290_ _2297_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__a21oi_1
X_9456_ clknet_leaf_18_clk _0074_ _0366_ VGND VGND VPWR VPWR mul_res\[11\] sky130_fd_sc_hd__dfrtp_1
X_9387_ clknet_leaf_13_clk adder_inst.exp_larger\[1\] _0297_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[1\]
+ sky130_fd_sc_hd__dfrtp_2
X_8407_ net408 net171 _3978_ _3979_ VGND VGND VPWR VPWR _3980_ sky130_fd_sc_hd__a22o_1
X_6599_ _2212_ _2227_ _2228_ _2152_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__a211o_1
X_5619_ _1237_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__xnor2_1
X_8338_ _3906_ _3908_ VGND VGND VPWR VPWR _3911_ sky130_fd_sc_hd__xor2_2
XFILLER_105_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8269_ net128 _3841_ _3838_ VGND VGND VPWR VPWR _3842_ sky130_fd_sc_hd__a21oi_1
Xfanout430 net432 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__buf_2
Xfanout441 net443 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_4
Xfanout474 net476 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout452 adder_inst.man_a_r\[5\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout463 net464 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__clkbuf_2
Xfanout496 net499 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__buf_2
Xfanout485 net487 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_86_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5970_ _1598_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4921_ adder_inst.man_b_r\[21\] net421 net427 net215 VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a22oi_1
X_4852_ _0475_ _0476_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nand3_1
X_7640_ _3159_ _3268_ VGND VGND VPWR VPWR _3270_ sky130_fd_sc_hd__nand2_2
XFILLER_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4783_ net371 net378 net249 net256 VGND VGND VPWR VPWR _4554_ sky130_fd_sc_hd__and4_1
XFILLER_20_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7571_ _3029_ _3030_ _3033_ VGND VGND VPWR VPWR _3201_ sky130_fd_sc_hd__and3_1
X_9310_ clknet_leaf_1_clk net567 _0220_ VGND VGND VPWR VPWR adder_inst.man_a_r\[22\]
+ sky130_fd_sc_hd__dfrtp_2
X_6522_ _2139_ _2140_ _2151_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__and3_1
X_9241_ clknet_leaf_3_clk net35 _0151_ VGND VGND VPWR VPWR adder_inst.i_b\[11\] sky130_fd_sc_hd__dfrtp_1
X_6453_ _2015_ _2082_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nor2_1
XFILLER_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9172_ net530 VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__inv_2
X_5404_ _0455_ _0978_ _1029_ _1032_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__a211oi_1
X_8123_ _3344_ _3695_ VGND VGND VPWR VPWR _3697_ sky130_fd_sc_hd__xnor2_4
X_6384_ net291 net458 net463 net284 VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__a22oi_1
X_5335_ _0843_ _0845_ _0842_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__o21ba_1
X_8054_ adder_inst.exp_larger_r\[4\] _3416_ VGND VGND VPWR VPWR _3633_ sky130_fd_sc_hd__nand2_1
XFILLER_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5266_ _0789_ _0894_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nand3_2
X_7005_ _1555_ _1562_ _2632_ _2634_ VGND VGND VPWR VPWR _2635_ sky130_fd_sc_hd__a211o_1
XFILLER_55_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5197_ net254 net410 net415 net248 VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a22oi_1
XFILLER_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8956_ net541 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__inv_2
XFILLER_55_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7907_ adder_inst.sum_raw_r\[3\] net488 _3462_ adder_inst.sum_raw_r\[2\] _3394_ VGND
+ VGND VPWR VPWR _3509_ sky130_fd_sc_hd__a221o_1
XFILLER_71_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8887_ net511 VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__inv_2
XFILLER_24_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7838_ net203 _3387_ _3401_ VGND VGND VPWR VPWR _3444_ sky130_fd_sc_hd__a21bo_1
XFILLER_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7769_ _3336_ _3347_ VGND VGND VPWR VPWR _3378_ sky130_fd_sc_hd__nor2_1
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9508_ clknet_leaf_10_clk net664 _0418_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
Xclkload1 clknet_leaf_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__inv_6
XFILLER_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9439_ clknet_leaf_11_clk multiplier_inst.exp_final\[4\] _0349_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout260 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_2
Xfanout282 net283 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
Xfanout271 net276 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout293 net294 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_109_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5120_ _0745_ _0749_ _0740_ _0741_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__o211a_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5051_ _0674_ _0675_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nor3b_1
XFILLER_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8810_ _3192_ _3185_ VGND VGND VPWR VPWR _4313_ sky130_fd_sc_hd__and2b_1
X_8741_ net691 net186 net183 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and3_1
XFILLER_53_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5953_ _1574_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__nand3_1
X_8672_ _4056_ net106 _4227_ VGND VGND VPWR VPWR _4228_ sky130_fd_sc_hd__and3_1
XFILLER_80_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4904_ _0531_ _0532_ _0526_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a21bo_1
XFILLER_61_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5884_ _1424_ _1429_ _1423_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__a21bo_1
XFILLER_33_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4835_ net361 net296 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nand2_1
X_7623_ net110 _3247_ _3252_ VGND VGND VPWR VPWR _3253_ sky130_fd_sc_hd__a21oi_1
X_4766_ _4534_ _4535_ _4514_ VGND VGND VPWR VPWR _4537_ sky130_fd_sc_hd__o21a_1
X_7554_ net109 _3177_ _3180_ _3182_ VGND VGND VPWR VPWR _3184_ sky130_fd_sc_hd__a211o_1
X_6505_ _2131_ _2134_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7485_ _3065_ _3112_ VGND VGND VPWR VPWR _3115_ sky130_fd_sc_hd__xor2_1
X_4697_ _4462_ _4467_ VGND VGND VPWR VPWR _4468_ sky130_fd_sc_hd__nand2_1
X_9224_ clknet_leaf_7_clk net19 _0134_ VGND VGND VPWR VPWR adder_inst.exp_a\[3\] sky130_fd_sc_hd__dfrtp_1
X_6436_ net301 net309 net444 net451 VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__and4_1
XFILLER_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9155_ net540 VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__inv_2
X_6367_ net309 net439 net444 net301 VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__a22o_1
X_8106_ _3669_ _3670_ _3675_ _3676_ VGND VGND VPWR VPWR _3680_ sky130_fd_sc_hd__a22o_2
XFILLER_0_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5318_ _0946_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__nor2_1
Xhold13 adder_inst.exp_a\[1\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
X_9086_ net519 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__inv_2
XFILLER_102_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6298_ net291 net451 net458 net284 VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold24 adder_inst.exp_b\[5\] VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold46 adder_inst.i_b\[18\] VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlygate4sd3_1
X_8037_ net199 _3620_ net500 VGND VGND VPWR VPWR _3621_ sky130_fd_sc_hd__a21oi_1
XFILLER_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold35 adder_inst.i_a\[15\] VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__dlygate4sd3_1
X_5249_ net350 net316 net322 net344 VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a22o_1
Xhold57 adder_inst.exp_b\[0\] VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 multiplier_inst.exp_final_r\[1\] VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 adder_inst.i_b\[21\] VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_56_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8939_ net515 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__inv_2
XFILLER_71_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_650 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4620_ _4388_ _4390_ _4371_ VGND VGND VPWR VPWR _4391_ sky130_fd_sc_hd__o21ai_1
X_7270_ _2897_ _2898_ VGND VGND VPWR VPWR _2900_ sky130_fd_sc_hd__xnor2_1
X_6221_ net277 net455 _1849_ _1847_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_94_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6152_ net258 net466 VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__nand2_1
XFILLER_106_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5103_ _0731_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__and2b_1
XFILLER_57_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6083_ _1706_ _1711_ _1712_ _1513_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__a211o_1
XFILLER_111_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5034_ _0659_ _0661_ _0662_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_56_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6985_ _2584_ _2612_ VGND VGND VPWR VPWR _2615_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_0_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8724_ adder_inst.exp_b_r\[3\] adder_inst.exp_a_r\[3\] net169 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[3\] sky130_fd_sc_hd__mux2_1
X_5936_ _1547_ _1564_ _1565_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__and3_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8655_ _3956_ _4212_ VGND VGND VPWR VPWR adder_inst.sum_raw\[15\] sky130_fd_sc_hd__xnor2_1
XFILLER_34_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7606_ _1133_ _3215_ VGND VGND VPWR VPWR _3236_ sky130_fd_sc_hd__nor2_1
X_5867_ net214 net220 net472 net478 VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__and4_1
X_8586_ _3926_ _4152_ VGND VGND VPWR VPWR adder_inst.sum_raw\[6\] sky130_fd_sc_hd__xnor2_1
X_5798_ _1426_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__nor2_1
X_4818_ _0445_ _0446_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__nor2_1
X_4749_ net224 net364 VGND VGND VPWR VPWR _4520_ sky130_fd_sc_hd__nand2_1
X_7537_ _1718_ _3166_ VGND VGND VPWR VPWR _3167_ sky130_fd_sc_hd__xnor2_2
XFILLER_107_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7468_ _3096_ _3097_ VGND VGND VPWR VPWR _3098_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9207_ clknet_leaf_3_clk net32 _0117_ VGND VGND VPWR VPWR adder_inst.i_a\[9\] sky130_fd_sc_hd__dfrtp_1
X_6419_ net426 net331 VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__nand2_1
X_7399_ _2256_ _3027_ _3028_ _3005_ _3025_ VGND VGND VPWR VPWR _3029_ sky130_fd_sc_hd__o221a_1
XFILLER_103_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput69 net69 VGND VGND VPWR VPWR o_res[10] sky130_fd_sc_hd__buf_2
X_9138_ net526 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9069_ net546 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__inv_2
XFILLER_103_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6770_ _2390_ _2397_ _2398_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__nand3_1
XFILLER_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5721_ _1336_ _1338_ _1349_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_33_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_99_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8440_ net145 _3797_ _3859_ net128 VGND VGND VPWR VPWR _4013_ sky130_fd_sc_hd__a211oi_1
X_5652_ _1254_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__nor2_1
XFILLER_31_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8371_ net170 _3941_ _3943_ VGND VGND VPWR VPWR _3944_ sky130_fd_sc_hd__o21ai_1
X_5583_ net252 net447 net453 net245 VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a22oi_1
X_4603_ net352 net229 VGND VGND VPWR VPWR _4374_ sky130_fd_sc_hd__and2_1
XFILLER_30_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7322_ _2890_ _2950_ VGND VGND VPWR VPWR _2952_ sky130_fd_sc_hd__xnor2_2
XFILLER_116_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7253_ _0970_ _2802_ _2872_ _2880_ VGND VGND VPWR VPWR _2883_ sky130_fd_sc_hd__a211oi_1
X_7184_ _0888_ _2812_ _2811_ VGND VGND VPWR VPWR _2814_ sky130_fd_sc_hd__a21o_1
X_6204_ _1831_ _1832_ _1833_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_5_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6135_ _1764_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__inv_2
XFILLER_85_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6066_ net236 net471 net478 net230 VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__a22o_1
XFILLER_85_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5017_ net227 net417 _0539_ _0538_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a31o_1
XFILLER_45_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8707_ _4071_ net107 _4257_ _4245_ _4076_ VGND VGND VPWR VPWR _4258_ sky130_fd_sc_hd__a32o_1
XFILLER_13_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6968_ _2592_ _2597_ VGND VGND VPWR VPWR _2598_ sky130_fd_sc_hd__xnor2_2
X_6899_ _2517_ _2528_ VGND VGND VPWR VPWR _2529_ sky130_fd_sc_hd__and2_1
X_5919_ net278 net410 VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_101_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8638_ _3977_ _4190_ net181 VGND VGND VPWR VPWR _4198_ sky130_fd_sc_hd__a21oi_1
X_8569_ net193 _4133_ _4134_ _4137_ VGND VGND VPWR VPWR _4138_ sky130_fd_sc_hd__a31o_1
XFILLER_21_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_112_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7940_ adder_inst.sum_raw_r\[3\] _3524_ _3536_ _3433_ VGND VGND VPWR VPWR _3537_
+ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_38_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7871_ net499 adder_inst.exp_larger_r\[1\] _3404_ _3474_ VGND VGND VPWR VPWR _3477_
+ sky130_fd_sc_hd__a22o_1
XFILLER_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6822_ net335 net457 net341 net462 VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__and4_1
XFILLER_35_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6753_ net324 net456 net461 net317 VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__a22o_1
X_9472_ clknet_leaf_12_clk _0091_ _0382_ VGND VGND VPWR VPWR mul_res\[27\] sky130_fd_sc_hd__dfrtp_1
X_6684_ _2260_ _2309_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__xnor2_1
X_5704_ _1327_ _1328_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__nand3_1
X_8423_ _3993_ _3994_ VGND VGND VPWR VPWR _3996_ sky130_fd_sc_hd__nand2_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5635_ _1262_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__or2_1
XFILLER_12_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8354_ _3911_ _3926_ VGND VGND VPWR VPWR _3927_ sky130_fd_sc_hd__nand2_1
Xhold110 add_res\[2\] VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd3_1
X_5566_ _1194_ _1195_ net277 net436 VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__and4bb_1
Xhold121 _0021_ VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 multiplier_inst.exp_final_r\[2\] VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
X_8285_ net142 _3801_ _3857_ VGND VGND VPWR VPWR _3858_ sky130_fd_sc_hd__o21a_1
Xhold132 add_res\[14\] VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlygate4sd3_1
X_5497_ _1095_ _1118_ _0740_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__o21ai_1
X_7305_ _2930_ _2934_ VGND VGND VPWR VPWR _2935_ sky130_fd_sc_hd__xor2_1
Xhold165 adder_inst.is_nan_r VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold154 _0004_ VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
X_7236_ _0937_ _0938_ _0952_ VGND VGND VPWR VPWR _2866_ sky130_fd_sc_hd__o21a_1
XFILLER_98_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7167_ _1620_ net119 _2796_ VGND VGND VPWR VPWR _2797_ sky130_fd_sc_hd__o21a_1
XFILLER_86_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7098_ _2720_ _2721_ _2726_ VGND VGND VPWR VPWR _2728_ sky130_fd_sc_hd__a21o_1
X_6118_ _1741_ _1746_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__xnor2_1
XFILLER_73_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6049_ _1355_ _1676_ _1675_ _1656_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__a211oi_1
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5420_ _0704_ _0706_ _0703_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__o21ba_1
X_5351_ _4548_ _4550_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
X_8070_ adder_inst.exp_larger_r\[5\] _3419_ _3421_ _3647_ VGND VGND VPWR VPWR _3648_
+ sky130_fd_sc_hd__a31o_1
X_5282_ _0899_ _0900_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nand3_2
XFILLER_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7021_ _2648_ _2649_ _2644_ VGND VGND VPWR VPWR _2651_ sky130_fd_sc_hd__a21o_1
XFILLER_114_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8972_ net542 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__inv_2
XFILLER_83_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7923_ _4337_ net498 net493 VGND VGND VPWR VPWR _3522_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7854_ _4346_ net179 _3444_ net486 net174 VGND VGND VPWR VPWR _3460_ sky130_fd_sc_hd__a221o_1
X_7785_ net486 _3390_ VGND VGND VPWR VPWR _3391_ sky130_fd_sc_hd__nand2_1
X_6805_ net308 net473 net481 net300 VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__a22oi_1
X_6736_ _2362_ _2365_ _2318_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__o21ai_2
X_4997_ _0516_ _0518_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__nand2_1
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6667_ _2237_ _2296_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__or2_1
X_9455_ clknet_leaf_19_clk _0073_ _0365_ VGND VGND VPWR VPWR mul_res\[10\] sky130_fd_sc_hd__dfrtp_1
X_9386_ clknet_leaf_13_clk adder_inst.exp_larger\[0\] _0296_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_8406_ net172 _3732_ VGND VGND VPWR VPWR _3979_ sky130_fd_sc_hd__nor2_2
X_6598_ _2139_ _2140_ _2151_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__a21oi_1
X_5618_ _1242_ _1246_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__xnor2_1
X_8337_ _3906_ _3908_ VGND VGND VPWR VPWR _3910_ sky130_fd_sc_hd__nor2_1
X_5549_ net277 net424 VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nand2_1
XFILLER_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8268_ _3839_ _3840_ VGND VGND VPWR VPWR _3841_ sky130_fd_sc_hd__nor2_1
XFILLER_78_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8199_ _3771_ _3772_ net138 VGND VGND VPWR VPWR _3773_ sky130_fd_sc_hd__mux2_1
Xfanout420 net423 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__buf_2
X_7219_ _0943_ _2848_ VGND VGND VPWR VPWR _2849_ sky130_fd_sc_hd__nor2_1
Xfanout431 net432 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__clkbuf_4
Xfanout475 net476 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__buf_2
Xfanout464 adder_inst.man_a_r\[3\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_8
Xfanout442 net443 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__buf_2
Xfanout453 net455 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__buf_2
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__buf_2
Xfanout497 net498 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__buf_2
XFILLER_86_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4920_ net215 adder_inst.man_b_r\[21\] net421 net427 VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__and4_1
X_4851_ _0478_ _0479_ _0477_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_28_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_72_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4782_ _4417_ _4551_ _4552_ VGND VGND VPWR VPWR _4553_ sky130_fd_sc_hd__nand3_1
X_7570_ _3029_ _3030_ _3033_ VGND VGND VPWR VPWR _3200_ sky130_fd_sc_hd__a21oi_1
X_6521_ _2145_ _2149_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__xnor2_1
X_9240_ clknet_leaf_0_clk net34 _0150_ VGND VGND VPWR VPWR adder_inst.i_b\[10\] sky130_fd_sc_hd__dfrtp_1
X_6452_ net280 net470 _2013_ _2014_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9171_ net529 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__inv_2
X_5403_ _1029_ _1032_ _0455_ _0978_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__o211a_1
X_8122_ _3326_ _3688_ _3327_ VGND VGND VPWR VPWR _3696_ sky130_fd_sc_hd__o21a_2
X_6383_ net284 net291 net458 net463 VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__and4_1
X_5334_ _0961_ _0962_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__xnor2_1
X_8053_ net495 _3454_ _4347_ VGND VGND VPWR VPWR _3632_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_81_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5265_ net344 net311 _0787_ _0788_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a22o_1
X_7004_ _2630_ _2631_ _2616_ VGND VGND VPWR VPWR _2634_ sky130_fd_sc_hd__a21oi_1
X_5196_ net241 net423 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__nand2_1
XFILLER_68_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8955_ net541 VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__inv_2
XFILLER_28_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7906_ net200 adder_inst.sum_raw_r\[5\] adder_inst.sum_raw_r\[4\] _3383_ VGND VGND
+ VPWR VPWR _3508_ sky130_fd_sc_hd__o22a_1
X_8886_ net511 VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__inv_2
XFILLER_24_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7837_ net191 _3423_ _3440_ _3442_ VGND VGND VPWR VPWR _3443_ sky130_fd_sc_hd__a31o_1
XFILLER_36_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7768_ adder_inst.is_nan_b_r net695 _3377_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__or3_1
XFILLER_11_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9507_ clknet_leaf_12_clk net637 _0417_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
XFILLER_109_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7699_ _3318_ _3319_ _3323_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[5\] sky130_fd_sc_hd__o21a_1
X_6719_ _2278_ _2321_ _2336_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__a21o_1
Xclkload2 clknet_leaf_1_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinv_8
XFILLER_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9438_ clknet_leaf_11_clk multiplier_inst.exp_final\[3\] _0348_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9369_ clknet_leaf_18_clk _0042_ _0279_ VGND VGND VPWR VPWR add_res\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout250 net251 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout261 net263 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout272 net276 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_2
Xfanout283 adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout294 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_109_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5050_ _0676_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8740_ net667 net187 net183 VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__and3_1
X_5952_ _1579_ _1580_ _1575_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__a21o_1
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4903_ _0526_ _0531_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand3_1
X_8671_ _4054_ _4216_ VGND VGND VPWR VPWR _4227_ sky130_fd_sc_hd__nand2_1
X_5883_ _1510_ _1511_ _1512_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__nor3_4
XFILLER_33_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7622_ net110 _3251_ VGND VGND VPWR VPWR _3252_ sky130_fd_sc_hd__nor2_1
X_4834_ _0460_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2b_1
X_4765_ _4514_ _4534_ _4535_ VGND VGND VPWR VPWR _4536_ sky130_fd_sc_hd__nor3_1
X_7553_ net109 _3180_ _3182_ VGND VGND VPWR VPWR _3183_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_99_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6504_ _2132_ _2133_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__nor2_1
X_9223_ clknet_leaf_7_clk net18 _0133_ VGND VGND VPWR VPWR adder_inst.exp_a\[2\] sky130_fd_sc_hd__dfrtp_1
X_7484_ _3040_ _3041_ _3039_ VGND VGND VPWR VPWR _3114_ sky130_fd_sc_hd__a21o_1
X_4696_ _4465_ _4466_ VGND VGND VPWR VPWR _4467_ sky130_fd_sc_hd__xnor2_1
X_6435_ _1990_ _2063_ _2062_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__a21o_1
X_9154_ net544 VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__inv_2
X_6366_ net295 net451 VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__nand2_1
XFILLER_115_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9085_ net519 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__inv_2
X_8105_ _3669_ _3670_ _3675_ _3676_ VGND VGND VPWR VPWR _3679_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5317_ net218 net438 net442 net212 VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a22oi_1
X_8036_ adder_inst.sum_raw_r\[15\] adder_inst.sum_raw_r\[16\] net502 VGND VGND VPWR
+ VPWR _3620_ sky130_fd_sc_hd__mux2_1
Xhold14 adder_inst.i_a\[9\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
X_6297_ net284 net287 net451 net458 VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__and4_1
Xhold36 adder_inst.i_a\[8\] VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 adder_inst.i_a\[14\] VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 adder_inst.i_b\[10\] VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd3_1
X_5248_ net357 net310 VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__nand2_1
Xhold58 adder_inst.exp_b\[4\] VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 adder_inst.i_a\[11\] VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__dlygate4sd3_1
X_5179_ _0789_ _0790_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xor2_1
X_8938_ net514 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8869_ net624 mul_res\[21\] net506 VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_104_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6220_ _1847_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_94_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6151_ net265 net270 net455 net460 VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__and4_1
X_5102_ net367 net267 net274 net357 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a22o_1
XFILLER_97_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6082_ _1510_ _1511_ _1512_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__o21a_1
X_5033_ _0659_ _0661_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nor3b_1
XFILLER_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6984_ _2584_ _2612_ VGND VGND VPWR VPWR _2614_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8723_ adder_inst.exp_b_r\[2\] adder_inst.exp_a_r\[2\] net172 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[2\] sky130_fd_sc_hd__mux2_1
XFILLER_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5935_ _1562_ _1563_ _1548_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__a21o_1
XFILLER_25_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8654_ net193 _4206_ _4207_ _4211_ VGND VGND VPWR VPWR _4212_ sky130_fd_sc_hd__a31o_1
X_5866_ net220 net472 net478 net214 VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_36_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7605_ net112 _3225_ _3226_ _3234_ VGND VGND VPWR VPWR _3235_ sky130_fd_sc_hd__a31o_1
X_4817_ _0445_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__and2_1
X_8585_ _4148_ _4151_ net180 VGND VGND VPWR VPWR _4152_ sky130_fd_sc_hd__mux2_1
X_5797_ net374 net315 net323 net368 VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a22oi_1
XFILLER_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4748_ _4517_ _4518_ VGND VGND VPWR VPWR _4519_ sky130_fd_sc_hd__nor2_1
X_7536_ _1810_ _3165_ _1808_ VGND VGND VPWR VPWR _3166_ sky130_fd_sc_hd__a21bo_1
X_7467_ _3083_ _3085_ _3082_ VGND VGND VPWR VPWR _3097_ sky130_fd_sc_hd__o21bai_2
X_4679_ _4444_ _4449_ VGND VGND VPWR VPWR _4450_ sky130_fd_sc_hd__and2b_1
X_9206_ clknet_leaf_1_clk net31 _0116_ VGND VGND VPWR VPWR adder_inst.i_a\[8\] sky130_fd_sc_hd__dfrtp_1
X_6418_ net416 net422 net337 net343 VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9137_ net525 VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__inv_2
X_7398_ _3020_ _3022_ _3026_ VGND VGND VPWR VPWR _3028_ sky130_fd_sc_hd__a21boi_1
XFILLER_103_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6349_ net416 net337 net343 net412 VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_8_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9068_ net546 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__inv_2
XFILLER_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8019_ adder_inst.sum_raw_r\[16\] net497 _3432_ adder_inst.sum_raw_r\[13\] VGND VGND
+ VPWR VPWR _3605_ sky130_fd_sc_hd__a22o_1
XFILLER_56_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5720_ _1336_ _1338_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_61_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5651_ _1269_ _1279_ _1280_ _1253_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__o211a_1
XFILLER_31_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8370_ net428 net170 VGND VGND VPWR VPWR _3943_ sky130_fd_sc_hd__nand2_1
X_5582_ net245 net252 net447 net453 VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__and4_1
X_4602_ _4369_ _4372_ VGND VGND VPWR VPWR _4373_ sky130_fd_sc_hd__nand2_1
X_7321_ _2890_ _2950_ VGND VGND VPWR VPWR _2951_ sky130_fd_sc_hd__and2b_1
XFILLER_116_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7252_ _2874_ _2875_ _2878_ VGND VGND VPWR VPWR _2882_ sky130_fd_sc_hd__o21bai_1
XFILLER_104_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6203_ net426 net306 net433 net303 VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__a22oi_1
XFILLER_98_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7183_ _0888_ _2811_ _2812_ VGND VGND VPWR VPWR _2813_ sky130_fd_sc_hd__nand3_1
XFILLER_112_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6134_ _1760_ _1761_ _1763_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__and3_1
XFILLER_85_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6065_ _1680_ _1687_ _1693_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__nand3_1
X_5016_ _0644_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__xnor2_1
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6967_ _2593_ _2596_ VGND VGND VPWR VPWR _2597_ sky130_fd_sc_hd__xnor2_2
X_8706_ _4065_ _4072_ VGND VGND VPWR VPWR _4257_ sky130_fd_sc_hd__or2_1
X_5918_ _1434_ _1442_ _1441_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__a21o_1
XFILLER_41_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6898_ net326 net482 _2527_ _2525_ VGND VGND VPWR VPWR _2528_ sky130_fd_sc_hd__a31o_1
XFILLER_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8637_ _3972_ _3973_ VGND VGND VPWR VPWR _4197_ sky130_fd_sc_hd__nand2_1
X_5849_ net252 net436 net441 net246 VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__a22o_1
XFILLER_42_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8568_ _4115_ _4135_ _4136_ net182 VGND VGND VPWR VPWR _4137_ sky130_fd_sc_hd__o211a_1
XFILLER_21_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7519_ _3141_ _3144_ net118 VGND VGND VPWR VPWR _3149_ sky130_fd_sc_hd__a21o_1
XFILLER_107_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8499_ _4070_ _4069_ VGND VGND VPWR VPWR _4072_ sky130_fd_sc_hd__and2b_1
XFILLER_89_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_112_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7870_ net491 _3474_ _3475_ adder_inst.exp_larger_r\[1\] _3471_ VGND VGND VPWR VPWR
+ _3476_ sky130_fd_sc_hd__o32a_1
XFILLER_35_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6821_ _2419_ _2421_ _2420_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_18_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6752_ net317 net324 net456 net461 VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__and4_1
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9471_ clknet_leaf_11_clk _0090_ _0381_ VGND VGND VPWR VPWR mul_res\[26\] sky130_fd_sc_hd__dfrtp_1
X_6683_ _2311_ _2312_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__nor2_1
X_5703_ _1329_ _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8422_ _3993_ _3994_ VGND VGND VPWR VPWR _3995_ sky130_fd_sc_hd__nor2_1
X_5634_ _1262_ _1263_ net240 net471 VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__and4bb_1
X_8353_ _3920_ _3923_ VGND VGND VPWR VPWR _3926_ sky130_fd_sc_hd__xor2_2
Xhold100 _0015_ VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd3_1
X_5565_ net287 net424 net430 net281 VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a22oi_1
X_7304_ _2931_ _2932_ VGND VGND VPWR VPWR _2934_ sky130_fd_sc_hd__xor2_1
X_8284_ net138 _3746_ _3813_ net144 VGND VGND VPWR VPWR _3857_ sky130_fd_sc_hd__a211o_1
Xhold133 _0005_ VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 multiplier_inst.man_final_r\[12\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
X_5496_ _1123_ _1124_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__xnor2_1
Xhold111 _0022_ VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold122 multiplier_inst.man_final_r\[2\] VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 multiplier_inst.man_final_r\[15\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
X_7235_ _2846_ _2864_ _2845_ VGND VGND VPWR VPWR _2865_ sky130_fd_sc_hd__o21bai_2
Xhold155 multiplier_inst.man_final_r\[3\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
X_7166_ _2790_ _2791_ VGND VGND VPWR VPWR _2796_ sky130_fd_sc_hd__xnor2_1
XFILLER_85_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6117_ _1741_ _1746_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__nand2b_1
XFILLER_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7097_ _2720_ _2721_ _2726_ VGND VGND VPWR VPWR _2727_ sky130_fd_sc_hd__nand3_1
X_6048_ _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__inv_2
XFILLER_100_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7999_ adder_inst.sum_raw_r\[10\] net188 net177 adder_inst.sum_raw_r\[11\] VGND VGND
+ VPWR VPWR _3588_ sky130_fd_sc_hd__o22a_1
XFILLER_54_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5350_ net347 net279 _0609_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and3_1
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5281_ _0907_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__nand2_1
XFILLER_87_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7020_ _2644_ _2648_ _2649_ VGND VGND VPWR VPWR _2650_ sky130_fd_sc_hd__nand3_1
XFILLER_101_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_4_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_114_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8971_ net545 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__inv_2
XFILLER_67_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7922_ adder_inst.sum_raw_r\[0\] net496 net188 VGND VGND VPWR VPWR _3521_ sky130_fd_sc_hd__or3_1
XFILLER_67_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7853_ net489 _3420_ _3458_ _3457_ VGND VGND VPWR VPWR _3459_ sky130_fd_sc_hd__a31o_1
XFILLER_82_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7784_ net203 _3389_ VGND VGND VPWR VPWR _3390_ sky130_fd_sc_hd__and2_1
X_6804_ net312 net473 _2427_ _2425_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__a31o_1
X_4996_ _0623_ _0624_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand3_1
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6735_ _2356_ _2364_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__nor2_1
XFILLER_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9454_ clknet_leaf_21_clk _0103_ _0364_ VGND VGND VPWR VPWR mul_res\[9\] sky130_fd_sc_hd__dfrtp_1
X_6666_ _2235_ _2236_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__nor2_1
X_9385_ clknet_leaf_10_clk _0060_ _0295_ VGND VGND VPWR VPWR add_res\[31\] sky130_fd_sc_hd__dfrtp_1
X_8405_ _3728_ _3868_ _3872_ _3678_ VGND VGND VPWR VPWR _3978_ sky130_fd_sc_hd__o22ai_4
X_6597_ _2212_ _2224_ _2225_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__nand3_1
X_5617_ _1246_ _1242_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__and2b_1
X_8336_ _3906_ _3908_ VGND VGND VPWR VPWR _3909_ sky130_fd_sc_hd__nand2_1
X_5548_ _1175_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__nor2_1
XFILLER_105_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8267_ net137 _3742_ _3740_ net142 VGND VGND VPWR VPWR _3840_ sky130_fd_sc_hd__o211a_1
XFILLER_3_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5479_ _1098_ _1100_ _1103_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a21o_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7218_ net223 net437 _0941_ _0942_ VGND VGND VPWR VPWR _2848_ sky130_fd_sc_hd__o2bb2a_1
X_8198_ net251 net391 net160 VGND VGND VPWR VPWR _3772_ sky130_fd_sc_hd__mux2_1
Xfanout421 net423 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout410 net413 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_4
Xfanout432 net435 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__clkbuf_4
X_7149_ _2663_ _2670_ _2777_ VGND VGND VPWR VPWR _2779_ sky130_fd_sc_hd__o21ai_1
Xfanout454 net455 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__buf_2
Xfanout443 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__buf_2
Xfanout465 net467 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__buf_2
Xfanout487 adder_inst.sum_raw_r\[24\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__clkbuf_2
XFILLER_100_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout498 net499 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__buf_2
XFILLER_86_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout476 net477 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__buf_2
XFILLER_104_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_100_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4850_ _0477_ _0478_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_28_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6520_ _2145_ _2149_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__nand2b_1
X_4781_ net378 net243 _4415_ _4416_ VGND VGND VPWR VPWR _4552_ sky130_fd_sc_hd__a22o_1
X_6451_ _2006_ _2079_ _2078_ _2064_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__o211a_1
Xclkload20 clknet_leaf_20_clk VGND VGND VPWR VPWR clkload20/Y sky130_fd_sc_hd__clkinv_4
X_9170_ net529 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__inv_2
X_5402_ _1031_ _1030_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__and2b_1
X_6382_ _1929_ _2011_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__nor2_1
X_8121_ _3342_ _3664_ _3687_ VGND VGND VPWR VPWR _3695_ sky130_fd_sc_hd__a21oi_2
X_5333_ _0919_ _0955_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21o_1
XFILLER_114_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8052_ _3628_ _3631_ net204 VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__o21a_1
XFILLER_87_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5264_ _0890_ _0891_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__and3_1
XFILLER_87_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7003_ _2616_ _2630_ _2631_ VGND VGND VPWR VPWR _2633_ sky130_fd_sc_hd__nand3_1
X_5195_ net248 net254 net410 net418 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and4_1
XFILLER_110_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8954_ net541 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__inv_2
XFILLER_83_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7905_ net115 _3506_ _3507_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and3_1
X_8885_ net511 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__inv_2
X_7836_ _3391_ _3441_ net174 _3392_ VGND VGND VPWR VPWR _3442_ sky130_fd_sc_hd__a211o_1
XFILLER_70_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7767_ adder_inst.is_zero_a_r adder_inst.is_inf_b_r adder_inst.is_inf_a_r adder_inst.is_zero_b_r
+ VGND VGND VPWR VPWR _3377_ sky130_fd_sc_hd__a22o_1
X_4979_ net354 net285 VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nand2_1
X_9506_ clknet_leaf_11_clk net670 _0416_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
X_7698_ _3323_ VGND VGND VPWR VPWR _3324_ sky130_fd_sc_hd__inv_2
Xclkload3 clknet_leaf_2_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinv_16
X_6718_ _2341_ _2346_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9437_ clknet_leaf_11_clk multiplier_inst.exp_final\[2\] _0347_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
X_6649_ _2276_ _2277_ _2271_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__a21bo_1
X_9368_ clknet_leaf_18_clk _0041_ _0278_ VGND VGND VPWR VPWR add_res\[14\] sky130_fd_sc_hd__dfrtp_1
X_8319_ _3891_ _3889_ VGND VGND VPWR VPWR _3892_ sky130_fd_sc_hd__nand2b_1
X_9299_ clknet_leaf_1_clk net618 _0209_ VGND VGND VPWR VPWR adder_inst.man_a_r\[11\]
+ sky130_fd_sc_hd__dfrtp_1
Xfanout240 net244 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_2
XFILLER_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout273 net276 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_4
Xfanout251 adder_inst.man_b_r\[16\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_4
Xfanout262 net263 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_1
Xfanout295 net296 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
Xfanout284 net286 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5951_ _1575_ _1579_ _1580_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__nand3_1
XFILLER_92_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8670_ _4056_ _4106_ VGND VGND VPWR VPWR _4226_ sky130_fd_sc_hd__nand2_1
X_4902_ _0513_ _0525_ _0524_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a21o_1
XFILLER_18_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5882_ _1282_ _1283_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__xnor2_1
XFILLER_60_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4833_ _0460_ _0461_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or3_1
X_7621_ _3123_ _3245_ VGND VGND VPWR VPWR _3251_ sky130_fd_sc_hd__xor2_1
X_4764_ _4487_ _4504_ _4533_ VGND VGND VPWR VPWR _4535_ sky130_fd_sc_hd__and3_1
X_7552_ _4370_ net136 _3151_ _3171_ VGND VGND VPWR VPWR _3182_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_99_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6503_ net439 net319 net326 net433 VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__a22oi_1
X_7483_ _3065_ _3112_ VGND VGND VPWR VPWR _3113_ sky130_fd_sc_hd__nor2_1
X_9222_ clknet_leaf_7_clk net17 _0132_ VGND VGND VPWR VPWR adder_inst.exp_a\[1\] sky130_fd_sc_hd__dfrtp_1
X_6434_ _1990_ _2062_ _2063_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__nand3_2
X_4695_ net208 net396 VGND VGND VPWR VPWR _4466_ sky130_fd_sc_hd__nand2_1
X_9153_ net547 VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__inv_2
X_6365_ net301 net309 net439 net444 VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__and4_1
XFILLER_115_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9084_ net520 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__inv_2
XFILLER_102_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8104_ _3675_ _3676_ VGND VGND VPWR VPWR _3678_ sky130_fd_sc_hd__and2_2
XFILLER_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5316_ net212 net218 net437 net442 VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__and4_1
X_6296_ _1848_ _1850_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__xnor2_1
XFILLER_114_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8035_ net486 net489 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3619_ sky130_fd_sc_hd__o21a_1
X_5247_ net350 net344 net316 net322 VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__and4_1
Xhold37 adder_inst.i_b\[20\] VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 adder_inst.i_b\[17\] VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 adder_inst.i_a\[5\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 adder_inst.exp_b\[2\] VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 adder_inst.i_b\[0\] VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_56_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5178_ _0794_ _0795_ _0806_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__a21o_1
XFILLER_83_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8937_ net514 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
XFILLER_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_138 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8868_ net656 mul_res\[20\] net506 VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__mux2_1
X_7819_ adder_inst.sum_raw_r\[14\] adder_inst.sum_raw_r\[16\] net492 _3424_ VGND VGND
+ VPWR VPWR _3425_ sky130_fd_sc_hd__or4_1
XFILLER_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8799_ _1974_ _4277_ _4303_ _4305_ _4275_ VGND VGND VPWR VPWR _4306_ sky130_fd_sc_hd__a2111o_1
XFILLER_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6150_ _1691_ _1692_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__xnor2_1
XFILLER_112_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5101_ net357 net366 net267 net274 VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__and4_1
X_6081_ _1706_ _1707_ _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand3_2
XFILLER_111_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5032_ _0649_ _0654_ _0648_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a21oi_1
XFILLER_93_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6983_ _2584_ _2612_ VGND VGND VPWR VPWR _2613_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_0_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8722_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] net172 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[1\] sky130_fd_sc_hd__mux2_1
X_5934_ _1548_ _1562_ _1563_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_36_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8653_ net105 _4208_ _4210_ net181 VGND VGND VPWR VPWR _4211_ sky130_fd_sc_hd__o211a_1
X_5865_ _1492_ _1493_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7604_ _3223_ _3233_ _4370_ net136 _3151_ VGND VGND VPWR VPWR _3234_ sky130_fd_sc_hd__o2111a_1
X_4816_ net207 net403 _4438_ _4436_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a31o_1
X_8584_ _4099_ _4149_ net106 VGND VGND VPWR VPWR _4151_ sky130_fd_sc_hd__mux2_1
X_5796_ net368 net374 net316 net323 VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__and4_1
X_4747_ net358 net228 net234 net352 VGND VGND VPWR VPWR _4518_ sky130_fd_sc_hd__a22oi_1
XFILLER_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7535_ _1976_ _3164_ _1973_ VGND VGND VPWR VPWR _3165_ sky130_fd_sc_hd__o21ai_1
X_7466_ _3059_ _3086_ _3089_ _3095_ VGND VGND VPWR VPWR _3096_ sky130_fd_sc_hd__a31oi_4
X_4678_ _4445_ _4448_ VGND VGND VPWR VPWR _4449_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9205_ clknet_leaf_22_clk net30 _0115_ VGND VGND VPWR VPWR adder_inst.i_a\[7\] sky130_fd_sc_hd__dfrtp_1
X_7397_ _2800_ _3005_ _3021_ VGND VGND VPWR VPWR _3027_ sky130_fd_sc_hd__or3_1
X_6417_ _2045_ _2046_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__nand2b_1
X_6348_ net422 net331 VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__nand2_1
X_9136_ net528 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_8_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9067_ net546 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__inv_2
XFILLER_76_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6279_ _1825_ _1907_ _1906_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__a21o_1
X_8018_ net117 _3604_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_106_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_61_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5650_ _1250_ _1252_ _1193_ _1209_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__o211ai_1
XFILLER_31_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4601_ _4366_ _4368_ VGND VGND VPWR VPWR _4372_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_96_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5581_ net240 net459 VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__nand2_1
XFILLER_116_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7320_ _2892_ _2946_ _2949_ VGND VGND VPWR VPWR _2950_ sky130_fd_sc_hd__o21bai_2
X_7251_ _2872_ _2880_ _0970_ _2802_ VGND VGND VPWR VPWR _2881_ sky130_fd_sc_hd__o211a_1
XFILLER_116_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6202_ net293 net439 VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7182_ _0885_ _0887_ _0886_ VGND VGND VPWR VPWR _2812_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_5_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6133_ _1683_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__nor2_1
XFILLER_100_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6064_ _1687_ _1693_ _1680_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__a21o_1
X_5015_ net227 net412 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__nand2_1
XFILLER_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6966_ _2594_ _2595_ VGND VGND VPWR VPWR _2596_ sky130_fd_sc_hd__nor2_1
X_8705_ _4074_ _4256_ VGND VGND VPWR VPWR adder_inst.sum_raw\[21\] sky130_fd_sc_hd__xor2_1
X_5917_ _1457_ _1464_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__nand2_1
X_6897_ _2525_ _2526_ VGND VGND VPWR VPWR _2527_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_101_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8636_ _4115_ _4194_ _4195_ _3976_ VGND VGND VPWR VPWR _4196_ sky130_fd_sc_hd__o22a_1
X_5848_ net245 net252 net436 net441 VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__nand4_1
X_8567_ _4098_ _4115_ VGND VGND VPWR VPWR _4136_ sky130_fd_sc_hd__nand2_1
X_5779_ _1387_ _1388_ _1407_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__and4bb_1
X_7518_ _3126_ _3129_ _3140_ _3142_ _3147_ VGND VGND VPWR VPWR _3148_ sky130_fd_sc_hd__a2111o_1
X_8498_ _4069_ _4070_ VGND VGND VPWR VPWR _4071_ sky130_fd_sc_hd__nand2b_1
XFILLER_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7449_ _3053_ _3055_ _3052_ VGND VGND VPWR VPWR _3079_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9119_ net532 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__inv_2
XFILLER_67_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6820_ _2424_ _2430_ _2429_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__a21o_1
XFILLER_35_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6751_ _2326_ _2375_ _2380_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__nand3_1
XFILLER_35_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9470_ clknet_leaf_11_clk _0089_ _0380_ VGND VGND VPWR VPWR mul_res\[25\] sky130_fd_sc_hd__dfrtp_1
X_6682_ _2258_ _2310_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__nor2_1
X_5702_ _1330_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__nor2_1
X_8421_ net417 _3991_ net163 VGND VGND VPWR VPWR _3994_ sky130_fd_sc_hd__mux2_1
X_5633_ net252 net459 net465 net245 VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__a22oi_1
XFILLER_31_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8352_ _3920_ _3923_ VGND VGND VPWR VPWR _3925_ sky130_fd_sc_hd__nor2_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5564_ net281 net287 net424 net430 VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__and4_1
Xhold101 add_res\[11\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlygate4sd3_1
X_7303_ _2931_ _2932_ VGND VGND VPWR VPWR _2933_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8283_ _3831_ _3855_ VGND VGND VPWR VPWR _3856_ sky130_fd_sc_hd__nand2_1
X_5495_ _1124_ _1123_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__nand2b_1
Xhold112 add_res\[10\] VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 mul_res\[5\] VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 mul_res\[9\] VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 adder_inst.sign_sum_r VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 multiplier_inst.man_final_r\[16\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 multiplier_inst.man_final_r\[1\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
X_7234_ _2862_ _2863_ VGND VGND VPWR VPWR _2864_ sky130_fd_sc_hd__or2_1
X_7165_ _2793_ _2794_ VGND VGND VPWR VPWR _2795_ sky130_fd_sc_hd__and2b_2
XPHY_EDGE_ROW_13_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6116_ _1742_ _1744_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__xnor2_1
X_7096_ _2722_ _2725_ VGND VGND VPWR VPWR _2726_ sky130_fd_sc_hd__xnor2_1
XFILLER_73_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6047_ _1656_ _1675_ _1676_ _1355_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__o211a_1
XFILLER_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7998_ _4339_ net501 net496 VGND VGND VPWR VPWR _3587_ sky130_fd_sc_hd__a21oi_1
XFILLER_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6949_ _2575_ _2576_ VGND VGND VPWR VPWR _2579_ sky130_fd_sc_hd__xnor2_1
XFILLER_26_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8619_ _4005_ _4177_ _4004_ VGND VGND VPWR VPWR _4181_ sky130_fd_sc_hd__o21ba_1
XFILLER_10_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_626 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5280_ _0907_ _0908_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__nand3_1
XFILLER_114_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8970_ net542 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__inv_2
XFILLER_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7921_ _3517_ _3518_ _3519_ _3520_ net117 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__o311a_1
XFILLER_82_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7852_ adder_inst.exp_larger_r\[2\] _3406_ adder_inst.exp_larger_r\[3\] VGND VGND
+ VPWR VPWR _3458_ sky130_fd_sc_hd__o21ai_1
XFILLER_36_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7783_ net201 adder_inst.exp_larger_r\[5\] _3387_ VGND VGND VPWR VPWR _3389_ sky130_fd_sc_hd__and3_1
X_6803_ _2388_ _2417_ _2432_ VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__nand3_2
X_4995_ _0482_ _0489_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand2_1
X_6734_ _2361_ _2363_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__nand2_1
X_9453_ clknet_leaf_20_clk _0102_ _0363_ VGND VGND VPWR VPWR mul_res\[8\] sky130_fd_sc_hd__dfrtp_1
X_6665_ _2280_ _2294_ _2226_ _2263_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__a211o_1
X_8404_ _3975_ _3976_ VGND VGND VPWR VPWR _3977_ sky130_fd_sc_hd__or2_1
X_9384_ clknet_leaf_12_clk _0059_ _0294_ VGND VGND VPWR VPWR add_res\[30\] sky130_fd_sc_hd__dfrtp_1
X_6596_ _2212_ _2224_ _2225_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__and3_1
X_5616_ _1243_ _1245_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__nor2_1
X_8335_ net160 _3905_ _3907_ VGND VGND VPWR VPWR _3908_ sky130_fd_sc_hd__a21oi_2
X_5547_ _1175_ _1176_ net277 net430 VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__and4bb_1
X_8266_ net137 _3750_ _3748_ net144 VGND VGND VPWR VPWR _3839_ sky130_fd_sc_hd__o211a_1
X_5478_ _1097_ _1107_ _1076_ _1086_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__a211oi_1
XFILLER_105_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7217_ _2845_ _2846_ VGND VGND VPWR VPWR _2847_ sky130_fd_sc_hd__nor2_1
X_8197_ net242 net385 net160 VGND VGND VPWR VPWR _3771_ sky130_fd_sc_hd__mux2_1
Xfanout411 net412 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__buf_2
Xfanout400 net401 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_4
Xfanout422 net423 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout433 net434 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_2
Xfanout444 net446 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__buf_2
X_7148_ _2663_ _2670_ VGND VGND VPWR VPWR _2778_ sky130_fd_sc_hd__nor2_1
Xfanout455 adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__buf_2
Xfanout466 net467 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_2
Xfanout488 net490 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__buf_2
Xfanout499 adder_inst.sum_raw_r\[19\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__clkbuf_2
Xfanout477 adder_inst.man_a_r\[1\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_2
X_7079_ _2699_ _2708_ VGND VGND VPWR VPWR _2709_ sky130_fd_sc_hd__xor2_1
XFILLER_104_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4780_ net365 net262 _4549_ _4547_ VGND VGND VPWR VPWR _4551_ sky130_fd_sc_hd__a31o_1
XFILLER_20_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload10 clknet_leaf_9_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinv_16
X_6450_ _2064_ _2078_ _2079_ _2006_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__a211oi_2
X_5401_ _0979_ _1028_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__xnor2_1
X_6381_ net280 net463 _1927_ _1928_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__o2bb2a_1
Xclkload21 clknet_leaf_21_clk VGND VGND VPWR VPWR clkload21/Y sky130_fd_sc_hd__clkinv_8
X_8120_ _3685_ _3686_ _3691_ _3692_ VGND VGND VPWR VPWR _3694_ sky130_fd_sc_hd__or4_1
X_5332_ _0581_ _0835_ _0840_ _0847_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__o31a_1
X_8051_ adder_inst.is_zero_r _3461_ VGND VGND VPWR VPWR _3631_ sky130_fd_sc_hd__nor2_1
XFILLER_102_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5263_ _0778_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nor2_1
X_7002_ _2616_ _2630_ _2631_ VGND VGND VPWR VPWR _2632_ sky130_fd_sc_hd__and3_1
X_5194_ _0571_ _0822_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand3_1
XFILLER_110_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8953_ net542 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__inv_2
XFILLER_83_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7904_ net200 adder_inst.sum_raw_r\[4\] _3383_ adder_inst.sum_raw_r\[3\] VGND VGND
+ VPWR VPWR _3507_ sky130_fd_sc_hd__o22a_1
X_8884_ net511 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__inv_2
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7835_ adder_inst.exp_larger_r\[6\] net191 VGND VGND VPWR VPWR _3441_ sky130_fd_sc_hd__nor2_1
XFILLER_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9505_ clknet_leaf_12_clk net653 _0415_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
X_7766_ net720 _3372_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__nor2_1
X_4978_ net366 net279 VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__and2_1
XFILLER_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7697_ net103 _3322_ VGND VGND VPWR VPWR _3323_ sky130_fd_sc_hd__nand2_1
X_6717_ _2346_ _2341_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__nand2b_1
Xclkload4 clknet_leaf_3_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__bufinv_16
X_9436_ clknet_leaf_11_clk multiplier_inst.exp_final\[1\] _0346_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_6648_ _2271_ _2276_ _2277_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__nand3_1
XFILLER_109_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9367_ clknet_leaf_19_clk _0040_ _0277_ VGND VGND VPWR VPWR add_res\[13\] sky130_fd_sc_hd__dfrtp_1
X_8318_ net170 _3888_ _3890_ VGND VGND VPWR VPWR _3891_ sky130_fd_sc_hd__o21ai_2
X_6579_ _2202_ _2207_ _2208_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__nand3_1
XFILLER_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9298_ clknet_leaf_0_clk net612 _0208_ VGND VGND VPWR VPWR adder_inst.man_a_r\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8249_ net326 net161 VGND VGND VPWR VPWR _3822_ sky130_fd_sc_hd__and2_1
Xfanout230 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_4
Xfanout241 net244 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
Xfanout263 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
Xfanout274 net276 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_4
Xfanout252 net254 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__buf_2
XFILLER_101_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout296 adder_inst.man_b_r\[8\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__clkbuf_4
Xfanout285 net286 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_4
XFILLER_74_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5950_ _1577_ _1578_ _1576_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__a21bo_1
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4901_ _0527_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__nand2b_1
XFILLER_18_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7620_ _3247_ _3248_ net112 VGND VGND VPWR VPWR _3250_ sky130_fd_sc_hd__mux2_1
X_5881_ _1508_ _1509_ _1411_ _1414_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__a211oi_2
XFILLER_33_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4832_ net357 net299 net306 net351 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a22oi_1
XFILLER_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4763_ _4487_ _4504_ _4533_ VGND VGND VPWR VPWR _4534_ sky130_fd_sc_hd__a21oi_2
X_7551_ net109 _3180_ VGND VGND VPWR VPWR _3181_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_99_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6502_ net433 net439 net319 net326 VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__and4_1
X_7482_ _3105_ _3111_ VGND VGND VPWR VPWR _3112_ sky130_fd_sc_hd__nand2_1
X_4694_ _4463_ _4464_ VGND VGND VPWR VPWR _4465_ sky130_fd_sc_hd__nor2_1
X_9221_ clknet_leaf_7_clk net16 _0131_ VGND VGND VPWR VPWR adder_inst.exp_a\[0\] sky130_fd_sc_hd__dfrtp_1
X_6433_ _1983_ _1984_ _1989_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__a21o_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9152_ net548 VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__inv_2
X_6364_ _1905_ _1992_ _1991_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__a21o_1
X_9083_ net521 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__inv_2
X_8103_ _3675_ _3676_ VGND VGND VPWR VPWR _3677_ sky130_fd_sc_hd__nand2_1
X_5315_ _0940_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__xnor2_1
X_6295_ _1842_ _1923_ _1922_ _1908_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__o211ai_2
X_8034_ net117 _3618_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and2_1
XFILLER_88_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5246_ _0807_ _0808_ _0809_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a21oi_1
Xhold38 adder_inst.i_b\[3\] VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold27 adder_inst.i_b\[11\] VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 adder_inst.i_a\[7\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 adder_inst.i_a\[17\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_68_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5177_ _0794_ _0795_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand3_2
XFILLER_28_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8936_ net514 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__inv_2
XFILLER_83_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8867_ net622 mul_res\[19\] net507 VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__mux2_1
XFILLER_52_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7818_ adder_inst.sum_raw_r\[10\] adder_inst.sum_raw_r\[13\] adder_inst.sum_raw_r\[12\]
+ adder_inst.sum_raw_r\[15\] VGND VGND VPWR VPWR _3424_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_22_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8798_ _2047_ _4304_ VGND VGND VPWR VPWR _4305_ sky130_fd_sc_hd__xnor2_1
XFILLER_101_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7749_ adder_inst.i_a\[16\] adder_inst.i_a\[19\] adder_inst.i_a\[20\] _3366_ VGND
+ VGND VPWR VPWR _3367_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_22_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9419_ clknet_leaf_21_clk multiplier_inst.man_final\[7\] _0329_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5100_ net372 net261 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nand2_1
X_6080_ _1708_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__and2_1
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5031_ _0536_ _0556_ _0659_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a211oi_2
XFILLER_112_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8721_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] net165 VGND VGND VPWR VPWR
+ adder_inst.exp_larger\[0\] sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6982_ _2600_ _2611_ VGND VGND VPWR VPWR _2612_ sky130_fd_sc_hd__xnor2_2
X_5933_ _1555_ _1556_ _1561_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__a21o_1
X_8652_ _3964_ _4209_ net105 VGND VGND VPWR VPWR _4210_ sky130_fd_sc_hd__o21ai_1
X_5864_ _1493_ _1492_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_36_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8583_ _4149_ VGND VGND VPWR VPWR _4150_ sky130_fd_sc_hd__inv_2
X_7603_ _1082_ _1153_ _3222_ VGND VGND VPWR VPWR _3233_ sky130_fd_sc_hd__and3_1
X_4815_ _0438_ _0443_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_103_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5795_ net382 net310 VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__nand2_1
X_7534_ _2122_ _2257_ _2571_ _2252_ VGND VGND VPWR VPWR _3164_ sky130_fd_sc_hd__o31a_1
X_4746_ net358 net234 _4374_ VGND VGND VPWR VPWR _4517_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_78_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7465_ _3059_ _3093_ _3094_ VGND VGND VPWR VPWR _3095_ sky130_fd_sc_hd__a21oi_1
X_4677_ _4446_ _4447_ VGND VGND VPWR VPWR _4448_ sky130_fd_sc_hd__and2b_1
X_9204_ clknet_leaf_22_clk net29 _0114_ VGND VGND VPWR VPWR adder_inst.i_a\[6\] sky130_fd_sc_hd__dfrtp_1
X_7396_ _3014_ _3018_ _3013_ VGND VGND VPWR VPWR _3026_ sky130_fd_sc_hd__a21oi_1
X_6416_ _1969_ _2044_ _2043_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__a21o_1
XFILLER_103_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6347_ net412 net416 net337 net343 VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__and4_1
X_9135_ net527 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__inv_2
XFILLER_103_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9066_ net545 VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__inv_2
X_6278_ _1825_ _1906_ _1907_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__nand3_2
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8017_ net485 net494 net179 net499 _3603_ VGND VGND VPWR VPWR _3604_ sky130_fd_sc_hd__a221o_1
XFILLER_69_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5229_ _0856_ _0857_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__xnor2_1
XFILLER_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8919_ net518 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
XFILLER_24_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4600_ _4361_ _4369_ VGND VGND VPWR VPWR _4371_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_96_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5580_ _1202_ _1204_ _1203_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__o21ba_1
XFILLER_116_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7250_ _2872_ _2873_ _2879_ VGND VGND VPWR VPWR _2880_ sky130_fd_sc_hd__nor3_1
XFILLER_116_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6201_ net303 net426 net306 net433 VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__and4_1
X_7181_ _2687_ _2689_ _2688_ VGND VGND VPWR VPWR _2811_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_5_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6132_ net258 net459 _1681_ _1682_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__o2bb2a_1
X_6063_ _1691_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__nand2_1
XFILLER_100_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5014_ _0642_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__nor2_1
XFILLER_38_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6965_ net362 net315 net322 net356 VGND VGND VPWR VPWR _2595_ sky130_fd_sc_hd__a22oi_1
X_8704_ net194 _4253_ _4255_ VGND VGND VPWR VPWR _4256_ sky130_fd_sc_hd__o21ai_1
XFILLER_53_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5916_ _1543_ _1544_ _1432_ _1445_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__a211o_1
X_6896_ _2519_ _2520_ _2524_ VGND VGND VPWR VPWR _2526_ sky130_fd_sc_hd__nor3_1
X_8635_ _3974_ _4103_ net105 VGND VGND VPWR VPWR _4195_ sky130_fd_sc_hd__a21o_1
XFILLER_22_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5847_ net240 net447 VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nand2_1
XFILLER_21_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8566_ _3831_ _3855_ _4123_ _4097_ VGND VGND VPWR VPWR _4135_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_86_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5778_ _1405_ _1406_ _1184_ _1191_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__a211o_1
X_8497_ net222 _4068_ net172 VGND VGND VPWR VPWR _4070_ sky130_fd_sc_hd__mux2_1
X_7517_ _3146_ VGND VGND VPWR VPWR _3147_ sky130_fd_sc_hd__inv_2
X_4729_ _4498_ _4499_ VGND VGND VPWR VPWR _4500_ sky130_fd_sc_hd__nor2_1
X_7448_ _3062_ _3077_ VGND VGND VPWR VPWR _3078_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7379_ _3007_ _3008_ VGND VGND VPWR VPWR _3009_ sky130_fd_sc_hd__or2_1
X_9118_ net526 VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_95_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9049_ net526 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__inv_2
XFILLER_67_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6750_ _2377_ _2378_ _2376_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_18_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5701_ net387 net315 net322 net381 VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__a22oi_1
X_6681_ _2258_ _2310_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__and2_1
X_8420_ net279 net170 _3992_ VGND VGND VPWR VPWR _3993_ sky130_fd_sc_hd__o21ai_1
X_5632_ net245 net252 net459 net465 VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__and4_1
X_8351_ _3920_ _3923_ VGND VGND VPWR VPWR _3924_ sky130_fd_sc_hd__nand2_1
X_5563_ _1168_ _1174_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__a21o_1
X_7302_ _2847_ _2864_ VGND VGND VPWR VPWR _2932_ sky130_fd_sc_hd__xnor2_1
X_8282_ _3849_ _3851_ VGND VGND VPWR VPWR _3855_ sky130_fd_sc_hd__xor2_2
Xhold102 _0002_ VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd3_1
X_5494_ _0712_ _0714_ _0711_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__o21ba_1
Xhold113 _0001_ VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 _0027_ VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 _0031_ VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 adder_inst.is_nan_a_r VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 multiplier_inst.sign_res_r VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold168 multiplier_inst.man_final_r\[18\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
X_7233_ _2855_ _2861_ VGND VGND VPWR VPWR _2863_ sky130_fd_sc_hd__nor2_1
X_7164_ _2786_ _2789_ _2792_ VGND VGND VPWR VPWR _2794_ sky130_fd_sc_hd__nand3_1
X_6115_ _1645_ _1742_ _1743_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__or3_1
XFILLER_112_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7095_ _2723_ _2724_ VGND VGND VPWR VPWR _2725_ sky130_fd_sc_hd__and2b_1
X_6046_ _1352_ _1353_ _1354_ _1209_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__a22o_1
XFILLER_37_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7997_ net116 _3586_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__and2_1
XFILLER_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6948_ _1597_ _1599_ _1596_ VGND VGND VPWR VPWR _2578_ sky130_fd_sc_hd__o21ba_1
X_6879_ _2478_ _2485_ _2487_ _2508_ VGND VGND VPWR VPWR _2509_ sky130_fd_sc_hd__and4_1
X_8618_ _4008_ _4175_ net193 _4003_ VGND VGND VPWR VPWR _4180_ sky130_fd_sc_hd__o211a_1
XFILLER_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8549_ _4025_ _4091_ _4116_ VGND VGND VPWR VPWR _4120_ sky130_fd_sc_hd__a21o_1
XFILLER_10_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7920_ net200 adder_inst.sum_raw_r\[7\] adder_inst.sum_raw_r\[6\] _3383_ VGND VGND
+ VPWR VPWR _3520_ sky130_fd_sc_hd__o22a_1
X_7851_ _3452_ _3456_ net489 VGND VGND VPWR VPWR _3457_ sky130_fd_sc_hd__a21oi_1
X_6802_ _2429_ _2430_ _2424_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__a21bo_1
XFILLER_51_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7782_ net203 adder_inst.exp_larger_r\[1\] VGND VGND VPWR VPWR _3388_ sky130_fd_sc_hd__and2_1
X_4994_ _0621_ _0622_ _0606_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a21o_1
X_6733_ _2302_ _2319_ _2352_ _2360_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__o211ai_1
X_6664_ _2280_ _2291_ _2292_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__nand3_1
X_9452_ clknet_leaf_19_clk _0101_ _0362_ VGND VGND VPWR VPWR mul_res\[7\] sky130_fd_sc_hd__dfrtp_1
X_8403_ _3971_ _3973_ VGND VGND VPWR VPWR _3976_ sky130_fd_sc_hd__nor2_1
X_5615_ _1243_ _1244_ net225 net478 VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__and4bb_1
X_9383_ clknet_leaf_12_clk _0057_ _0293_ VGND VGND VPWR VPWR add_res\[29\] sky130_fd_sc_hd__dfrtp_1
X_6595_ _2136_ _2211_ _2210_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__a21o_1
X_8334_ net440 _3342_ _3664_ VGND VGND VPWR VPWR _3907_ sky130_fd_sc_hd__and3_1
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5546_ net287 net419 net424 net281 VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a22oi_1
X_8265_ net146 _3773_ _3837_ _3704_ VGND VGND VPWR VPWR _3838_ sky130_fd_sc_hd__o211a_1
X_5477_ _1097_ _1104_ _1105_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nand3_1
X_7216_ _0935_ _2837_ _2844_ VGND VGND VPWR VPWR _2846_ sky130_fd_sc_hd__a21oi_1
X_8196_ _3768_ _3769_ net141 VGND VGND VPWR VPWR _3770_ sky130_fd_sc_hd__mux2_1
Xfanout401 adder_inst.man_a_r\[14\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__clkbuf_2
Xfanout412 net413 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__clkbuf_4
Xfanout423 adder_inst.man_a_r\[10\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_4
Xfanout445 net446 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__clkbuf_2
Xfanout434 net435 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_4
Xfanout456 net458 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_4
X_7147_ _2641_ _2676_ _2675_ VGND VGND VPWR VPWR _2777_ sky130_fd_sc_hd__a21bo_1
Xfanout489 net490 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__buf_2
Xfanout467 adder_inst.man_a_r\[2\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__clkbuf_4
Xfanout478 net479 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__buf_2
X_7078_ _2706_ _2707_ VGND VGND VPWR VPWR _2708_ sky130_fd_sc_hd__and2b_1
XFILLER_104_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6029_ _1196_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__nor2_1
XFILLER_39_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_32_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload11 clknet_leaf_10_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinv_4
X_6380_ _1921_ _2008_ _2007_ _1993_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__o211a_1
X_5400_ _1020_ _1021_ _1024_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_41_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5331_ _0920_ _0954_ _0919_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a21bo_1
X_8050_ _3628_ _3630_ net204 VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__o21a_1
X_7001_ _2623_ _2624_ _2629_ VGND VGND VPWR VPWR _2631_ sky130_fd_sc_hd__a21o_1
X_5262_ net351 net310 net316 net348 VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__a22oi_1
XFILLER_102_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5193_ _0568_ _0570_ _0569_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__o21ai_1
XFILLER_110_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_50_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8952_ net541 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__inv_2
XFILLER_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8883_ net543 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__inv_2
X_7903_ adder_inst.sum_raw_r\[0\] net494 _3413_ _3505_ VGND VGND VPWR VPWR _3506_
+ sky130_fd_sc_hd__a31o_1
XFILLER_83_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7834_ adder_inst.exp_larger_r\[6\] _3422_ VGND VGND VPWR VPWR _3440_ sky130_fd_sc_hd__nand2_1
X_7765_ adder_inst.is_zero_b_r net700 VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__or2_1
X_9504_ clknet_leaf_12_clk net655 _0414_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_6716_ _2343_ _2344_ _2342_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__o21ba_1
X_4977_ _0472_ _0474_ _0473_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__o21bai_1
X_7696_ _3290_ _3312_ _3321_ VGND VGND VPWR VPWR _3322_ sky130_fd_sc_hd__and3_1
Xclkload5 clknet_leaf_4_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_16
X_9435_ clknet_leaf_9_clk multiplier_inst.exp_final\[0\] _0345_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
X_6647_ _2199_ _2265_ _2270_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__a21o_1
X_6578_ _2126_ _2201_ _2200_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__a21o_1
X_9366_ clknet_leaf_19_clk _0039_ _0276_ VGND VGND VPWR VPWR add_res\[12\] sky130_fd_sc_hd__dfrtp_1
X_8317_ adder_inst.man_a_r\[4\] net170 VGND VGND VPWR VPWR _3890_ sky130_fd_sc_hd__nand2_1
XFILLER_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5529_ net393 net398 net314 net321 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__and4_1
X_9297_ clknet_leaf_3_clk net563 _0207_ VGND VGND VPWR VPWR adder_inst.man_a_r\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_8248_ _3678_ _3811_ _3816_ net122 VGND VGND VPWR VPWR _3821_ sky130_fd_sc_hd__o31ai_1
XFILLER_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8179_ net175 _3680_ net155 _3699_ _3752_ VGND VGND VPWR VPWR _3753_ sky130_fd_sc_hd__a41o_1
Xfanout231 net233 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_2
Xfanout220 adder_inst.man_b_r\[21\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_2
Xfanout242 net244 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout253 net254 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__buf_2
Xfanout264 net266 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_2
XFILLER_86_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout275 net276 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout286 adder_inst.man_b_r\[10\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_2
XFILLER_75_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_70_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout297 net303 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__buf_2
XFILLER_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4900_ _0527_ _0528_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__or3_1
X_5880_ _1411_ _1414_ _1508_ _1509_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__o211a_1
X_4831_ net363 net294 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
X_4762_ _4531_ _4532_ VGND VGND VPWR VPWR _4533_ sky130_fd_sc_hd__or2_1
X_7550_ _3015_ _3179_ VGND VGND VPWR VPWR _3180_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_99_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6501_ net313 net444 VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__nand2_1
X_7481_ _3103_ _3104_ VGND VGND VPWR VPWR _3111_ sky130_fd_sc_hd__nand2_1
X_4693_ net219 net384 net389 net211 VGND VGND VPWR VPWR _4464_ sky130_fd_sc_hd__a22oi_1
X_9220_ clknet_leaf_1_clk net15 _0130_ VGND VGND VPWR VPWR adder_inst.i_a\[22\] sky130_fd_sc_hd__dfrtp_1
X_6432_ _2055_ _2060_ _2054_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__a21bo_1
X_9151_ net542 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__inv_2
X_8102_ _3673_ _3674_ _3273_ VGND VGND VPWR VPWR _3676_ sky130_fd_sc_hd__a21bo_1
X_6363_ _1905_ _1991_ _1992_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__nand3_2
X_9082_ net521 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__inv_2
X_5314_ _0941_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__nor2_1
X_6294_ _1908_ _1922_ _1923_ _1842_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__a211o_1
XFILLER_102_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8033_ net487 net488 net179 net491 _3617_ VGND VGND VPWR VPWR _3618_ sky130_fd_sc_hd__a221o_1
X_5245_ _0851_ _0852_ _0853_ _0812_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__o22a_1
Xhold28 adder_inst.i_b\[8\] VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 adder_inst.i_a\[3\] VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_96_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold39 adder_inst.i_a\[0\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd3_1
X_5176_ _0802_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_108_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8935_ net514 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__inv_2
XFILLER_37_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8866_ net646 mul_res\[18\] net505 VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__mux2_1
XFILLER_24_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7817_ adder_inst.exp_larger_r\[6\] _3422_ VGND VGND VPWR VPWR _3423_ sky130_fd_sc_hd__or2_1
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8797_ _2121_ _4279_ _2120_ VGND VGND VPWR VPWR _4304_ sky130_fd_sc_hd__a21bo_1
XFILLER_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7748_ adder_inst.i_a\[9\] adder_inst.i_a\[10\] adder_inst.i_a\[12\] adder_inst.i_a\[15\]
+ VGND VGND VPWR VPWR _3366_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_22_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7679_ _3303_ _3304_ VGND VGND VPWR VPWR _3305_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_50_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9418_ clknet_leaf_21_clk multiplier_inst.man_final\[6\] _0328_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
X_9349_ clknet_leaf_10_clk adder_inst.is_nan_a _0259_ VGND VGND VPWR VPWR adder_inst.is_nan_a_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_106_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_115_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5030_ _0656_ _0658_ _0623_ _0626_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__o211a_1
XFILLER_78_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6981_ _2601_ _2610_ VGND VGND VPWR VPWR _2611_ sky130_fd_sc_hd__xor2_2
X_8720_ net209 _3355_ _4084_ _4087_ _4264_ VGND VGND VPWR VPWR adder_inst.sum_raw\[24\]
+ sky130_fd_sc_hd__a32o_1
X_5932_ _1555_ _1556_ _1561_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_0_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8651_ _4201_ _3965_ VGND VGND VPWR VPWR _4209_ sky130_fd_sc_hd__and2b_1
X_5863_ _1238_ _1240_ _1239_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__o21ba_1
X_8582_ _3878_ _3894_ _3897_ _4135_ _3879_ VGND VGND VPWR VPWR _4149_ sky130_fd_sc_hd__a221oi_2
X_7602_ net112 _3227_ _3228_ _3231_ VGND VGND VPWR VPWR _3232_ sky130_fd_sc_hd__o31a_1
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5794_ _1421_ _1422_ _1416_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__a21o_1
XFILLER_33_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4814_ _0443_ _0438_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_103_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4745_ _4484_ _4515_ VGND VGND VPWR VPWR _4516_ sky130_fd_sc_hd__xnor2_1
X_7533_ _3160_ _3162_ net111 VGND VGND VPWR VPWR _3163_ sky130_fd_sc_hd__mux2_1
X_7464_ _3086_ _3091_ _3089_ VGND VGND VPWR VPWR _3094_ sky130_fd_sc_hd__a21o_1
X_4676_ net353 net247 net253 net346 VGND VGND VPWR VPWR _4447_ sky130_fd_sc_hd__a22o_1
X_9203_ clknet_leaf_22_clk net28 _0113_ VGND VGND VPWR VPWR adder_inst.i_a\[5\] sky130_fd_sc_hd__dfrtp_1
X_7395_ _2887_ _2951_ _3024_ _2886_ VGND VGND VPWR VPWR _3025_ sky130_fd_sc_hd__a211oi_1
X_6415_ _1969_ _2043_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__and3_1
X_9134_ net527 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__inv_2
X_6346_ _1974_ _1975_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__nand2_1
X_9065_ net544 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__inv_2
XFILLER_88_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8016_ adder_inst.sum_raw_r\[16\] _3504_ _3601_ _3602_ VGND VGND VPWR VPWR _3603_
+ sky130_fd_sc_hd__o211a_1
X_6277_ _1818_ _1819_ _1824_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__a21o_1
X_5228_ _0814_ _0851_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__o21ba_1
X_5159_ net348 net310 _0787_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_55_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8918_ net519 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__inv_2
XFILLER_112_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8849_ net665 mul_res\[1\] net505 VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__mux2_1
XFILLER_25_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7180_ _2702_ _2704_ VGND VGND VPWR VPWR _2810_ sky130_fd_sc_hd__nand2_1
X_6200_ _1732_ _1827_ _1826_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__a21o_1
X_6131_ _1663_ _1754_ _1759_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__a21o_1
XFILLER_97_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6062_ _1684_ _1686_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__xnor2_1
X_5013_ net238 net402 net408 net232 VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a22oi_1
XFILLER_66_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_18_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6964_ net356 net362 net315 net322 VGND VGND VPWR VPWR _2594_ sky130_fd_sc_hd__and4_1
X_6895_ _2520_ _2524_ _2519_ VGND VGND VPWR VPWR _2525_ sky130_fd_sc_hd__o21a_1
X_8703_ net194 _4254_ VGND VGND VPWR VPWR _4255_ sky130_fd_sc_hd__nand2_1
X_5915_ _1432_ _1445_ _1543_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__o211ai_1
X_8634_ _3974_ _4186_ _3976_ VGND VGND VPWR VPWR _4194_ sky130_fd_sc_hd__a21oi_1
X_5846_ net259 net436 _1400_ _1399_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__a31o_1
XFILLER_21_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8565_ _4126_ _4127_ _3831_ VGND VGND VPWR VPWR _4134_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_60_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5777_ _1184_ _1191_ _1405_ _1406_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__o211ai_2
X_8496_ adder_inst.man_a_r\[21\] _4068_ net165 VGND VGND VPWR VPWR _4069_ sky130_fd_sc_hd__mux2_1
X_7516_ _3144_ _3145_ VGND VGND VPWR VPWR _3146_ sky130_fd_sc_hd__and2_1
X_4728_ net218 net377 net384 net211 VGND VGND VPWR VPWR _4499_ sky130_fd_sc_hd__a22oi_1
XFILLER_107_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4659_ net226 net390 VGND VGND VPWR VPWR _4430_ sky130_fd_sc_hd__nand2_1
X_7447_ _3049_ _3050_ _3057_ VGND VGND VPWR VPWR _3077_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_116_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7378_ _2988_ _2995_ VGND VGND VPWR VPWR _3008_ sky130_fd_sc_hd__xnor2_1
XFILLER_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9117_ net531 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__inv_2
XFILLER_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6329_ _1957_ _1958_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__or2_1
XFILLER_103_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9048_ net528 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__inv_2
XFILLER_76_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5700_ net381 net387 net315 net322 VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__and4_1
X_6680_ _2247_ _2259_ _2309_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_100_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5631_ _1219_ _1258_ _1259_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__or3_1
X_8350_ net159 _3919_ _3922_ VGND VGND VPWR VPWR _3923_ sky130_fd_sc_hd__a21oi_2
X_5562_ _1185_ _1190_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__xnor2_1
X_8281_ _3849_ _3851_ VGND VGND VPWR VPWR _3854_ sky130_fd_sc_hd__and2_1
XFILLER_8_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7301_ _2826_ _2902_ _2903_ _2906_ VGND VGND VPWR VPWR _2931_ sky130_fd_sc_hd__a31o_1
Xhold114 mul_res\[31\] VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 mul_res\[28\] VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlygate4sd3_1
X_5493_ _1121_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__and2_1
Xhold125 multiplier_inst.man_final_r\[13\] VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlygate4sd3_1
X_7232_ _2855_ _2861_ VGND VGND VPWR VPWR _2862_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
Xhold136 add_ovf VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 _0070_ VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 add_res\[26\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
Xhold169 multiplier_inst.exp_final_r\[4\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
X_7163_ _2789_ _2792_ _2786_ VGND VGND VPWR VPWR _2793_ sky130_fd_sc_hd__a21oi_1
XFILLER_98_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7094_ net272 net406 net410 net266 VGND VGND VPWR VPWR _2724_ sky130_fd_sc_hd__a22o_1
X_6114_ _1645_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__nor2_1
XFILLER_98_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6045_ _1657_ _1656_ _1673_ _1674_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and4bb_1
XFILLER_85_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7996_ net484 net503 adder_inst.sum_raw_r\[16\] net178 _3585_ VGND VGND VPWR VPWR
+ _3586_ sky130_fd_sc_hd__a221o_1
XFILLER_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6947_ _1594_ _1601_ _2575_ VGND VGND VPWR VPWR _2577_ sky130_fd_sc_hd__o21ai_1
X_6878_ _2490_ _2507_ VGND VGND VPWR VPWR _2508_ sky130_fd_sc_hd__nor2_1
X_8617_ _4007_ _4179_ VGND VGND VPWR VPWR adder_inst.sum_raw\[10\] sky130_fd_sc_hd__xnor2_1
XFILLER_10_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5829_ net258 net431 VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__nand2_1
X_8548_ _4092_ _4119_ VGND VGND VPWR VPWR adder_inst.sum_raw\[1\] sky130_fd_sc_hd__xnor2_1
XFILLER_10_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8479_ net251 net163 _3776_ _3981_ VGND VGND VPWR VPWR _4052_ sky130_fd_sc_hd__a22o_1
XFILLER_76_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7850_ net491 net494 _3450_ _3451_ _3455_ VGND VGND VPWR VPWR _3456_ sky130_fd_sc_hd__o41a_1
XFILLER_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6801_ _2424_ _2429_ _2430_ VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__nand3_1
XFILLER_63_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7781_ _4346_ _3386_ VGND VGND VPWR VPWR _3387_ sky130_fd_sc_hd__nor2_1
X_4993_ _0606_ _0621_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand3_2
X_6732_ _2361_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__inv_2
X_6663_ _2280_ _2291_ _2292_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__and3_1
X_9451_ clknet_leaf_21_clk _0100_ _0361_ VGND VGND VPWR VPWR mul_res\[6\] sky130_fd_sc_hd__dfrtp_1
X_8402_ _3974_ VGND VGND VPWR VPWR _3975_ sky130_fd_sc_hd__inv_2
X_5614_ net236 net465 net471 net230 VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__a22oi_1
X_9382_ clknet_leaf_13_clk _0056_ _0292_ VGND VGND VPWR VPWR add_res\[28\] sky130_fd_sc_hd__dfrtp_1
X_6594_ _2217_ _2222_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__xnor2_1
X_8333_ net302 _3905_ net168 VGND VGND VPWR VPWR _3906_ sky130_fd_sc_hd__mux2_2
X_5545_ net281 net287 net419 net424 VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__and4_1
X_8264_ net137 _3737_ _3735_ net145 VGND VGND VPWR VPWR _3837_ sky130_fd_sc_hd__o211ai_1
X_5476_ _1097_ _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__and3_1
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8195_ net238 net379 net160 VGND VGND VPWR VPWR _3769_ sky130_fd_sc_hd__mux2_1
X_7215_ _0935_ _2837_ _2844_ VGND VGND VPWR VPWR _2845_ sky130_fd_sc_hd__and3_1
Xfanout402 net403 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__buf_2
Xfanout413 adder_inst.man_a_r\[12\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkbuf_4
X_7146_ _2666_ _2668_ _2665_ VGND VGND VPWR VPWR _2776_ sky130_fd_sc_hd__o21ba_1
Xfanout435 adder_inst.man_a_r\[8\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__clkbuf_2
Xfanout457 net458 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_1
Xfanout446 adder_inst.man_a_r\[6\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__clkbuf_4
Xfanout424 net425 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__buf_2
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout468 net470 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__buf_2
XFILLER_58_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout479 adder_inst.man_a_r\[0\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__clkbuf_4
X_7077_ _2704_ _2705_ _2700_ VGND VGND VPWR VPWR _2707_ sky130_fd_sc_hd__a21o_1
XFILLER_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6028_ net277 net436 _1194_ _1195_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7979_ adder_inst.sum_raw_r\[11\] _3570_ net197 VGND VGND VPWR VPWR _3571_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload12 clknet_leaf_11_clk VGND VGND VPWR VPWR clkload12/X sky130_fd_sc_hd__clkbuf_4
X_5330_ _0917_ _0959_ net152 _0875_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__a211oi_2
X_5261_ _0883_ _0884_ _0889_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__a21o_1
X_7000_ _2623_ _2624_ _2629_ VGND VGND VPWR VPWR _2630_ sky130_fd_sc_hd__nand3_2
X_5192_ net259 net405 _0820_ _0818_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a31o_1
XFILLER_110_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8951_ net541 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__inv_2
X_7902_ adder_inst.sum_raw_r\[2\] net488 _3462_ adder_inst.sum_raw_r\[1\] _3394_ VGND
+ VGND VPWR VPWR _3505_ sky130_fd_sc_hd__a221o_1
X_8882_ net543 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__inv_2
XFILLER_36_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7833_ net191 _3438_ _3437_ net174 VGND VGND VPWR VPWR _3439_ sky130_fd_sc_hd__a211o_1
X_7764_ _3371_ _3375_ _3376_ VGND VGND VPWR VPWR adder_inst.is_inf_a sky130_fd_sc_hd__and3_1
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9503_ clknet_leaf_12_clk net708 _0413_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_6715_ _2342_ _2344_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__nor2_1
X_4976_ _0601_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__and2_1
X_7695_ _3315_ _3320_ VGND VGND VPWR VPWR _3321_ sky130_fd_sc_hd__nor2_1
XFILLER_51_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload6 clknet_leaf_5_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_16
X_6646_ _2274_ _2275_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__xnor2_1
X_9434_ clknet_leaf_17_clk multiplier_inst.man_final\[22\] _0344_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[22\] sky130_fd_sc_hd__dfrtp_1
X_6577_ _2205_ _2206_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__xnor2_1
X_9365_ clknet_leaf_18_clk _0038_ _0275_ VGND VGND VPWR VPWR add_res\[11\] sky130_fd_sc_hd__dfrtp_1
X_8316_ net165 _3888_ _3881_ VGND VGND VPWR VPWR _3889_ sky130_fd_sc_hd__o21ai_2
X_5528_ _1136_ _1157_ _1155_ _1154_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__o211a_1
XFILLER_105_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9296_ clknet_leaf_1_clk net585 _0206_ VGND VGND VPWR VPWR adder_inst.man_a_r\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8247_ _3799_ _3805_ net127 VGND VGND VPWR VPWR _3820_ sky130_fd_sc_hd__a21oi_1
X_5459_ _0737_ _1059_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and3_1
X_8178_ _3751_ VGND VGND VPWR VPWR _3752_ sky130_fd_sc_hd__inv_2
Xfanout232 net233 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_2
Xfanout221 net222 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_2
Xfanout210 net213 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_2
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_2
X_7129_ _2756_ _2757_ VGND VGND VPWR VPWR _2759_ sky130_fd_sc_hd__xnor2_1
Xfanout265 net266 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__clkbuf_2
Xfanout254 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__buf_4
XFILLER_101_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout276 adder_inst.man_b_r\[12\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout287 net290 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_2
XFILLER_19_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout298 net299 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_2
XFILLER_47_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4830_ net351 net357 net299 net306 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__and4_1
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4761_ _4516_ _4530_ VGND VGND VPWR VPWR _4532_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_99_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6500_ _2051_ _2128_ _2127_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__a21o_1
X_7480_ _3081_ _3108_ VGND VGND VPWR VPWR _3110_ sky130_fd_sc_hd__xnor2_1
X_4692_ net211 net219 net384 net389 VGND VGND VPWR VPWR _4463_ sky130_fd_sc_hd__and4_1
X_6431_ _2054_ _2055_ _2060_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__nand3_1
X_9150_ net542 VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__inv_2
X_6362_ _1898_ _1899_ _1904_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__a21o_1
X_8101_ _3273_ _3673_ _3674_ VGND VGND VPWR VPWR _3675_ sky130_fd_sc_hd__nand3b_2
X_5313_ _0941_ _0942_ net223 net437 VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__and4bb_1
X_9081_ net518 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__inv_2
XFILLER_88_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6293_ _1828_ _1830_ _1841_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__a21oi_1
X_8032_ net494 net196 net190 _3616_ VGND VGND VPWR VPWR _3617_ sky130_fd_sc_hd__o211a_1
X_5244_ _0855_ _0863_ _0862_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__o21ai_1
Xhold18 adder_inst.i_a\[22\] VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 adder_inst.i_a\[16\] VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__dlygate4sd3_1
X_5175_ _0802_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand3_1
XFILLER_29_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8934_ net515 VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__inv_2
XFILLER_45_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_108_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8865_ net629 mul_res\[17\] net505 VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__mux2_1
X_7816_ _3419_ _3421_ adder_inst.exp_larger_r\[5\] VGND VGND VPWR VPWR _3422_ sky130_fd_sc_hd__a21o_1
X_8796_ _1974_ _4277_ _4278_ _4280_ _4302_ VGND VGND VPWR VPWR _4303_ sky130_fd_sc_hd__o2111ai_1
X_7747_ adder_inst.i_a\[1\] adder_inst.i_a\[0\] adder_inst.i_a\[3\] adder_inst.i_a\[2\]
+ VGND VGND VPWR VPWR _3365_ sky130_fd_sc_hd__or4_1
X_4959_ _0587_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_22_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7678_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] VGND VGND VPWR VPWR _3304_
+ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_50_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6629_ _2195_ _2243_ _2246_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__or3_1
X_9417_ clknet_leaf_21_clk multiplier_inst.man_final\[5\] _0327_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
X_9348_ clknet_leaf_12_clk net556 _0258_ VGND VGND VPWR VPWR adder_inst.i_vld_r2 sky130_fd_sc_hd__dfrtp_1
XFILLER_105_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9279_ clknet_leaf_17_clk adder_inst.sum_raw\[16\] _0189_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[16\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_72_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6980_ _2608_ _2609_ VGND VGND VPWR VPWR _2610_ sky130_fd_sc_hd__and2b_1
X_5931_ _1557_ _1560_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__xnor2_1
XFILLER_80_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8650_ _3964_ _4104_ _3965_ VGND VGND VPWR VPWR _4208_ sky130_fd_sc_hd__o21a_1
XFILLER_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5862_ _1488_ _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__xnor2_2
X_8581_ _4146_ _4147_ VGND VGND VPWR VPWR _4148_ sky130_fd_sc_hd__nand2_1
X_7601_ _4370_ net136 _3151_ _3230_ VGND VGND VPWR VPWR _3231_ sky130_fd_sc_hd__a31o_1
X_5793_ _1416_ _1421_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__nand3_1
X_4813_ _4435_ _4440_ _4434_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_103_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4744_ net345 net241 _4401_ VGND VGND VPWR VPWR _4515_ sky130_fd_sc_hd__and3_1
X_7532_ _2795_ _3161_ VGND VGND VPWR VPWR _3162_ sky130_fd_sc_hd__xnor2_2
X_9202_ clknet_leaf_22_clk net27 _0112_ VGND VGND VPWR VPWR adder_inst.i_a\[4\] sky130_fd_sc_hd__dfrtp_1
X_7463_ _3092_ VGND VGND VPWR VPWR _3093_ sky130_fd_sc_hd__inv_2
X_4675_ net353 net346 net247 net253 VGND VGND VPWR VPWR _4446_ sky130_fd_sc_hd__and4_1
X_7394_ _2888_ _2952_ _3023_ VGND VGND VPWR VPWR _3024_ sky130_fd_sc_hd__and3_1
X_6414_ _1885_ _1968_ _1967_ _1964_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__o211ai_1
X_6345_ _1969_ _1971_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__xnor2_1
X_9133_ net527 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__inv_2
X_9064_ net545 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__inv_2
XFILLER_88_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6276_ _1899_ _1904_ _1898_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__a21bo_1
XFILLER_102_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8015_ net501 net195 _3463_ net503 net190 VGND VGND VPWR VPWR _3602_ sky130_fd_sc_hd__o221a_1
X_5227_ _0584_ _0589_ _0583_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__o21a_1
XFILLER_29_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5158_ _0780_ _0781_ _0786_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21o_1
X_5089_ _0688_ _0717_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__and3_1
XFILLER_56_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8917_ net518 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_55_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8848_ net642 mul_res\[0\] net504 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__mux2_1
XFILLER_24_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8779_ _2553_ _2558_ VGND VGND VPWR VPWR _4286_ sky130_fd_sc_hd__xor2_1
XFILLER_52_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6130_ _1663_ _1754_ _1759_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__nand3_1
XFILLER_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6061_ net246 net254 net465 net471 _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__a41o_1
X_5012_ net232 net238 net402 net408 VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__and4_1
XFILLER_81_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_105_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6963_ net368 net310 VGND VGND VPWR VPWR _2593_ sky130_fd_sc_hd__nand2_1
X_6894_ _2521_ _2523_ VGND VGND VPWR VPWR _2524_ sky130_fd_sc_hd__nor2_1
X_8702_ _4059_ _4060_ _4062_ _4067_ _4250_ VGND VGND VPWR VPWR _4254_ sky130_fd_sc_hd__a32o_1
X_5914_ _1530_ _1531_ _1542_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a21o_1
XFILLER_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8633_ _3977_ _4193_ VGND VGND VPWR VPWR adder_inst.sum_raw\[12\] sky130_fd_sc_hd__xnor2_1
X_5845_ _1226_ _1228_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__nand2_1
XFILLER_22_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8564_ _3824_ _3827_ VGND VGND VPWR VPWR _4133_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5776_ _1403_ _1404_ _1389_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__a21o_1
XFILLER_22_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8495_ _3678_ net130 net122 _3871_ VGND VGND VPWR VPWR _4068_ sky130_fd_sc_hd__and4_1
X_7515_ _3106_ _3109_ _3143_ VGND VGND VPWR VPWR _3145_ sky130_fd_sc_hd__or3_1
X_4727_ net211 net218 net377 net384 VGND VGND VPWR VPWR _4498_ sky130_fd_sc_hd__and4_1
X_7446_ _3074_ _3075_ VGND VGND VPWR VPWR _3076_ sky130_fd_sc_hd__nor2_1
X_4658_ net231 net237 net378 net384 VGND VGND VPWR VPWR _4429_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_116_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9116_ net531 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__inv_2
X_7377_ _2775_ _2782_ _2774_ VGND VGND VPWR VPWR _3007_ sky130_fd_sc_hd__a21boi_2
XFILLER_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4589_ net208 net346 VGND VGND VPWR VPWR _4360_ sky130_fd_sc_hd__nand2_1
X_6328_ _1937_ _1939_ _1956_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__and3_1
XFILLER_103_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9047_ net525 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__inv_2
X_6259_ _1806_ _1888_ _1887_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5630_ _1219_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__nor2_1
X_5561_ _1185_ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__and2_1
X_8280_ _3849_ _3851_ VGND VGND VPWR VPWR _3853_ sky130_fd_sc_hd__nor2_1
X_5492_ _0719_ _0721_ _1120_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__or3b_1
X_7300_ _2914_ _2929_ VGND VGND VPWR VPWR _2930_ sky130_fd_sc_hd__or2_1
Xhold115 _0024_ VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 _0020_ VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 multiplier_inst.man_final_r\[14\] VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlygate4sd3_1
X_7231_ _2859_ _2860_ VGND VGND VPWR VPWR _2861_ sky130_fd_sc_hd__nor2_1
Xhold137 _0032_ VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 _0018_ VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
Xhold148 multiplier_inst.man_final_r\[5\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
X_7162_ _2791_ _2790_ VGND VGND VPWR VPWR _2792_ sky130_fd_sc_hd__nand2b_1
XFILLER_112_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7093_ net266 net272 net406 net410 VGND VGND VPWR VPWR _2723_ sky130_fd_sc_hd__and4_1
X_6113_ net293 net424 _1643_ _1644_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_111_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6044_ _1671_ _1672_ _1665_ _1669_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__a211o_1
XFILLER_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7995_ adder_inst.sum_raw_r\[13\] _3504_ _3583_ _3584_ VGND VGND VPWR VPWR _3585_
+ sky130_fd_sc_hd__o211a_1
XFILLER_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6946_ _1594_ _1601_ VGND VGND VPWR VPWR _2576_ sky130_fd_sc_hd__nor2_1
XFILLER_26_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6877_ _2500_ _2505_ _2504_ VGND VGND VPWR VPWR _2507_ sky130_fd_sc_hd__a21oi_1
X_8616_ _4175_ _4178_ net180 VGND VGND VPWR VPWR _4179_ sky130_fd_sc_hd__mux2_1
X_5828_ _1454_ _1455_ _1456_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__a21o_1
X_8547_ net194 _4118_ _4117_ VGND VGND VPWR VPWR _4119_ sky130_fd_sc_hd__o21ai_1
XFILLER_10_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5759_ _1339_ _1347_ _1346_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__a21o_1
X_8478_ _4050_ VGND VGND VPWR VPWR _4051_ sky130_fd_sc_hd__inv_2
X_7429_ _4481_ _3058_ VGND VGND VPWR VPWR _3059_ sky130_fd_sc_hd__and2_2
XFILLER_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6800_ _2379_ _2418_ _2423_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__a21o_1
XFILLER_75_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7780_ adder_inst.exp_larger_r\[1\] net202 VGND VGND VPWR VPWR _3386_ sky130_fd_sc_hd__nand2_1
X_4992_ _0614_ _0615_ _0620_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__a21o_1
XFILLER_63_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6731_ _2352_ _2360_ _2302_ _2319_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__a211o_1
XFILLER_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6662_ _2209_ _2264_ _2279_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__a21o_1
X_9450_ clknet_leaf_20_clk _0099_ _0360_ VGND VGND VPWR VPWR mul_res\[5\] sky130_fd_sc_hd__dfrtp_1
X_9381_ clknet_leaf_12_clk _0055_ _0291_ VGND VGND VPWR VPWR add_res\[27\] sky130_fd_sc_hd__dfrtp_1
X_8401_ _3971_ _3973_ VGND VGND VPWR VPWR _3974_ sky130_fd_sc_hd__nand2_1
X_5613_ net230 net236 net465 net471 VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__and4_1
X_8332_ net123 _3904_ _3902_ _3903_ VGND VGND VPWR VPWR _3905_ sky130_fd_sc_hd__a2bb2o_1
X_6593_ _2222_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__inv_2
X_5544_ _1172_ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__nand2b_1
XFILLER_105_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8263_ net128 _3833_ _3834_ _3835_ net126 VGND VGND VPWR VPWR _3836_ sky130_fd_sc_hd__o221ai_1
X_5475_ _1065_ _1087_ _1096_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__o21ai_1
X_8194_ net232 net372 net160 VGND VGND VPWR VPWR _3768_ sky130_fd_sc_hd__mux2_1
X_7214_ _2841_ _2842_ _2840_ VGND VGND VPWR VPWR _2844_ sky130_fd_sc_hd__a21bo_1
Xfanout403 adder_inst.man_a_r\[14\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkbuf_4
X_7145_ _2683_ _2773_ VGND VGND VPWR VPWR _2775_ sky130_fd_sc_hd__xnor2_1
Xfanout414 net418 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__buf_2
XFILLER_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout436 net438 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__buf_2
Xfanout447 net449 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__buf_2
Xfanout425 net429 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_4
Xfanout469 net470 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout458 adder_inst.man_a_r\[4\] VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__buf_2
X_7076_ _2700_ _2704_ _2705_ VGND VGND VPWR VPWR _2706_ sky130_fd_sc_hd__and3_1
XFILLER_104_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6027_ _1319_ _1655_ _1654_ _1641_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a211oi_1
XFILLER_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7978_ adder_inst.sum_raw_r\[10\] net496 _3568_ _3569_ VGND VGND VPWR VPWR _3570_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_64_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6929_ _2553_ _2558_ VGND VGND VPWR VPWR _2559_ sky130_fd_sc_hd__or2_1
XFILLER_80_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_150 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload13 clknet_leaf_12_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_9_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5260_ _0883_ _0884_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nand3_1
XFILLER_114_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5191_ _0818_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and2b_1
X_8950_ net541 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__inv_2
XFILLER_68_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7901_ net494 _3413_ VGND VGND VPWR VPWR _3504_ sky130_fd_sc_hd__nand2_2
X_8881_ _3628_ _4331_ net204 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__o21a_1
XFILLER_36_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7832_ adder_inst.exp_larger_r\[7\] _3423_ VGND VGND VPWR VPWR _3438_ sky130_fd_sc_hd__xor2_1
XFILLER_24_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7763_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] adder_inst.exp_a\[2\]
+ VGND VGND VPWR VPWR _3376_ sky130_fd_sc_hd__and4_1
X_4975_ _0603_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nor2_1
XFILLER_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9502_ clknet_leaf_12_clk net645 _0412_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_6714_ net308 net468 net473 net300 VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__a22oi_1
XFILLER_51_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7694_ net114 _3286_ _3314_ VGND VGND VPWR VPWR _3320_ sky130_fd_sc_hd__a21oi_1
X_9433_ clknet_leaf_17_clk multiplier_inst.man_final\[21\] _0343_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[21\] sky130_fd_sc_hd__dfrtp_1
Xclkload7 clknet_leaf_7_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__inv_12
X_6645_ net312 net456 VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__nand2_1
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6576_ net313 net450 VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__nand2_1
X_9364_ clknet_leaf_19_clk _0037_ _0274_ VGND VGND VPWR VPWR add_res\[10\] sky130_fd_sc_hd__dfrtp_1
X_8315_ net122 _3883_ _3885_ _3887_ VGND VGND VPWR VPWR _3888_ sky130_fd_sc_hd__a31oi_2
X_9295_ clknet_leaf_22_clk net565 _0205_ VGND VGND VPWR VPWR adder_inst.man_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
X_5527_ _0977_ _1152_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__o21a_1
XFILLER_105_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8246_ _3677_ _3817_ _3818_ net121 VGND VGND VPWR VPWR _3819_ sky130_fd_sc_hd__a31o_1
XFILLER_105_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5458_ _1046_ _1047_ _1058_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__o21ai_1
Xfanout222 adder_inst.man_b_r\[21\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_2
X_8177_ net292 net428 net159 VGND VGND VPWR VPWR _3751_ sky130_fd_sc_hd__mux2_1
Xfanout200 _4336_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_2
X_5389_ _4544_ _0439_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__xor2_1
Xfanout211 net212 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_2
XFILLER_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout233 adder_inst.man_b_r\[19\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_2
Xfanout244 adder_inst.man_b_r\[17\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout255 net257 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_4
X_7128_ _2757_ _2756_ VGND VGND VPWR VPWR _2758_ sky130_fd_sc_hd__and2b_1
XFILLER_101_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout299 net303 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_2
Xfanout288 net290 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7059_ net356 net316 net322 net350 VGND VGND VPWR VPWR _2689_ sky130_fd_sc_hd__a22oi_2
Xfanout266 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
Xfanout277 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4760_ _4516_ _4530_ VGND VGND VPWR VPWR _4531_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4691_ _4460_ _4461_ VGND VGND VPWR VPWR _4462_ sky130_fd_sc_hd__xnor2_1
X_6430_ _2056_ _2059_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__xnor2_1
X_6361_ _1984_ _1989_ _1983_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__a21bo_1
X_8100_ _3342_ _3664_ _3672_ VGND VGND VPWR VPWR _3674_ sky130_fd_sc_hd__a21o_1
X_5312_ adder_inst.man_b_r\[18\] net425 net432 net231 VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9080_ net537 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__inv_2
XFILLER_114_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6292_ _1908_ _1909_ _1920_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__nand3_1
X_8031_ _3463_ _3614_ _3615_ net497 VGND VGND VPWR VPWR _3616_ sky130_fd_sc_hd__a22o_1
X_5243_ _0869_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__or2_1
Xhold19 adder_inst.i_b\[16\] VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlygate4sd3_1
X_5174_ _0562_ _0564_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__xnor2_1
XFILLER_29_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8933_ net514 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_108_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8864_ net638 mul_res\[16\] net505 VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__mux2_1
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7815_ net196 _3396_ _3406_ VGND VGND VPWR VPWR _3421_ sky130_fd_sc_hd__or3_1
XFILLER_52_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8795_ _4300_ _4301_ VGND VGND VPWR VPWR _4302_ sky130_fd_sc_hd__nor2_1
XFILLER_51_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7746_ adder_inst.i_a\[5\] adder_inst.i_a\[4\] adder_inst.i_a\[7\] adder_inst.i_a\[6\]
+ VGND VGND VPWR VPWR _3364_ sky130_fd_sc_hd__or4_1
X_4958_ net209 net440 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7677_ adder_inst.exp_a_r\[4\] adder_inst.exp_b_r\[4\] VGND VGND VPWR VPWR _3303_
+ sky130_fd_sc_hd__and2b_1
X_4889_ net242 net401 _0516_ _0517_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_50_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6628_ _2193_ _2247_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__xor2_1
X_9416_ clknet_leaf_21_clk multiplier_inst.man_final\[4\] _0326_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[4\] sky130_fd_sc_hd__dfrtp_1
X_9347_ clknet_leaf_12_clk net554 _0257_ VGND VGND VPWR VPWR adder_inst.i_vld_r sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6559_ _2184_ _2187_ _2188_ _2114_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__a211o_1
XFILLER_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9278_ clknet_leaf_17_clk adder_inst.sum_raw\[15\] _0188_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[15\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8229_ net175 _3680_ net155 _3699_ _3755_ VGND VGND VPWR VPWR _3802_ sky130_fd_sc_hd__a41oi_2
XTAP_TAPCELL_ROW_72_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5930_ _1558_ _1559_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__and2b_1
XFILLER_19_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5861_ _1489_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__nor2_1
X_7600_ _3036_ _3229_ VGND VGND VPWR VPWR _3230_ sky130_fd_sc_hd__or2_1
X_8580_ _4139_ _4140_ _3880_ VGND VGND VPWR VPWR _4147_ sky130_fd_sc_hd__a21o_1
XFILLER_61_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5792_ _1419_ _1420_ _1417_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_38_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4812_ _0440_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_103_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7531_ _2574_ _2799_ _2797_ VGND VGND VPWR VPWR _3161_ sky130_fd_sc_hd__a21o_1
X_4743_ _4512_ _4513_ VGND VGND VPWR VPWR _4514_ sky130_fd_sc_hd__xnor2_1
X_7462_ _3086_ _3091_ VGND VGND VPWR VPWR _3092_ sky130_fd_sc_hd__xnor2_1
X_9201_ clknet_leaf_22_clk net26 _0111_ VGND VGND VPWR VPWR adder_inst.i_a\[3\] sky130_fd_sc_hd__dfrtp_1
X_4674_ net358 net241 VGND VGND VPWR VPWR _4445_ sky130_fd_sc_hd__nand2_1
X_6413_ _2038_ _2041_ _2042_ _1966_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__a211oi_1
X_7393_ _2982_ _3002_ _2981_ VGND VGND VPWR VPWR _3023_ sky130_fd_sc_hd__a21o_1
X_9132_ net527 VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__inv_2
X_6344_ _1889_ _1891_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__nor2_1
X_9063_ net544 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__inv_2
X_6275_ _1898_ _1899_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_47_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8014_ adder_inst.sum_raw_r\[12\] _3432_ _3523_ adder_inst.sum_raw_r\[13\] _3600_
+ VGND VGND VPWR VPWR _3601_ sky130_fd_sc_hd__a221o_1
X_5226_ _0816_ _0850_ _0814_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21o_1
X_5157_ _0780_ _0781_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__nand3_1
XFILLER_29_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5088_ _0700_ _0702_ _0716_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__o21ai_1
X_8916_ net518 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__inv_2
XFILLER_71_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8847_ net685 mul_ovf net506 VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__mux2_1
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8778_ _2556_ _2560_ _2562_ _2563_ VGND VGND VPWR VPWR _4285_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_35_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7729_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _3351_ sky130_fd_sc_hd__or4_1
XFILLER_40_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_74_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6060_ net240 net478 _1688_ _1689_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__and4_1
X_5011_ _0636_ _0637_ _0638_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21oi_1
XFILLER_26_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_105_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6962_ _2586_ _2589_ VGND VGND VPWR VPWR _2592_ sky130_fd_sc_hd__xnor2_1
X_6893_ _2520_ _2522_ VGND VGND VPWR VPWR _2523_ sky130_fd_sc_hd__or2_1
X_8701_ _4065_ net107 _4245_ _4064_ _4252_ VGND VGND VPWR VPWR _4253_ sky130_fd_sc_hd__a221o_1
X_5913_ _1530_ _1531_ _1542_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__nand3_1
X_8632_ net181 _4190_ _4191_ _4192_ VGND VGND VPWR VPWR _4193_ sky130_fd_sc_hd__a2bb2o_1
X_5844_ _1223_ _1231_ _1230_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__a21bo_1
XFILLER_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8563_ _3831_ _4132_ VGND VGND VPWR VPWR adder_inst.sum_raw\[3\] sky130_fd_sc_hd__xor2_1
XFILLER_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5775_ _1389_ _1403_ _1404_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__nand3_2
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7514_ _3106_ _3109_ _3143_ VGND VGND VPWR VPWR _3144_ sky130_fd_sc_hd__o21ai_2
X_8494_ _4064_ _4066_ VGND VGND VPWR VPWR _4067_ sky130_fd_sc_hd__nand2_1
X_4726_ _4495_ _4496_ VGND VGND VPWR VPWR _4497_ sky130_fd_sc_hd__nor2_1
X_7445_ _4538_ _4540_ _3072_ VGND VGND VPWR VPWR _3075_ sky130_fd_sc_hd__and3_1
X_4657_ _4426_ _4427_ VGND VGND VPWR VPWR _4428_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_116_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7376_ _2999_ _3000_ VGND VGND VPWR VPWR _3006_ sky130_fd_sc_hd__xnor2_1
X_9115_ net531 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__inv_2
XFILLER_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4588_ net352 net211 VGND VGND VPWR VPWR _4359_ sky130_fd_sc_hd__nand2_1
X_6327_ _1937_ _1939_ _1956_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__a21oi_2
XFILLER_89_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9046_ net525 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_4_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6258_ _1711_ _1805_ _1803_ _1800_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__a211o_1
XFILLER_103_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5209_ _0837_ _0838_ net226 net434 VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__and4bb_1
X_6189_ _1722_ _1817_ _1816_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a21o_1
XFILLER_84_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5560_ _1186_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__xnor2_1
XFILLER_31_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5491_ _0719_ _0721_ _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__o21bai_2
Xhold105 add_res\[27\] VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 add_res\[1\] VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7230_ _2856_ _2857_ net207 net455 VGND VGND VPWR VPWR _2860_ sky130_fd_sc_hd__and4b_1
Xhold149 adder_inst.is_nan_b_r VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold138 add_res\[12\] VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 mul_res\[8\] VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7161_ _2787_ _2788_ VGND VGND VPWR VPWR _2791_ sky130_fd_sc_hd__xnor2_1
X_7092_ net263 net415 VGND VGND VPWR VPWR _2722_ sky130_fd_sc_hd__nand2_1
X_6112_ _1727_ _1729_ _1728_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__o21ba_1
XFILLER_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6043_ _1665_ _1669_ _1671_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__o211ai_4
XFILLER_54_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7994_ adder_inst.sum_raw_r\[15\] net196 net176 adder_inst.sum_raw_r\[14\] net190
+ VGND VGND VPWR VPWR _3584_ sky130_fd_sc_hd__o221a_1
X_6945_ _1573_ _1606_ _1605_ VGND VGND VPWR VPWR _2575_ sky130_fd_sc_hd__o21bai_2
X_6876_ _2504_ _2505_ VGND VGND VPWR VPWR _2506_ sky130_fd_sc_hd__nand2b_1
XFILLER_22_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8615_ _4102_ _4177_ net105 VGND VGND VPWR VPWR _4178_ sky130_fd_sc_hd__mux2_1
X_5827_ _1454_ _1455_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__nand3_1
XFILLER_22_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8546_ _3782_ _3783_ net107 VGND VGND VPWR VPWR _4118_ sky130_fd_sc_hd__mux2_1
X_5758_ _1385_ _1386_ _1337_ _1350_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__a211oi_1
XFILLER_108_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8477_ _4046_ _4047_ VGND VGND VPWR VPWR _4050_ sky130_fd_sc_hd__xnor2_2
X_4709_ net359 net241 _4447_ _4446_ VGND VGND VPWR VPWR _4480_ sky130_fd_sc_hd__a31o_1
X_7428_ _3051_ _3056_ VGND VGND VPWR VPWR _3058_ sky130_fd_sc_hd__xnor2_1
X_5689_ _1316_ _1317_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nand3_2
XFILLER_116_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7359_ _2761_ _2763_ _2760_ VGND VGND VPWR VPWR _2989_ sky130_fd_sc_hd__o21ba_1
X_9029_ net515 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__inv_2
XFILLER_103_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6730_ _2352_ _2358_ _2359_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__nand3_2
X_4991_ _0614_ _0615_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nand3_1
XFILLER_23_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6661_ _2284_ _2289_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__xnor2_1
X_9380_ clknet_leaf_11_clk _0054_ _0290_ VGND VGND VPWR VPWR add_res\[26\] sky130_fd_sc_hd__dfrtp_1
X_6592_ _2219_ _2220_ _2218_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__o21ba_1
X_8400_ net413 _3969_ net163 VGND VGND VPWR VPWR _3973_ sky130_fd_sc_hd__mux2_1
X_5612_ _1238_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__xnor2_1
X_8331_ net150 net143 _3784_ VGND VGND VPWR VPWR _3904_ sky130_fd_sc_hd__or3b_1
X_5543_ _1162_ _1167_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__xnor2_1
X_8262_ net145 _3717_ net128 VGND VGND VPWR VPWR _3835_ sky130_fd_sc_hd__o21ai_1
X_5474_ _1101_ _1102_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_113_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8193_ _3763_ _3766_ net146 VGND VGND VPWR VPWR _3767_ sky130_fd_sc_hd__mux2_1
X_7213_ _2840_ _2841_ _2842_ VGND VGND VPWR VPWR _2843_ sky130_fd_sc_hd__nand3_1
X_7144_ _2683_ _2773_ VGND VGND VPWR VPWR _2774_ sky130_fd_sc_hd__nand2b_1
Xfanout404 net405 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__buf_2
Xfanout426 net428 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__clkbuf_4
Xfanout415 net418 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__buf_2
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__buf_2
Xfanout437 net438 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__buf_2
XFILLER_113_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout459 net460 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__buf_2
X_7075_ _2702_ _2703_ _2701_ VGND VGND VPWR VPWR _2705_ sky130_fd_sc_hd__a21bo_1
XFILLER_67_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6026_ _1641_ _1654_ _1655_ _1319_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__o211a_1
XFILLER_54_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7977_ adder_inst.sum_raw_r\[9\] _4341_ net188 adder_inst.sum_raw_r\[7\] net198 VGND
+ VGND VPWR VPWR _3569_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_64_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6928_ _2555_ _2557_ VGND VGND VPWR VPWR _2558_ sky130_fd_sc_hd__xor2_2
XFILLER_42_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6859_ _2467_ _2471_ _2470_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__o21ai_1
XFILLER_80_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8529_ _3948_ _4100_ _4101_ VGND VGND VPWR VPWR _4102_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload14 clknet_leaf_13_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__inv_16
XFILLER_70_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5190_ net394 net271 net398 net265 VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__a22o_1
XFILLER_83_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7900_ net115 _3502_ _3503_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and3_1
XFILLER_49_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8880_ adder_inst.is_zero_r _3497_ VGND VGND VPWR VPWR _4331_ sky130_fd_sc_hd__nor2_1
X_7831_ _3436_ adder_inst.exp_larger_r\[7\] _3392_ VGND VGND VPWR VPWR _3437_ sky130_fd_sc_hd__mux2_1
XFILLER_64_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7762_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _3375_ sky130_fd_sc_hd__and4_1
X_4974_ net355 net296 net302 net349 VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a22oi_1
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9501_ clknet_leaf_12_clk net710 _0411_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
X_7693_ net103 _3290_ _3314_ VGND VGND VPWR VPWR _3319_ sky130_fd_sc_hd__and3_1
X_6713_ net295 net481 VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__nand2_1
X_6644_ _2272_ _2273_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__nor2_1
X_9432_ clknet_leaf_19_clk multiplier_inst.man_final\[20\] _0342_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[20\] sky130_fd_sc_hd__dfrtp_1
Xclkload8 clknet_leaf_8_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_16
X_6575_ _2203_ _2204_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__and2b_1
X_9363_ clknet_leaf_19_clk _0067_ _0273_ VGND VGND VPWR VPWR add_res\[9\] sky130_fd_sc_hd__dfrtp_1
X_8314_ net130 _3732_ _3767_ VGND VGND VPWR VPWR _3887_ sky130_fd_sc_hd__and3_1
X_5526_ _1145_ _1149_ _1144_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__a21oi_1
X_9294_ clknet_leaf_22_clk net570 _0204_ VGND VGND VPWR VPWR adder_inst.man_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_8245_ _3809_ _3810_ net129 VGND VGND VPWR VPWR _3818_ sky130_fd_sc_hd__a21o_1
X_5457_ _1061_ _1062_ _1064_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a21oi_1
Xfanout201 adder_inst.exp_larger_r\[4\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_2
X_8176_ _3749_ VGND VGND VPWR VPWR _3750_ sky130_fd_sc_hd__inv_2
X_5388_ _4399_ _1014_ _1015_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__nor4_2
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_2
Xfanout223 net225 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_2
XFILLER_86_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_4
X_7127_ _2657_ _2659_ _2658_ VGND VGND VPWR VPWR _2757_ sky130_fd_sc_hd__o21ba_1
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_2
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_2
Xfanout267 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_70_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7058_ net350 net356 net315 net322 VGND VGND VPWR VPWR _2688_ sky130_fd_sc_hd__and4_1
Xfanout278 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_2
Xfanout289 net290 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6009_ _1295_ _1296_ _1298_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__a21o_1
XFILLER_82_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_643 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4690_ _4423_ _4426_ VGND VGND VPWR VPWR _4461_ sky130_fd_sc_hd__nor2_1
X_6360_ _1983_ _1984_ _1989_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__nand3_1
X_5311_ net231 net235 net427 net432 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__and4_1
X_8030_ net503 net197 net491 VGND VGND VPWR VPWR _3615_ sky130_fd_sc_hd__a21o_1
XFILLER_88_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6291_ _1908_ _1909_ _1920_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__and3_1
X_5242_ _0858_ _0861_ _0868_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nor3_1
X_5173_ _0498_ _0796_ _0801_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__a21o_1
Xinput1 i_a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_8932_ net512 VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__inv_2
XFILLER_37_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8863_ net631 mul_res\[15\] net504 VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__mux2_1
XFILLER_37_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7814_ _3395_ _3406_ VGND VGND VPWR VPWR _3420_ sky130_fd_sc_hd__or2_1
XFILLER_101_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8794_ _2257_ _4281_ VGND VGND VPWR VPWR _4301_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7745_ adder_inst.man_b\[23\] _3363_ VGND VGND VPWR VPWR adder_inst.is_zero_b sky130_fd_sc_hd__and2b_1
X_4957_ _0585_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_22_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7676_ _3300_ _3301_ VGND VGND VPWR VPWR _3302_ sky130_fd_sc_hd__nor2_1
X_4888_ net242 net400 _0516_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_50_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9415_ clknet_leaf_21_clk multiplier_inst.man_final\[3\] _0325_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[3\] sky130_fd_sc_hd__dfrtp_1
X_6627_ _2191_ _2192_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__or2_1
X_9346_ clknet_leaf_10_clk _0034_ _0256_ VGND VGND VPWR VPWR adder_inst.is_nan_r sky130_fd_sc_hd__dfrtp_2
X_6558_ _2112_ _2113_ _2107_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__a21oi_1
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9277_ clknet_leaf_17_clk adder_inst.sum_raw\[14\] _0187_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[14\]
+ sky130_fd_sc_hd__dfrtp_4
X_5509_ _0750_ _0752_ _1128_ _1138_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__o211ai_2
X_6489_ _2043_ _2118_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__nor2_2
X_8228_ net138 _3751_ _3800_ VGND VGND VPWR VPWR _3801_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_72_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8159_ net257 net396 net159 VGND VGND VPWR VPWR _3733_ sky130_fd_sc_hd__mux2_1
XFILLER_87_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5860_ net234 net454 net464 net228 VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__a22oi_1
XFILLER_46_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4811_ _4443_ _4471_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__xor2_1
XFILLER_61_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5791_ _1417_ _1419_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_103_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4742_ net207 net389 _4500_ _4498_ VGND VGND VPWR VPWR _4513_ sky130_fd_sc_hd__a31o_1
X_7530_ _2574_ _2799_ VGND VGND VPWR VPWR _3160_ sky130_fd_sc_hd__xnor2_2
X_7461_ _3089_ _3090_ VGND VGND VPWR VPWR _3091_ sky130_fd_sc_hd__nor2_1
X_4673_ _4400_ _4403_ _4402_ VGND VGND VPWR VPWR _4444_ sky130_fd_sc_hd__o21ba_1
X_9200_ clknet_leaf_22_clk net23 _0110_ VGND VGND VPWR VPWR adder_inst.i_a\[2\] sky130_fd_sc_hd__dfrtp_1
X_6412_ _1964_ _1965_ _1957_ _1960_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__a211oi_2
X_7392_ _2794_ _2797_ _2793_ VGND VGND VPWR VPWR _3022_ sky130_fd_sc_hd__a21o_1
X_6343_ _1890_ _1972_ _1891_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__a21oi_1
X_9131_ net527 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__inv_2
X_9062_ net547 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__inv_2
XFILLER_88_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6274_ _1900_ _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8013_ adder_inst.sum_raw_r\[15\] net497 _3404_ adder_inst.sum_raw_r\[14\] _3473_
+ VGND VGND VPWR VPWR _3600_ sky130_fd_sc_hd__a221o_1
X_5225_ _0812_ _0854_ _0764_ _0776_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o211a_4
XFILLER_69_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5156_ _0782_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nand2b_1
X_5087_ _0700_ _0702_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__or3_2
X_8915_ net537 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_55_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8846_ _3159_ _3268_ VGND VGND VPWR VPWR multiplier_inst.man_final\[22\] sky130_fd_sc_hd__or2_1
XFILLER_24_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8777_ _2556_ _2560_ _2562_ _2563_ VGND VGND VPWR VPWR _4284_ sky130_fd_sc_hd__nor4_1
XFILLER_52_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5989_ _1611_ _1612_ _1617_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_35_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7728_ _3348_ _3350_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[7\] sky130_fd_sc_hd__or2_1
XFILLER_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7659_ _4357_ net114 _3285_ _3284_ VGND VGND VPWR VPWR _3287_ sky130_fd_sc_hd__a31o_1
XFILLER_108_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9329_ clknet_leaf_0_clk net590 _0239_ VGND VGND VPWR VPWR adder_inst.man_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_7_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5010_ _0636_ _0637_ _0638_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand3_1
XFILLER_78_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8700_ _4064_ _4109_ net107 _4065_ VGND VGND VPWR VPWR _4252_ sky130_fd_sc_hd__a211oi_1
XFILLER_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6961_ _2586_ _2589_ VGND VGND VPWR VPWR _2591_ sky130_fd_sc_hd__or2_1
X_6892_ net342 net469 net474 net336 VGND VGND VPWR VPWR _2522_ sky130_fd_sc_hd__a22oi_1
XFILLER_81_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5912_ _1532_ _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__xor2_1
X_8631_ _4103_ net105 net181 VGND VGND VPWR VPWR _4192_ sky130_fd_sc_hd__o21a_1
X_5843_ _1470_ _1471_ _1387_ _1409_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__a211oi_1
XFILLER_22_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8562_ _3355_ _4126_ _4127_ _4131_ VGND VGND VPWR VPWR _4132_ sky130_fd_sc_hd__a31o_1
XFILLER_61_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5774_ _1396_ _1397_ _1402_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__a21o_1
X_7513_ _3136_ _3138_ VGND VGND VPWR VPWR _3143_ sky130_fd_sc_hd__xnor2_1
X_8493_ _4065_ VGND VGND VPWR VPWR _4066_ sky130_fd_sc_hd__inv_2
X_4725_ _4455_ _4458_ _4494_ VGND VGND VPWR VPWR _4496_ sky130_fd_sc_hd__o21a_1
X_4656_ net223 net386 _4425_ VGND VGND VPWR VPWR _4427_ sky130_fd_sc_hd__a21oi_1
X_7444_ _3073_ VGND VGND VPWR VPWR _3074_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4587_ _4355_ _4356_ VGND VGND VPWR VPWR _4358_ sky130_fd_sc_hd__nand2_4
XPHY_EDGE_ROW_2_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7375_ _2888_ _2952_ _2983_ _3004_ VGND VGND VPWR VPWR _3005_ sky130_fd_sc_hd__nand4_1
X_9114_ net531 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__inv_2
X_6326_ _1791_ _1955_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__xor2_1
XFILLER_88_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9045_ net528 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__inv_2
X_6257_ _1883_ _1885_ _1886_ _1804_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_4_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5208_ net237 net421 net427 net231 VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a22oi_1
X_6188_ _1722_ _1816_ _1817_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__nand3_1
X_5139_ _0765_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__or3_1
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8829_ _3242_ net102 _4322_ _3241_ net104 VGND VGND VPWR VPWR multiplier_inst.man_final\[13\]
+ sky130_fd_sc_hd__a221oi_1
XFILLER_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5490_ _0710_ _0715_ _0709_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a21oi_1
Xhold106 _0019_ VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__dlygate4sd3_1
Xhold117 _0011_ VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 _0003_ VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
Xhold128 _0030_ VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlygate4sd3_1
X_7160_ _1497_ _1616_ _1614_ VGND VGND VPWR VPWR _2790_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6111_ _1737_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__and2b_1
X_7091_ _2717_ _2718_ _2719_ VGND VGND VPWR VPWR _2721_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_111_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6042_ _1650_ _1652_ _1670_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__nand3_1
XFILLER_66_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7993_ adder_inst.sum_raw_r\[12\] net499 _3581_ _3582_ _3473_ VGND VGND VPWR VPWR
+ _3583_ sky130_fd_sc_hd__a221o_1
XFILLER_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6944_ _2568_ _2573_ _2256_ VGND VGND VPWR VPWR _2574_ sky130_fd_sc_hd__a21bo_2
XFILLER_34_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6875_ _2491_ _2497_ _2503_ VGND VGND VPWR VPWR _2505_ sky130_fd_sc_hd__nand3_1
X_8614_ _3948_ _4163_ _4176_ VGND VGND VPWR VPWR _4177_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5826_ _1391_ _1393_ _1392_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__a21bo_1
XFILLER_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8545_ net182 _4116_ VGND VGND VPWR VPWR _4117_ sky130_fd_sc_hd__or2_1
X_5757_ _1337_ _1350_ _1385_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__o211a_1
XFILLER_22_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8476_ _4047_ _4046_ VGND VGND VPWR VPWR _4049_ sky130_fd_sc_hd__and2b_1
X_4708_ _4454_ _4470_ _4453_ VGND VGND VPWR VPWR _4479_ sky130_fd_sc_hd__o21ba_1
X_7427_ _3051_ _3056_ VGND VGND VPWR VPWR _3057_ sky130_fd_sc_hd__nand2b_1
X_5688_ _1172_ _1173_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__xnor2_1
X_4639_ net354 net267 net274 net347 VGND VGND VPWR VPWR _4410_ sky130_fd_sc_hd__a22o_1
XFILLER_89_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7358_ _2985_ _2986_ VGND VGND VPWR VPWR _2988_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7289_ _2917_ _2918_ VGND VGND VPWR VPWR _2919_ sky130_fd_sc_hd__and2_1
X_6309_ _1931_ _1934_ _1937_ _1938_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__o211ai_4
X_9028_ net515 VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__inv_2
XFILLER_77_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4990_ _0616_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__xnor2_1
X_6660_ _2289_ _2284_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__nand2b_1
X_6591_ _2218_ _2220_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__nor2_1
X_5611_ _1239_ _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__nor2_1
X_8330_ _3898_ _3899_ net123 VGND VGND VPWR VPWR _3903_ sky130_fd_sc_hd__o21a_1
X_5542_ _1169_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__nor2_1
X_8261_ net142 _3721_ VGND VGND VPWR VPWR _3834_ sky130_fd_sc_hd__nor2_1
X_5473_ _1102_ _1101_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_113_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8192_ _3764_ _3765_ net140 VGND VGND VPWR VPWR _3766_ sky130_fd_sc_hd__mux2_1
X_7212_ _0932_ _2839_ _2838_ VGND VGND VPWR VPWR _2842_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_92_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7143_ _2737_ _2772_ VGND VGND VPWR VPWR _2773_ sky130_fd_sc_hd__xor2_1
Xfanout405 net406 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__buf_2
Xfanout416 net417 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_4
Xfanout427 net428 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__buf_2
XFILLER_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7074_ _2701_ _2702_ _2703_ VGND VGND VPWR VPWR _2704_ sky130_fd_sc_hd__nand3b_1
Xfanout438 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__clkbuf_4
XFILLER_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout449 net452 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__buf_2
XFILLER_104_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6025_ _1316_ _1317_ _1318_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__a21o_1
XFILLER_104_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7976_ adder_inst.sum_raw_r\[8\] net177 VGND VGND VPWR VPWR _3568_ sky130_fd_sc_hd__or2_1
X_6927_ _2411_ _2550_ VGND VGND VPWR VPWR _2557_ sky130_fd_sc_hd__nand2_1
X_6858_ _2487_ VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__inv_2
X_5809_ _1436_ _1437_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_40_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6789_ net450 net336 net457 net341 VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__and4_1
X_8528_ _3933_ _3946_ _3945_ VGND VGND VPWR VPWR _4101_ sky130_fd_sc_hd__a21oi_1
XFILLER_13_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8459_ _4027_ _4029_ VGND VGND VPWR VPWR _4032_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload15 clknet_leaf_14_clk VGND VGND VPWR VPWR clkload15/Y sky130_fd_sc_hd__clkinv_16
XFILLER_70_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7830_ adder_inst.exp_larger_r\[7\] net191 VGND VGND VPWR VPWR _3436_ sky130_fd_sc_hd__nor2_1
XFILLER_63_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7761_ _3363_ _3373_ _3374_ VGND VGND VPWR VPWR adder_inst.is_inf_b sky130_fd_sc_hd__and3_1
X_4973_ net349 net296 _0459_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__and3_1
XFILLER_63_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9500_ clknet_leaf_12_clk net649 _0410_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
X_7692_ net114 _3317_ _3316_ VGND VGND VPWR VPWR _3318_ sky130_fd_sc_hd__a21oi_1
X_6712_ net300 net308 net468 net473 VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__and4_1
X_6643_ net445 net325 net450 net318 VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__a22oi_1
X_9431_ clknet_leaf_17_clk multiplier_inst.man_final\[19\] _0341_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[19\] sky130_fd_sc_hd__dfrtp_1
Xclkload9 clknet_leaf_22_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__inv_6
X_6574_ net318 net444 net325 net439 VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__a22o_1
X_9362_ clknet_leaf_19_clk _0066_ _0272_ VGND VGND VPWR VPWR add_res\[8\] sky130_fd_sc_hd__dfrtp_1
X_8313_ net130 _3767_ VGND VGND VPWR VPWR _3886_ sky130_fd_sc_hd__and2_1
X_9293_ clknet_leaf_22_clk net564 _0203_ VGND VGND VPWR VPWR adder_inst.man_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_5525_ _1034_ _1081_ _1033_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__o21ba_1
X_8244_ _3814_ _3815_ net148 VGND VGND VPWR VPWR _3817_ sky130_fd_sc_hd__a21o_1
X_5456_ _1067_ _1075_ _1074_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__o21a_1
Xfanout202 adder_inst.exp_larger_r\[2\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__buf_2
X_8175_ net286 net421 net159 VGND VGND VPWR VPWR _3749_ sky130_fd_sc_hd__mux2_1
X_5387_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__inv_2
Xfanout213 net214 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7126_ _2752_ _2755_ VGND VGND VPWR VPWR _2756_ sky130_fd_sc_hd__xnor2_1
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_4
Xfanout246 net251 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_2
Xfanout235 net236 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout279 net280 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_4
Xfanout268 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__buf_2
Xfanout257 adder_inst.man_b_r\[15\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_2
X_7057_ net362 net310 VGND VGND VPWR VPWR _2687_ sky130_fd_sc_hd__nand2_1
XFILLER_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6008_ _1631_ _1636_ _1630_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a21bo_1
XFILLER_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7959_ adder_inst.sum_raw_r\[11\] net178 net189 _3552_ _3553_ VGND VGND VPWR VPWR
+ _3554_ sky130_fd_sc_hd__a221o_1
XFILLER_70_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6290_ _1914_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__xor2_1
X_5310_ _0839_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nor2_1
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5241_ _0866_ _0869_ _0774_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__o21ai_1
XFILLER_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5172_ _0498_ _0796_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand3_1
XFILLER_96_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput2 i_a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_96_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8931_ net509 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__inv_2
XFILLER_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_108_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8862_ net681 mul_res\[14\] net505 VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__mux2_1
XFILLER_37_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7813_ net489 _3412_ _3418_ VGND VGND VPWR VPWR _3419_ sky130_fd_sc_hd__or3_1
X_8793_ _2566_ _4299_ _4298_ _4283_ _4282_ VGND VGND VPWR VPWR _4300_ sky130_fd_sc_hd__a2111o_1
XFILLER_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7744_ _3359_ _3362_ VGND VGND VPWR VPWR _3363_ sky130_fd_sc_hd__nor2_1
XFILLER_51_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4956_ net221 net427 net435 net215 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_22_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7675_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] _3299_ VGND VGND VPWR VPWR
+ _3301_ sky130_fd_sc_hd__a21oi_1
X_4887_ net255 net391 net395 net250 VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_50_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6626_ _1811_ _2253_ _2255_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__o21a_1
X_9414_ clknet_leaf_21_clk multiplier_inst.man_final\[2\] _0324_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[2\] sky130_fd_sc_hd__dfrtp_1
X_9345_ clknet_leaf_8_clk adder_inst.man_b\[23\] _0255_ VGND VGND VPWR VPWR adder_inst.man_b_r\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_6557_ _2180_ _2184_ _2185_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__nand3_1
X_5508_ _1119_ _1127_ _1126_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a21o_1
XFILLER_105_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9276_ clknet_leaf_17_clk adder_inst.sum_raw\[13\] _0186_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[13\]
+ sky130_fd_sc_hd__dfrtp_4
X_6488_ _1966_ _2042_ _2041_ _2038_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__o211a_1
X_8227_ _4358_ net156 net154 net153 _3749_ VGND VGND VPWR VPWR _3800_ sky130_fd_sc_hd__o41a_1
XTAP_TAPCELL_ROW_72_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5439_ _0426_ _0998_ _1003_ _1010_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__o31a_1
XFILLER_99_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8158_ _3671_ _3700_ VGND VGND VPWR VPWR _3732_ sky130_fd_sc_hd__or2_2
XFILLER_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7109_ _2646_ _2648_ VGND VGND VPWR VPWR _2739_ sky130_fd_sc_hd__nand2_1
X_8089_ _3327_ _3661_ _3662_ _3343_ _3326_ VGND VGND VPWR VPWR _3663_ sky130_fd_sc_hd__a311oi_4
XFILLER_59_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4810_ _4544_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or2_1
XFILLER_33_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5790_ net356 net334 net339 net350 VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__a22oi_2
XFILLER_34_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_103_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4741_ _4507_ _4510_ VGND VGND VPWR VPWR _4512_ sky130_fd_sc_hd__xnor2_1
X_7460_ _3045_ _3048_ _3088_ VGND VGND VPWR VPWR _3090_ sky130_fd_sc_hd__nor3_1
X_4672_ _4441_ _4442_ _4422_ VGND VGND VPWR VPWR _4443_ sky130_fd_sc_hd__o21ai_1
X_6411_ _2032_ _2038_ _2039_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__nand3_1
X_9130_ net543 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__inv_2
X_7391_ _3020_ VGND VGND VPWR VPWR _3021_ sky130_fd_sc_hd__inv_2
X_6342_ _1969_ _1971_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__and2b_1
XFILLER_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9061_ net542 VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__inv_2
X_6273_ _1901_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__nor2_1
X_8012_ net116 _3599_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and2_1
X_5224_ _0812_ _0851_ _0852_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__nor4_1
XFILLER_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5155_ _0782_ _0783_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__or3_1
X_5086_ _0710_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__xnor2_1
XFILLER_29_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8914_ net520 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__inv_2
XFILLER_84_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8845_ _3268_ _4330_ VGND VGND VPWR VPWR multiplier_inst.man_final\[21\] sky130_fd_sc_hd__nor2_1
XFILLER_24_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8776_ _2313_ _2567_ VGND VGND VPWR VPWR _4283_ sky130_fd_sc_hd__xor2_1
XFILLER_12_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5988_ _1611_ _1612_ _1617_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_35_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7727_ net103 _3339_ _3349_ VGND VGND VPWR VPWR _3350_ sky130_fd_sc_hd__a21oi_1
XFILLER_40_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4939_ net242 net416 VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand2_1
X_7658_ net175 _3284_ _3285_ VGND VGND VPWR VPWR _3286_ sky130_fd_sc_hd__and3_1
X_6609_ _2152_ _2228_ _2227_ _2212_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__o211ai_1
XFILLER_20_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7589_ _4370_ net136 _3151_ _3206_ VGND VGND VPWR VPWR _3219_ sky130_fd_sc_hd__a31o_1
X_9328_ clknet_leaf_0_clk net592 _0238_ VGND VGND VPWR VPWR adder_inst.man_b_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_9259_ clknet_leaf_5_clk net54 _0169_ VGND VGND VPWR VPWR adder_inst.exp_b\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6960_ _2586_ _2589_ VGND VGND VPWR VPWR _2590_ sky130_fd_sc_hd__and2_1
XFILLER_38_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_105_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5911_ _1539_ _1540_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__and2b_1
XFILLER_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6891_ net330 net481 VGND VGND VPWR VPWR _2521_ sky130_fd_sc_hd__nand2_1
XFILLER_46_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8630_ net106 _4186_ VGND VGND VPWR VPWR _4191_ sky130_fd_sc_hd__nand2_1
X_5842_ _1387_ _1409_ _1470_ _1471_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__o211a_1
X_8561_ net107 _4128_ _4130_ _3853_ net182 VGND VGND VPWR VPWR _4131_ sky130_fd_sc_hd__o221a_1
X_5773_ _1396_ _1397_ _1402_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__nand3_1
XFILLER_22_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4724_ _4455_ _4458_ _4494_ VGND VGND VPWR VPWR _4495_ sky130_fd_sc_hd__nor3_1
X_7512_ _3132_ _3135_ _3139_ VGND VGND VPWR VPWR _3142_ sky130_fd_sc_hd__nor3_1
X_8492_ _4061_ _4063_ VGND VGND VPWR VPWR _4065_ sky130_fd_sc_hd__and2_1
XFILLER_30_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7443_ _4538_ _4540_ _3072_ VGND VGND VPWR VPWR _3073_ sky130_fd_sc_hd__a21o_1
X_4655_ net223 net384 _4425_ VGND VGND VPWR VPWR _4426_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_116_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4586_ _4355_ _4356_ VGND VGND VPWR VPWR _4357_ sky130_fd_sc_hd__and2_1
Xinput60 i_b[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
X_7374_ _3003_ VGND VGND VPWR VPWR _3004_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_116_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9113_ net531 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__inv_2
X_6325_ _1789_ _1872_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__nor2_1
XFILLER_107_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9044_ net528 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__inv_2
XFILLER_103_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6256_ _1800_ _1802_ _1801_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__o21ai_1
XFILLER_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5207_ net231 net237 net421 net427 VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__and4_1
X_6187_ _1719_ _1721_ _1720_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__o21ai_1
X_5138_ _0749_ _0754_ _0761_ _0764_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__o211a_1
X_5069_ _0627_ _0635_ _0634_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__a21bo_1
XFILLER_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8828_ _3270_ _4321_ _4322_ VGND VGND VPWR VPWR multiplier_inst.man_final\[12\] sky130_fd_sc_hd__and3_1
XFILLER_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8759_ net628 _4272_ _0104_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__a21o_1
XFILLER_40_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_112_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold107 add_res\[20\] VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dlygate4sd3_1
Xhold118 multiplier_inst.man_final_r\[9\] VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 multiplier_inst.man_final_r\[0\] VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlygate4sd3_1
X_6110_ _1737_ _1738_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__or3_1
X_7090_ _2717_ _2718_ _2719_ VGND VGND VPWR VPWR _2720_ sky130_fd_sc_hd__nand3_1
XFILLER_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6041_ _1650_ _1652_ _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__a21o_1
XFILLER_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7992_ adder_inst.sum_raw_r\[9\] net188 net177 adder_inst.sum_raw_r\[10\] VGND VGND
+ VPWR VPWR _3582_ sky130_fd_sc_hd__o22a_1
XFILLER_66_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6943_ _1811_ _2572_ VGND VGND VPWR VPWR _2573_ sky130_fd_sc_hd__nor2_8
X_6874_ _2497_ _2503_ _2491_ VGND VGND VPWR VPWR _2504_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_66_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8613_ _3935_ _3946_ _3945_ VGND VGND VPWR VPWR _4176_ sky130_fd_sc_hd__a21o_1
X_5825_ _1452_ _1453_ _1451_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__o21ai_1
XFILLER_34_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8544_ _3777_ _3778_ _3780_ VGND VGND VPWR VPWR _4116_ sky130_fd_sc_hd__or3_1
X_5756_ _1372_ _1373_ _1384_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__a21o_1
X_8475_ _4046_ _4047_ VGND VGND VPWR VPWR _4048_ sky130_fd_sc_hd__nand2b_1
X_5687_ _1314_ _1315_ _1300_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__a21o_1
X_4707_ _4475_ _4476_ VGND VGND VPWR VPWR _4478_ sky130_fd_sc_hd__xor2_1
X_4638_ net360 net262 VGND VGND VPWR VPWR _4409_ sky130_fd_sc_hd__nand2_1
X_7426_ _3054_ _3055_ VGND VGND VPWR VPWR _3056_ sky130_fd_sc_hd__xnor2_1
X_4569_ net500 VGND VGND VPWR VPWR _4341_ sky130_fd_sc_hd__inv_2
XFILLER_89_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7357_ _2985_ _2986_ VGND VGND VPWR VPWR _2987_ sky130_fd_sc_hd__and2b_1
X_7288_ net224 net448 _2754_ _2753_ VGND VGND VPWR VPWR _2918_ sky130_fd_sc_hd__a31o_1
XFILLER_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6308_ _1855_ _1936_ _1935_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__a21o_1
X_9027_ net514 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__inv_2
X_6239_ _1866_ _1868_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__and2b_1
XFILLER_85_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6590_ net308 net456 net461 net300 VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__a22oi_1
X_5610_ net236 net459 net465 net230 VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_42_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5541_ _1169_ _1170_ net419 net293 VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__and4bb_1
X_8260_ net142 _3714_ _3832_ VGND VGND VPWR VPWR _3833_ sky130_fd_sc_hd__o21bai_1
X_5472_ _1053_ _1055_ _1052_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__o21ba_1
X_7211_ _2741_ _2743_ VGND VGND VPWR VPWR _2841_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_113_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8191_ net227 net366 net159 VGND VGND VPWR VPWR _3765_ sky130_fd_sc_hd__mux2_1
XFILLER_113_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7142_ _2738_ _2771_ VGND VGND VPWR VPWR _2772_ sky130_fd_sc_hd__xor2_1
XFILLER_98_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout417 net418 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_4
Xfanout428 net429 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__buf_2
Xfanout439 net440 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__clkbuf_4
X_7073_ net375 net298 net307 net369 VGND VGND VPWR VPWR _2703_ sky130_fd_sc_hd__a22o_1
Xfanout406 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__buf_2
XFILLER_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6024_ _1640_ _1642_ _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__and3_1
X_7975_ net115 _3567_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__and2_1
XFILLER_54_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6926_ _2550_ _2555_ VGND VGND VPWR VPWR _2556_ sky130_fd_sc_hd__nor2_1
XFILLER_81_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6857_ _2477_ _2486_ VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__nor2_2
X_6788_ _2376_ _2378_ _2377_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__o21ai_1
XFILLER_10_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5808_ net395 net298 net304 net387 VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__a22o_1
X_8527_ _3910_ _3924_ _3927_ _4099_ _3909_ VGND VGND VPWR VPWR _4100_ sky130_fd_sc_hd__o221a_1
XFILLER_6_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5739_ _1365_ _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__xnor2_1
XFILLER_89_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8458_ _4030_ VGND VGND VPWR VPWR _4031_ sky130_fd_sc_hd__inv_2
XFILLER_89_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8389_ net164 _3960_ _3961_ VGND VGND VPWR VPWR _3962_ sky130_fd_sc_hd__o21ai_1
X_7409_ _3038_ _4534_ VGND VGND VPWR VPWR _3039_ sky130_fd_sc_hd__and2b_1
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload16 clknet_leaf_15_clk VGND VGND VPWR VPWR clkload16/Y sky130_fd_sc_hd__inv_12
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7760_ adder_inst.exp_b\[5\] adder_inst.exp_b\[4\] adder_inst.exp_b\[7\] adder_inst.exp_b\[6\]
+ VGND VGND VPWR VPWR _3374_ sky130_fd_sc_hd__and4_1
X_4972_ net349 net296 VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_63_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7691_ _3286_ _3312_ _3314_ VGND VGND VPWR VPWR _3317_ sky130_fd_sc_hd__and3_1
X_6711_ _2338_ _2339_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__xnor2_1
X_6642_ net318 net444 net325 net452 VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__and4_1
X_9430_ clknet_leaf_19_clk multiplier_inst.man_final\[18\] _0340_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[18\] sky130_fd_sc_hd__dfrtp_1
X_9361_ clknet_leaf_19_clk _0065_ _0271_ VGND VGND VPWR VPWR add_res\[7\] sky130_fd_sc_hd__dfrtp_1
X_8312_ net149 _3774_ _3884_ net124 VGND VGND VPWR VPWR _3885_ sky130_fd_sc_hd__a211o_1
X_6573_ net439 net318 net444 net325 VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__and4_1
X_9292_ clknet_leaf_22_clk net579 _0202_ VGND VGND VPWR VPWR adder_inst.man_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_4
X_5524_ _1083_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or2_1
X_8243_ net128 _3814_ _3815_ VGND VGND VPWR VPWR _3816_ sky130_fd_sc_hd__and3_1
X_5455_ _1079_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__and2_1
X_8174_ net175 _3680_ net155 _3699_ _3747_ VGND VGND VPWR VPWR _3748_ sky130_fd_sc_hd__a41o_1
XFILLER_59_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout203 adder_inst.exp_larger_r\[0\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_2
X_5386_ net354 net261 net267 net347 VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a22o_1
Xfanout214 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__buf_2
X_7125_ _2753_ _2754_ VGND VGND VPWR VPWR _2755_ sky130_fd_sc_hd__and2b_1
XFILLER_59_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout225 adder_inst.man_b_r\[20\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
Xfanout247 net251 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_2
Xfanout236 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_4
XFILLER_115_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout269 adder_inst.man_b_r\[13\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_2
X_7056_ net344 net328 _1418_ VGND VGND VPWR VPWR _2686_ sky130_fd_sc_hd__and3_1
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_4
XFILLER_55_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6007_ _1630_ _1631_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__nand3_1
XFILLER_39_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7958_ _4336_ _4339_ VGND VGND VPWR VPWR _3553_ sky130_fd_sc_hd__nor2_1
XFILLER_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6909_ _2521_ _2523_ VGND VGND VPWR VPWR _2539_ sky130_fd_sc_hd__and2_1
X_7889_ _3439_ _3443_ _3461_ _3494_ VGND VGND VPWR VPWR _3495_ sky130_fd_sc_hd__or4_1
XFILLER_70_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5240_ _0774_ _0866_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__or3_1
XFILLER_5_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5171_ _0798_ _0799_ _0797_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__o21bai_1
XFILLER_110_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8930_ net512 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
XFILLER_68_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 i_a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_49_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8861_ net702 mul_res\[13\] net504 VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__mux2_1
XFILLER_37_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7812_ net201 _3416_ net492 VGND VGND VPWR VPWR _3418_ sky130_fd_sc_hd__o21a_1
XFILLER_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8792_ _2369_ _2565_ VGND VGND VPWR VPWR _4299_ sky130_fd_sc_hd__or2_1
XFILLER_36_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7743_ _3356_ _3357_ _3360_ _3361_ VGND VGND VPWR VPWR _3362_ sky130_fd_sc_hd__or4_1
X_4955_ net215 net221 net427 net434 VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7674_ adder_inst.exp_b_r\[4\] adder_inst.exp_a_r\[4\] _3299_ VGND VGND VPWR VPWR
+ _3300_ sky130_fd_sc_hd__and3_1
X_4886_ net250 net255 net391 net395 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand4_1
XFILLER_32_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6625_ _1716_ _2254_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__nor2_1
X_9413_ clknet_leaf_21_clk multiplier_inst.man_final\[1\] _0323_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[1\] sky130_fd_sc_hd__dfrtp_1
X_9344_ clknet_leaf_2_clk net616 _0254_ VGND VGND VPWR VPWR adder_inst.man_b_r\[22\]
+ sky130_fd_sc_hd__dfrtp_2
X_6556_ _2184_ _2185_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__and2_1
XFILLER_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9275_ clknet_leaf_17_clk adder_inst.sum_raw\[12\] _0185_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[12\]
+ sky130_fd_sc_hd__dfrtp_4
X_5507_ _1129_ _1130_ _1121_ _1125_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__o211a_1
X_8226_ net142 _3798_ _3795_ net148 VGND VGND VPWR VPWR _3799_ sky130_fd_sc_hd__a211o_1
X_6487_ _2112_ _2115_ _2116_ _2040_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__a211oi_4
XFILLER_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5438_ _1043_ _1060_ _1042_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8157_ _3671_ _3700_ VGND VGND VPWR VPWR _3731_ sky130_fd_sc_hd__nor2_1
X_5369_ _0426_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nor2_1
X_8088_ _3296_ _3303_ _3297_ VGND VGND VPWR VPWR _3662_ sky130_fd_sc_hd__a21oi_2
XFILLER_101_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7108_ _2655_ _2672_ VGND VGND VPWR VPWR _2738_ sky130_fd_sc_hd__nor2_1
XFILLER_101_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7039_ _2667_ _2668_ VGND VGND VPWR VPWR _2669_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4740_ _4479_ _4506_ _4510_ VGND VGND VPWR VPWR _4511_ sky130_fd_sc_hd__or3_1
X_4671_ _4408_ _4421_ VGND VGND VPWR VPWR _4442_ sky130_fd_sc_hd__xnor2_1
X_7390_ _3013_ _3019_ _3014_ VGND VGND VPWR VPWR _3020_ sky130_fd_sc_hd__nor3b_1
X_6410_ _2032_ _2038_ _2039_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6341_ _1887_ _1970_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__nor2_1
X_9060_ net542 VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__inv_2
X_6272_ net422 net314 net327 net416 VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__a22oi_1
X_8011_ net189 _3596_ _3597_ _3598_ VGND VGND VPWR VPWR _3599_ sky130_fd_sc_hd__a31o_1
X_5223_ _0759_ _0777_ _0791_ _0811_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__o211a_1
X_5154_ net363 net299 net306 net357 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a22oi_1
XFILLER_111_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5085_ _0713_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__xnor2_1
X_8913_ net522 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__inv_2
XFILLER_112_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8844_ _3262_ _3266_ _3265_ VGND VGND VPWR VPWR _4330_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_69_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8775_ _2568_ _2570_ VGND VGND VPWR VPWR _4282_ sky130_fd_sc_hd__xnor2_1
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5987_ _1497_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_35_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7726_ _3337_ _3347_ VGND VGND VPWR VPWR _3349_ sky130_fd_sc_hd__xnor2_1
XFILLER_12_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4938_ net250 net255 net405 net411 VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__and4_1
X_7657_ _4354_ _3282_ VGND VGND VPWR VPWR _3285_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_25_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4869_ _0496_ _0497_ _0495_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6608_ _2233_ _2237_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__xor2_1
X_7588_ _3212_ _3217_ net113 VGND VGND VPWR VPWR _3218_ sky130_fd_sc_hd__mux2_1
XFILLER_106_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9327_ clknet_leaf_0_clk net581 _0237_ VGND VGND VPWR VPWR adder_inst.man_b_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_6539_ _2148_ _2150_ _2168_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__a21oi_1
X_9258_ clknet_leaf_5_clk net53 _0168_ VGND VGND VPWR VPWR adder_inst.exp_b\[5\] sky130_fd_sc_hd__dfrtp_1
X_9189_ net543 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__inv_2
X_8209_ _3779_ _3781_ VGND VGND VPWR VPWR _3783_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_7_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5910_ _1537_ _1538_ _1533_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__a21o_1
X_6890_ net335 net342 net469 net473 VGND VGND VPWR VPWR _2520_ sky130_fd_sc_hd__and4_1
XFILLER_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5841_ _1447_ _1448_ _1468_ _1469_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__a22o_1
X_8560_ net107 _4129_ VGND VGND VPWR VPWR _4130_ sky130_fd_sc_hd__nand2_1
X_5772_ _1398_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8491_ _4061_ _4063_ VGND VGND VPWR VPWR _4064_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_60_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4723_ _4492_ _4493_ VGND VGND VPWR VPWR _4494_ sky130_fd_sc_hd__xnor2_1
X_7511_ _3140_ VGND VGND VPWR VPWR _3141_ sky130_fd_sc_hd__inv_2
X_7442_ _3037_ _3070_ VGND VGND VPWR VPWR _3072_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_12_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4654_ _4423_ _4424_ VGND VGND VPWR VPWR _4425_ sky130_fd_sc_hd__nor2_1
Xinput50 i_b[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4585_ adder_inst.exp_a_r\[0\] _4332_ VGND VGND VPWR VPWR _4356_ sky130_fd_sc_hd__nand2_1
Xinput61 i_b[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_7373_ _2984_ _3001_ VGND VGND VPWR VPWR _3003_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_116_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9112_ net531 VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__inv_2
X_6324_ _1951_ _1953_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__nand2_1
XFILLER_107_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9043_ net528 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__inv_2
X_6255_ _1876_ _1878_ _1883_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__a211oi_2
XFILLER_89_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5206_ _0581_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6186_ _1813_ _1814_ _1812_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__o21bai_1
XFILLER_97_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5137_ _0597_ _0598_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__xor2_1
X_5068_ _0695_ _0696_ _0689_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21o_1
XFILLER_57_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8827_ _3213_ _3218_ _3238_ _4317_ VGND VGND VPWR VPWR _4322_ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8758_ net699 _4272_ _0104_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a21o_1
X_7709_ _3331_ _3332_ VGND VGND VPWR VPWR _3333_ sky130_fd_sc_hd__xnor2_1
XFILLER_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8689_ _4033_ _4242_ VGND VGND VPWR VPWR adder_inst.sum_raw\[19\] sky130_fd_sc_hd__xnor2_1
XFILLER_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold108 _0012_ VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd3_1
Xhold119 multiplier_inst.man_final_r\[6\] VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6040_ _1201_ _1206_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_111_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7991_ _4338_ net501 net496 VGND VGND VPWR VPWR _3581_ sky130_fd_sc_hd__a21oi_1
XFILLER_26_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6942_ _1976_ _2122_ _2257_ _2570_ VGND VGND VPWR VPWR _2572_ sky130_fd_sc_hd__or4_4
X_6873_ _2501_ _2502_ VGND VGND VPWR VPWR _2503_ sky130_fd_sc_hd__nand2b_1
XFILLER_81_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8612_ _3947_ _4169_ _4174_ VGND VGND VPWR VPWR _4175_ sky130_fd_sc_hd__a21boi_1
X_5824_ _1451_ _1452_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_17_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8543_ adder_inst.sign_b_r adder_inst.sign_a_r _4114_ VGND VGND VPWR VPWR adder_inst.sign_sum
+ sky130_fd_sc_hd__mux2_1
X_5755_ _1372_ _1373_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__nand3_2
X_8474_ net243 net164 _3981_ _4019_ VGND VGND VPWR VPWR _4047_ sky130_fd_sc_hd__a22o_2
X_5686_ _1300_ _1314_ _1315_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__nand3_2
X_4706_ _4476_ _4475_ VGND VGND VPWR VPWR _4477_ sky130_fd_sc_hd__and2b_1
X_7425_ net206 net377 VGND VGND VPWR VPWR _3055_ sky130_fd_sc_hd__nand2_1
X_4637_ _4397_ _4406_ VGND VGND VPWR VPWR _4408_ sky130_fd_sc_hd__xor2_1
X_4568_ net498 VGND VGND VPWR VPWR _4340_ sky130_fd_sc_hd__inv_2
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7356_ _2957_ _2963_ VGND VGND VPWR VPWR _2986_ sky130_fd_sc_hd__xor2_1
XFILLER_103_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7287_ _2852_ _2916_ VGND VGND VPWR VPWR _2917_ sky130_fd_sc_hd__nor2_1
X_6307_ _1855_ _1935_ _1936_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__nand3_2
X_9026_ net514 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__inv_2
XFILLER_89_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6238_ net273 net460 net466 net269 VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__a22o_1
XFILLER_57_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6169_ _1677_ _1679_ _1701_ _1702_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__o22a_1
XFILLER_69_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_5540_ net414 net297 net305 net409 VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a22oi_1
X_5471_ _1098_ _1099_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__xnor2_1
X_7210_ _0932_ _2838_ _2839_ VGND VGND VPWR VPWR _2840_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_113_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8190_ net222 adder_inst.man_a_r\[21\] net162 VGND VGND VPWR VPWR _3764_ sky130_fd_sc_hd__mux2_1
X_7141_ _2769_ _2770_ VGND VGND VPWR VPWR _2771_ sky130_fd_sc_hd__nand2_1
Xfanout418 adder_inst.man_a_r\[11\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__buf_4
Xfanout407 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_2
Xfanout429 adder_inst.man_a_r\[9\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_2
X_7072_ net369 net375 net299 net307 VGND VGND VPWR VPWR _2702_ sky130_fd_sc_hd__nand4_1
X_6023_ _1646_ _1651_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__xnor2_1
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7974_ net484 adder_inst.sum_raw_r\[14\] net178 adder_inst.sum_raw_r\[13\] _3566_
+ VGND VGND VPWR VPWR _3567_ sky130_fd_sc_hd__a221o_1
X_6925_ _2366_ _2554_ VGND VGND VPWR VPWR _2555_ sky130_fd_sc_hd__nand2_2
XFILLER_82_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6856_ _2475_ _2476_ _2468_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__a21oi_1
X_6787_ _2381_ _2387_ _2386_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__a21o_1
XFILLER_10_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5807_ net388 net394 net298 net304 VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand4_1
X_8526_ _3879_ _3892_ _3896_ _4098_ _3878_ VGND VGND VPWR VPWR _4099_ sky130_fd_sc_hd__o221a_1
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5738_ _1366_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__nor2_1
XFILLER_108_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8457_ _4027_ _4029_ VGND VGND VPWR VPWR _4030_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_20_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5669_ _1295_ _1296_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__nand3_1
X_8388_ net261 net171 VGND VGND VPWR VPWR _3961_ sky130_fd_sc_hd__or2_1
X_7408_ _4524_ _4529_ _4523_ VGND VGND VPWR VPWR _3038_ sky130_fd_sc_hd__a21oi_1
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7339_ _2958_ _2962_ _2960_ VGND VGND VPWR VPWR _2969_ sky130_fd_sc_hd__o21ai_1
XFILLER_104_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_8_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9009_ net518 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__inv_2
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload17 clknet_leaf_16_clk VGND VGND VPWR VPWR clkload17/Y sky130_fd_sc_hd__inv_12
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_76_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4971_ net361 net296 _0468_ _0467_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__a31o_1
XFILLER_51_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7690_ _3312_ _3315_ VGND VGND VPWR VPWR _3316_ sky130_fd_sc_hd__nor2_1
X_6710_ _2338_ _2339_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_63_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6641_ _2199_ _2265_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__nand3_1
X_9360_ clknet_leaf_19_clk _0064_ _0270_ VGND VGND VPWR VPWR add_res\[6\] sky130_fd_sc_hd__dfrtp_1
X_8311_ net148 _3743_ _3744_ VGND VGND VPWR VPWR _3884_ sky130_fd_sc_hd__nor3_1
X_6572_ _2126_ _2200_ _2201_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__nand3_1
X_5523_ _1114_ _1133_ _1113_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__a21oi_1
X_9291_ clknet_leaf_22_clk net566 _0201_ VGND VGND VPWR VPWR adder_inst.man_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_105_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8242_ net138 _3738_ _3812_ net144 VGND VGND VPWR VPWR _3815_ sky130_fd_sc_hd__a211o_1
X_5454_ _1070_ _1073_ _1078_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__nand3_1
X_8173_ _3746_ VGND VGND VPWR VPWR _3747_ sky130_fd_sc_hd__inv_2
X_5385_ _0986_ _0987_ _1013_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21oi_1
Xfanout204 net205 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7124_ net234 net437 net442 net228 VGND VGND VPWR VPWR _2754_ sky130_fd_sc_hd__a22o_1
XFILLER_115_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout215 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_2
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_2
Xfanout237 net239 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_2
XFILLER_86_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout259 adder_inst.man_b_r\[14\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_4
XFILLER_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7055_ _2600_ _2611_ _2599_ VGND VGND VPWR VPWR _2685_ sky130_fd_sc_hd__a21oi_1
Xfanout248 net251 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6006_ _1632_ _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7957_ adder_inst.sum_raw_r\[10\] net490 _3462_ adder_inst.sum_raw_r\[9\] _3551_
+ VGND VGND VPWR VPWR _3552_ sky130_fd_sc_hd__a221o_1
XFILLER_70_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6908_ _2499_ _2527_ VGND VGND VPWR VPWR _2538_ sky130_fd_sc_hd__xnor2_1
X_7888_ _3469_ _3481_ _3482_ _3493_ VGND VGND VPWR VPWR _3494_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_25_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6839_ net308 net481 _2458_ _2462_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_53_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8509_ _4079_ _4081_ VGND VGND VPWR VPWR _4082_ sky130_fd_sc_hd__nand2_1
X_9489_ clknet_leaf_18_clk net688 _0399_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
XFILLER_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5170_ _0797_ _0798_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__or3_1
XFILLER_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput4 i_a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_108_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8860_ net687 mul_res\[12\] net505 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__mux2_1
X_7811_ adder_inst.sum_raw_r\[21\] _3416_ VGND VGND VPWR VPWR _3417_ sky130_fd_sc_hd__nand2_1
X_8791_ _4284_ _4285_ _4297_ VGND VGND VPWR VPWR _4298_ sky130_fd_sc_hd__or3_1
X_7742_ adder_inst.i_b\[17\] adder_inst.i_b\[18\] adder_inst.i_b\[21\] adder_inst.i_b\[22\]
+ VGND VGND VPWR VPWR _3361_ sky130_fd_sc_hd__or4_1
X_4954_ _0578_ _0582_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__xnor2_1
XFILLER_24_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7673_ _3295_ _3297_ VGND VGND VPWR VPWR _3299_ sky130_fd_sc_hd__or2_1
X_4885_ net391 net260 _0486_ _0485_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a31o_1
XFILLER_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9412_ clknet_leaf_21_clk multiplier_inst.man_final\[0\] _0322_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[0\] sky130_fd_sc_hd__dfrtp_1
X_6624_ _1717_ _1808_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__nor2_1
X_9343_ clknet_leaf_2_clk net617 _0253_ VGND VGND VPWR VPWR adder_inst.man_b_r\[21\]
+ sky130_fd_sc_hd__dfrtp_4
XPHY_EDGE_ROW_89_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6555_ _2110_ _2183_ _2182_ _2176_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__o211ai_1
X_9274_ clknet_leaf_17_clk adder_inst.sum_raw\[11\] _0184_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[11\]
+ sky130_fd_sc_hd__dfrtp_4
X_5506_ _1083_ _1115_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__or3_1
X_8225_ net139 _3715_ _3796_ VGND VGND VPWR VPWR _3798_ sky130_fd_sc_hd__a21bo_1
X_6486_ _2038_ _2039_ _2032_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__a21oi_2
X_5437_ _1018_ _1066_ _1065_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__nor3b_1
X_8156_ net148 _3718_ _3727_ net127 VGND VGND VPWR VPWR _3730_ sky130_fd_sc_hd__a211oi_1
X_5368_ net226 net397 _0424_ _0425_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__o2bb2a_1
X_8087_ _3656_ _3659_ _3299_ _3306_ VGND VGND VPWR VPWR _3661_ sky130_fd_sc_hd__a211o_2
X_7107_ _2684_ _2735_ VGND VGND VPWR VPWR _2737_ sky130_fd_sc_hd__xor2_1
X_5299_ net248 net254 net415 net420 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__and4_1
XFILLER_101_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7038_ net206 net477 VGND VGND VPWR VPWR _2668_ sky130_fd_sc_hd__nand2_1
XFILLER_47_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8989_ net513 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_2_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4670_ _4435_ _4440_ VGND VGND VPWR VPWR _4441_ sky130_fd_sc_hd__xnor2_1
X_6340_ _1804_ _1886_ _1885_ _1883_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__a211oi_1
XFILLER_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6271_ net416 net422 net320 net327 VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__and4_1
X_8010_ net485 net499 net501 net178 VGND VGND VPWR VPWR _3598_ sky130_fd_sc_hd__a22o_1
X_5222_ _0815_ _0816_ _0850_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a21oi_1
X_5153_ net368 net294 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand2_1
XFILLER_84_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5084_ net209 net421 VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand2_1
X_8912_ net520 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_55_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8843_ _3262_ _3266_ VGND VGND VPWR VPWR multiplier_inst.man_final\[20\] sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_69_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8774_ _2249_ _2571_ VGND VGND VPWR VPWR _4281_ sky130_fd_sc_hd__nand2_1
XFILLER_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5986_ _1614_ _1615_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__and2_1
X_7725_ net103 _3339_ _3347_ VGND VGND VPWR VPWR _3348_ sky130_fd_sc_hd__and3_1
X_4937_ _0530_ _0565_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_35_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7656_ _3276_ _3283_ VGND VGND VPWR VPWR _3284_ sky130_fd_sc_hd__xnor2_1
XANTENNA_20 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4868_ _0495_ _0496_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__or3_1
X_6607_ _2235_ _2236_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__and2_1
XFILLER_20_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9326_ clknet_leaf_0_clk net572 _0236_ VGND VGND VPWR VPWR adder_inst.man_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_7587_ _3215_ _3216_ VGND VGND VPWR VPWR _3217_ sky130_fd_sc_hd__or2_1
X_4799_ _0423_ _0427_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__xnor2_1
X_6538_ _2088_ _2093_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__xor2_1
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9257_ clknet_leaf_6_clk net52 _0167_ VGND VGND VPWR VPWR adder_inst.exp_b\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6469_ _2095_ _2097_ _2098_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__nand3_1
X_9188_ net544 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__inv_2
X_8208_ _3779_ _3781_ VGND VGND VPWR VPWR _3782_ sky130_fd_sc_hd__nand2_1
X_8139_ net309 net446 net161 VGND VGND VPWR VPWR _3713_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_96_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_105_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5840_ _1447_ _1448_ _1468_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__nand4_2
XFILLER_34_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5771_ _1399_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__and2b_1
X_8490_ net172 _4059_ _4062_ VGND VGND VPWR VPWR _4063_ sky130_fd_sc_hd__o21a_1
X_4722_ net223 net370 VGND VGND VPWR VPWR _4493_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7510_ _3135_ _3139_ _3132_ VGND VGND VPWR VPWR _3140_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_60_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7441_ _3070_ _3037_ VGND VGND VPWR VPWR _3071_ sky130_fd_sc_hd__and2b_1
Xinput40 i_b[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
X_4653_ net235 net370 net377 net229 VGND VGND VPWR VPWR _4424_ sky130_fd_sc_hd__a22oi_1
Xinput51 i_b[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_4584_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _4355_
+ sky130_fd_sc_hd__nand2b_2
Xinput62 i_b[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7372_ _2984_ _3001_ VGND VGND VPWR VPWR _3002_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_116_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9111_ net531 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__inv_2
X_6323_ _1872_ _1952_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__nor2_1
XFILLER_107_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9042_ net527 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__inv_2
X_6254_ _1798_ _1882_ _1880_ _1864_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__a211oi_1
XFILLER_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5205_ net226 net427 _0579_ _0580_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6185_ _1812_ _1813_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__or3_1
XFILLER_96_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5136_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__inv_2
X_5067_ _0689_ _0695_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nand3_1
XFILLER_57_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8826_ net102 _3238_ VGND VGND VPWR VPWR _4321_ sky130_fd_sc_hd__nand2b_1
XFILLER_13_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8757_ multiplier_inst.is_nan_r multiplier_inst.is_inf_r _4273_ net205 VGND VGND
+ VPWR VPWR _0104_ sky130_fd_sc_hd__o31a_2
XFILLER_52_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5969_ net206 net479 VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__nand2_1
X_7708_ _3301_ _3311_ _3300_ VGND VGND VPWR VPWR _3332_ sky130_fd_sc_hd__o21ba_1
XFILLER_52_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8688_ net180 _4239_ _4241_ VGND VGND VPWR VPWR _4242_ sky130_fd_sc_hd__a21o_1
X_7639_ _3159_ _3244_ _3261_ _3267_ VGND VGND VPWR VPWR _3269_ sky130_fd_sc_hd__and4_1
XFILLER_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9309_ clknet_leaf_1_clk net614 _0219_ VGND VGND VPWR VPWR adder_inst.man_a_r\[21\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_91_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold109 multiplier_inst.man_final_r\[4\] VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7990_ net116 _3580_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__and2_1
XFILLER_54_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6941_ _2570_ _2568_ VGND VGND VPWR VPWR _2571_ sky130_fd_sc_hd__nand2b_1
X_6872_ _2492_ _2496_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__xnor2_1
XFILLER_81_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8611_ _3947_ _4170_ _4173_ VGND VGND VPWR VPWR _4174_ sky130_fd_sc_hd__a21oi_1
X_5823_ net282 net409 net288 net405 VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_17_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8542_ _4114_ VGND VGND VPWR VPWR _4115_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_45_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5754_ _1374_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__xor2_1
X_8473_ net386 net171 _3979_ _4019_ VGND VGND VPWR VPWR _4046_ sky130_fd_sc_hd__a22o_2
X_5685_ _1307_ _1308_ _1313_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__a21o_1
X_4705_ _4464_ _4466_ _4463_ VGND VGND VPWR VPWR _4476_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_62_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7424_ _3052_ _3053_ VGND VGND VPWR VPWR _3054_ sky130_fd_sc_hd__nor2_1
X_4636_ _4406_ _4397_ VGND VGND VPWR VPWR _4407_ sky130_fd_sc_hd__and2b_1
X_7355_ _2737_ _2772_ _2736_ VGND VGND VPWR VPWR _2985_ sky130_fd_sc_hd__a21oi_1
XFILLER_116_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4567_ adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR _4339_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_77_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6306_ _1852_ _1853_ _1854_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__a21o_1
XFILLER_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7286_ net223 net442 _2850_ _2851_ VGND VGND VPWR VPWR _2916_ sky130_fd_sc_hd__o2bb2a_1
X_9025_ net514 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__inv_2
X_6237_ net260 net472 VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__nand2_1
X_6168_ _1774_ _1776_ _1796_ _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__or4_4
X_5119_ _0661_ _0746_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nor3_2
XFILLER_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_71_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6099_ net410 net314 net321 net405 VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__a22oi_1
X_8809_ _3185_ _3192_ VGND VGND VPWR VPWR _4312_ sky130_fd_sc_hd__and2b_1
XFILLER_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_80_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5470_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_113_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7140_ _2767_ _2768_ _2633_ _2635_ VGND VGND VPWR VPWR _2770_ sky130_fd_sc_hd__o211ai_1
Xfanout408 adder_inst.man_a_r\[13\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_4
X_7071_ net381 net294 VGND VGND VPWR VPWR _2701_ sky130_fd_sc_hd__nand2_1
Xfanout419 net423 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__buf_2
XFILLER_86_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6022_ _1646_ _1651_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__nand2b_1
XFILLER_39_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7973_ _3414_ _3564_ _3565_ VGND VGND VPWR VPWR _3566_ sky130_fd_sc_hd__o21a_1
XFILLER_66_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6924_ _2318_ _2362_ _2365_ VGND VGND VPWR VPWR _2554_ sky130_fd_sc_hd__or3_1
XFILLER_35_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6855_ _2444_ _2448_ _2474_ _2477_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__a211o_1
XFILLER_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6786_ _2390_ _2398_ _2397_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__a21oi_1
X_5806_ net399 net294 VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__nand2_1
X_8525_ _3830_ _3854_ _4095_ _4096_ VGND VGND VPWR VPWR _4098_ sky130_fd_sc_hd__o31ai_2
XTAP_TAPCELL_ROW_79_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5737_ net381 net315 net322 net374 VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__a22oi_1
X_8456_ net164 _4026_ _4028_ VGND VGND VPWR VPWR _4029_ sky130_fd_sc_hd__o21ai_1
XFILLER_108_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5668_ _1161_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__nor2_1
X_7407_ _4512_ _4513_ _4511_ VGND VGND VPWR VPWR _3037_ sky130_fd_sc_hd__a21bo_1
X_8387_ net123 _3958_ _3959_ VGND VGND VPWR VPWR _3960_ sky130_fd_sc_hd__and3_1
X_5599_ _1226_ _1227_ _1225_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a21bo_1
X_4619_ _4373_ _4383_ VGND VGND VPWR VPWR _4390_ sky130_fd_sc_hd__nor2_1
X_7338_ net206 net464 _2923_ _2922_ VGND VGND VPWR VPWR _2968_ sky130_fd_sc_hd__a31oi_1
XFILLER_116_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7269_ _2898_ _2897_ VGND VGND VPWR VPWR _2899_ sky130_fd_sc_hd__and2b_1
X_9008_ net518 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__inv_2
XFILLER_89_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_109_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload18 clknet_leaf_17_clk VGND VGND VPWR VPWR clkload18/Y sky130_fd_sc_hd__inv_8
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4970_ _0595_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__or2_1
XFILLER_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6640_ _2267_ _2268_ _2266_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__o21bai_1
X_6571_ _2123_ _2125_ _2124_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__o21ai_1
XFILLER_32_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8310_ net128 _3718_ net127 _3882_ VGND VGND VPWR VPWR _3883_ sky130_fd_sc_hd__a211o_1
X_5522_ _1146_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__or2_1
X_9290_ clknet_leaf_22_clk net560 _0200_ VGND VGND VPWR VPWR adder_inst.man_a_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
X_8241_ net138 _3746_ _3813_ net142 VGND VGND VPWR VPWR _3814_ sky130_fd_sc_hd__a211o_1
X_5453_ _1035_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__or2_1
X_8172_ net279 net418 net159 VGND VGND VPWR VPWR _3746_ sky130_fd_sc_hd__mux2_1
X_5384_ _0986_ _0987_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__and3_1
Xfanout205 adder_inst.i_vld_r2 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_74_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7123_ net228 net234 net437 net442 VGND VGND VPWR VPWR _2753_ sky130_fd_sc_hd__and4_1
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout216 adder_inst.man_b_r\[22\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_2
Xfanout227 adder_inst.man_b_r\[20\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_4
Xfanout238 net239 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout249 net251 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_4
X_7054_ _2614_ _2637_ _2613_ VGND VGND VPWR VPWR _2684_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6005_ _1633_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__nor2_1
X_7956_ adder_inst.sum_raw_r\[8\] net197 _3549_ _3550_ _3413_ VGND VGND VPWR VPWR
+ _3551_ sky130_fd_sc_hd__o221a_1
XFILLER_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6907_ _2484_ _2536_ VGND VGND VPWR VPWR _2537_ sky130_fd_sc_hd__xnor2_1
X_7887_ net192 _3490_ _3491_ _3492_ VGND VGND VPWR VPWR _3493_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_85_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6838_ _2458_ _2462_ net308 net481 VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__o211a_1
XFILLER_24_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8508_ _4080_ VGND VGND VPWR VPWR _4081_ sky130_fd_sc_hd__inv_2
X_6769_ _2390_ _2397_ _2398_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__and3_1
XFILLER_108_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9488_ clknet_leaf_18_clk net651 _0398_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
X_8439_ _4011_ VGND VGND VPWR VPWR _4012_ sky130_fd_sc_hd__inv_2
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput5 i_a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_83_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7810_ adder_inst.exp_larger_r\[1\] _3395_ VGND VGND VPWR VPWR _3416_ sky130_fd_sc_hd__or2_1
X_8790_ _2552_ _4287_ _4296_ _4286_ VGND VGND VPWR VPWR _4297_ sky130_fd_sc_hd__a211o_1
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7741_ adder_inst.i_b\[8\] adder_inst.i_b\[11\] adder_inst.i_b\[13\] adder_inst.i_b\[14\]
+ VGND VGND VPWR VPWR _3360_ sky130_fd_sc_hd__or4_1
X_4953_ _0578_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nand2_1
XFILLER_52_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7672_ _3295_ _3297_ VGND VGND VPWR VPWR _3298_ sky130_fd_sc_hd__nor2_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9411_ clknet_leaf_11_clk multiplier_inst.overflow_calc _0321_ VGND VGND VPWR VPWR
+ multiplier_inst.overflow_calc_r sky130_fd_sc_hd__dfrtp_1
X_4884_ _0510_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_22_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6623_ _1976_ _2252_ _1973_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_50_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9342_ clknet_leaf_3_clk net586 _0252_ VGND VGND VPWR VPWR adder_inst.man_b_r\[20\]
+ sky130_fd_sc_hd__dfrtp_4
X_6554_ _2176_ _2182_ _2183_ _2110_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__a211o_1
XFILLER_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9273_ clknet_leaf_17_clk adder_inst.sum_raw\[10\] _0183_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[10\]
+ sky130_fd_sc_hd__dfrtp_4
X_5505_ _1133_ _1134_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__or2_1
X_6485_ _2107_ _2112_ _2113_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__nand3_2
X_8224_ net139 _3715_ _3796_ VGND VGND VPWR VPWR _3797_ sky130_fd_sc_hd__a21boi_1
X_5436_ _1014_ _1015_ _1017_ _4399_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__o22a_1
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8155_ _3678_ _3700_ VGND VGND VPWR VPWR _3729_ sky130_fd_sc_hd__or2_1
X_5367_ _0419_ _0988_ _0995_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__a21oi_1
X_8086_ _3656_ _3659_ VGND VGND VPWR VPWR _3660_ sky130_fd_sc_hd__and2_1
XFILLER_87_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7106_ _2684_ _2735_ VGND VGND VPWR VPWR _2736_ sky130_fd_sc_hd__nor2_1
X_5298_ _0828_ _0926_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nand3_1
X_7037_ _2665_ _2666_ VGND VGND VPWR VPWR _2667_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_58_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8988_ net524 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_2_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7939_ adder_inst.sum_raw_r\[5\] net198 _3405_ adder_inst.sum_raw_r\[4\] net197 VGND
+ VGND VPWR VPWR _3536_ sky130_fd_sc_hd__o221a_1
XFILLER_42_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6270_ net426 net311 VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__nand2_1
XFILLER_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5221_ _0815_ _0816_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__and3_1
X_5152_ net356 net363 net299 net306 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__and4_1
XFILLER_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5083_ _0711_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nor2_1
XFILLER_56_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8911_ net520 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_55_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8842_ _3250_ _4329_ _3262_ VGND VGND VPWR VPWR multiplier_inst.man_final\[19\] sky130_fd_sc_hd__a21oi_1
XFILLER_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8773_ _2121_ _4279_ VGND VGND VPWR VPWR _4280_ sky130_fd_sc_hd__xnor2_1
X_7724_ _3340_ _3346_ VGND VGND VPWR VPWR _3347_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_82_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5985_ _1503_ _1505_ _1613_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__or3b_1
X_4936_ _0527_ _0529_ _0528_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_35_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7655_ _4352_ _3282_ _3281_ VGND VGND VPWR VPWR _3283_ sky130_fd_sc_hd__o21bai_1
XANTENNA_21 net464 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_10 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4867_ net376 net285 net289 net369 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a22oi_2
X_6606_ net284 net291 net475 net480 VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__and4_1
X_7586_ _1135_ _1156_ _3214_ VGND VGND VPWR VPWR _3216_ sky130_fd_sc_hd__and3_1
X_9325_ clknet_leaf_6_clk net587 _0235_ VGND VGND VPWR VPWR adder_inst.man_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_6537_ _2090_ _2166_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__nand2b_1
X_4798_ _0427_ _0423_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__and2b_1
X_9256_ clknet_leaf_6_clk net51 _0166_ VGND VGND VPWR VPWR adder_inst.exp_b\[3\] sky130_fd_sc_hd__dfrtp_1
X_6468_ _2073_ _2075_ _2096_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__nand3_1
X_9187_ net543 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__inv_2
X_8207_ net165 _3777_ _3780_ VGND VGND VPWR VPWR _3781_ sky130_fd_sc_hd__a21oi_1
X_5419_ _1002_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__nor2_1
X_6399_ _2009_ _2026_ _2028_ _1941_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__o211ai_4
X_8138_ net302 net440 net161 VGND VGND VPWR VPWR _3712_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8069_ net192 _3422_ VGND VGND VPWR VPWR _3647_ sky130_fd_sc_hd__nand2_1
XFILLER_87_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5770_ net270 net424 net430 net264 VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_60_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4721_ _4490_ _4491_ VGND VGND VPWR VPWR _4492_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7440_ _3068_ _3069_ VGND VGND VPWR VPWR _3070_ sky130_fd_sc_hd__or2_1
X_4652_ net229 net235 net370 net377 VGND VGND VPWR VPWR _4423_ sky130_fd_sc_hd__and4_1
Xinput30 i_a[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
Xinput52 i_b[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
X_4583_ _4352_ _4353_ VGND VGND VPWR VPWR _4354_ sky130_fd_sc_hd__nand2_1
Xinput41 i_b[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput63 i_b[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
X_9110_ net531 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_12_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7371_ _2999_ _3000_ _2998_ VGND VGND VPWR VPWR _3001_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_116_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6322_ _1790_ _1871_ _1870_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9041_ net528 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
X_6253_ _1864_ _1880_ _1882_ _1798_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__o211a_1
X_5204_ _0574_ _0817_ _0832_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_4_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6184_ net407 net332 net338 net400 VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__a22oi_2
XFILLER_69_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5135_ _0761_ _0764_ _0749_ _0754_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__a211oi_2
X_5066_ _0693_ _0694_ _0690_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a21o_1
XFILLER_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8825_ net104 _4319_ _4320_ VGND VGND VPWR VPWR multiplier_inst.man_final\[11\] sky130_fd_sc_hd__nor3_1
XFILLER_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8756_ multiplier_inst.is_zero_r multiplier_inst.overflow_calc_r VGND VGND VPWR VPWR
+ _4273_ sky130_fd_sc_hd__and2b_1
XFILLER_80_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5968_ _1596_ _1597_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__nor2_1
XFILLER_13_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7707_ _3329_ _3330_ VGND VGND VPWR VPWR _3331_ sky130_fd_sc_hd__nor2_1
X_4919_ _0542_ _0547_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__xor2_1
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8687_ net194 _4038_ _4240_ VGND VGND VPWR VPWR _4241_ sky130_fd_sc_hd__and3_1
XFILLER_21_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5899_ _1521_ _1522_ _1527_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__a21o_1
X_7638_ _3244_ _3261_ _3267_ VGND VGND VPWR VPWR _3268_ sky130_fd_sc_hd__and3_1
X_7569_ _3173_ _3184_ _3198_ _3193_ VGND VGND VPWR VPWR _3199_ sky130_fd_sc_hd__nor4b_4
XFILLER_106_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9308_ clknet_leaf_1_clk net615 _0218_ VGND VGND VPWR VPWR adder_inst.man_a_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_9239_ clknet_leaf_22_clk net64 _0149_ VGND VGND VPWR VPWR adder_inst.i_b\[9\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_91_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6940_ _2249_ _2569_ VGND VGND VPWR VPWR _2570_ sky130_fd_sc_hd__nand2_1
XFILLER_66_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6871_ _2498_ _2500_ VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_66_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8610_ _3942_ _3944_ VGND VGND VPWR VPWR _4173_ sky130_fd_sc_hd__and2b_1
XFILLER_62_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5822_ net404 net282 net409 net288 VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_17_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8541_ _4012_ _4093_ _4111_ _4113_ VGND VGND VPWR VPWR _4114_ sky130_fd_sc_hd__a2bb2o_1
X_5753_ _1381_ _1382_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_45_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4704_ _4472_ _4473_ VGND VGND VPWR VPWR _4475_ sky130_fd_sc_hd__xnor2_1
X_8472_ _4044_ VGND VGND VPWR VPWR _4045_ sky130_fd_sc_hd__inv_2
X_5684_ _1307_ _1308_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__nand3_1
X_7423_ net217 net364 net370 net213 VGND VGND VPWR VPWR _3053_ sky130_fd_sc_hd__a22oi_1
X_4635_ _4399_ _4405_ VGND VGND VPWR VPWR _4406_ sky130_fd_sc_hd__xnor2_1
X_4566_ adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR _4338_ sky130_fd_sc_hd__inv_2
X_7354_ _2978_ _2979_ VGND VGND VPWR VPWR _2984_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_77_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6305_ _1914_ _1918_ _1917_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__a21o_1
XFILLER_103_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9024_ net512 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__inv_2
X_7285_ _2843_ _2912_ _2913_ VGND VGND VPWR VPWR _2915_ sky130_fd_sc_hd__a21oi_1
X_6236_ net269 net273 net460 net465 VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__and4_1
XFILLER_57_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6167_ _1778_ _1779_ _1793_ _1795_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__o211a_1
XFILLER_84_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5118_ _0745_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__or2_1
XFILLER_57_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6098_ net405 net409 net314 net321 VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__and4_1
XFILLER_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5049_ _0677_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__and2b_1
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8808_ _3178_ _3181_ _4310_ _3185_ VGND VGND VPWR VPWR multiplier_inst.man_final\[3\]
+ sky130_fd_sc_hd__o31a_1
XFILLER_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8739_ net679 net187 net185 VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__and3_1
XFILLER_107_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7070_ _2593_ _2595_ _2594_ VGND VGND VPWR VPWR _2700_ sky130_fd_sc_hd__o21bai_1
Xfanout409 net410 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__buf_2
XFILLER_100_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6021_ _1647_ _1649_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__xnor2_1
XFILLER_67_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7972_ adder_inst.sum_raw_r\[12\] net195 net176 adder_inst.sum_raw_r\[11\] net189
+ VGND VGND VPWR VPWR _3565_ sky130_fd_sc_hd__o221a_1
XFILLER_66_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6923_ _2548_ _2551_ _2412_ _2481_ VGND VGND VPWR VPWR _2553_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_82_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6854_ _2447_ _2478_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__xnor2_2
XFILLER_62_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6785_ _2406_ _2414_ VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__nand2b_1
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5805_ _1365_ _1367_ _1366_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__o21bai_1
X_8524_ _4096_ VGND VGND VPWR VPWR _4097_ sky130_fd_sc_hd__inv_2
X_5736_ net374 net381 net315 net322 VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__and4_1
XFILLER_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8455_ net232 net171 VGND VGND VPWR VPWR _4028_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_79_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5667_ net404 net311 _1159_ _1160_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__o2bb2a_1
X_4618_ _4373_ _4387_ VGND VGND VPWR VPWR _4389_ sky130_fd_sc_hd__and2_1
X_7406_ _1158_ _3035_ _0458_ VGND VGND VPWR VPWR _3036_ sky130_fd_sc_hd__a21oi_1
X_8386_ net130 net147 _3763_ _3678_ VGND VGND VPWR VPWR _3959_ sky130_fd_sc_hd__a31o_1
X_5598_ _1225_ _1226_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__nand3b_1
XFILLER_104_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7337_ _2964_ _2965_ VGND VGND VPWR VPWR _2967_ sky130_fd_sc_hd__xnor2_1
XFILLER_104_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7268_ _2697_ _2709_ _2696_ VGND VGND VPWR VPWR _2898_ sky130_fd_sc_hd__a21oi_1
X_9007_ net545 VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__inv_2
XFILLER_77_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6219_ net290 net441 net449 net281 VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__a22o_1
X_7199_ _0907_ _0908_ _0909_ VGND VGND VPWR VPWR _2829_ sky130_fd_sc_hd__a21o_1
XFILLER_26_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload19 clknet_leaf_18_clk VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__inv_6
XFILLER_110_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6570_ _2197_ _2198_ _2196_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__o21bai_1
X_5521_ _1149_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__or2_1
X_8240_ _4358_ net156 net154 net153 _3741_ VGND VGND VPWR VPWR _3813_ sky130_fd_sc_hd__o41a_1
X_5452_ _1036_ _1080_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__xnor2_1
X_8171_ net129 _3743_ _3744_ VGND VGND VPWR VPWR _3745_ sky130_fd_sc_hd__or3_1
X_5383_ _0996_ _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nand2b_1
XFILLER_99_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7122_ net224 net448 VGND VGND VPWR VPWR _2752_ sky130_fd_sc_hd__nand2_1
X_7053_ _2640_ _2677_ _2639_ VGND VGND VPWR VPWR _2683_ sky130_fd_sc_hd__a21oi_1
Xfanout228 net230 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_2
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout206 net208 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
Xfanout217 net219 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_2
XFILLER_115_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout239 adder_inst.man_b_r\[18\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_2
X_6004_ net404 net314 net321 net398 VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a22oi_1
XFILLER_55_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7955_ adder_inst.sum_raw_r\[7\] net496 net493 VGND VGND VPWR VPWR _3550_ sky130_fd_sc_hd__a21o_1
X_6906_ _2488_ _2515_ _2530_ _2534_ _2510_ VGND VGND VPWR VPWR _2536_ sky130_fd_sc_hd__o41a_1
X_7886_ _4345_ net179 _3483_ net486 net174 VGND VGND VPWR VPWR _3492_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_85_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6837_ _2431_ _2450_ _2466_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__and3_1
X_8507_ _4077_ _4078_ VGND VGND VPWR VPWR _4080_ sky130_fd_sc_hd__and2_1
X_6768_ _2335_ _2374_ _2389_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__a21o_1
XFILLER_108_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6699_ net317 net324 net450 net456 VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__and4_1
X_9487_ clknet_leaf_19_clk net662 _0397_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
X_5719_ _1339_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__xor2_1
X_8438_ _3948_ _3967_ _3989_ _4010_ VGND VGND VPWR VPWR _4011_ sky130_fd_sc_hd__and4b_1
X_8369_ _4333_ _3941_ net168 VGND VGND VPWR VPWR _3942_ sky130_fd_sc_hd__mux2_1
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput6 i_a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_110_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_627 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7740_ adder_inst.i_b\[16\] adder_inst.i_b\[19\] adder_inst.i_b\[20\] _3358_ VGND
+ VGND VPWR VPWR _3359_ sky130_fd_sc_hd__or4_1
X_4952_ _0579_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__or2_1
XFILLER_17_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7671_ adder_inst.exp_a_r\[5\] adder_inst.exp_b_r\[5\] VGND VGND VPWR VPWR _3297_
+ sky130_fd_sc_hd__and2b_1
X_4883_ _0510_ _0511_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__or3_1
X_9410_ clknet_leaf_10_clk net696 _0320_ VGND VGND VPWR VPWR multiplier_inst.is_nan_r
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_20_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6622_ _2046_ _2121_ _2250_ _2251_ _2045_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__a311oi_2
XFILLER_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9341_ clknet_leaf_3_clk net582 _0251_ VGND VGND VPWR VPWR adder_inst.man_b_r\[19\]
+ sky130_fd_sc_hd__dfrtp_4
X_6553_ _2103_ _2104_ _2109_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__o21ba_1
X_9272_ clknet_leaf_17_clk adder_inst.sum_raw\[9\] _0182_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[9\]
+ sky130_fd_sc_hd__dfrtp_4
X_5504_ _1116_ _1132_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__and2_1
X_6484_ _2107_ _2112_ _2113_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__and3_1
XFILLER_106_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8223_ _4358_ net156 net154 net153 _3713_ VGND VGND VPWR VPWR _3796_ sky130_fd_sc_hd__o41ai_1
X_5435_ _1061_ _1062_ _1064_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__and3_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8154_ _3678_ _3700_ VGND VGND VPWR VPWR _3728_ sky130_fd_sc_hd__nor2_2
X_5366_ _0419_ _0988_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__and3_1
X_8085_ _3654_ _3657_ VGND VGND VPWR VPWR _3659_ sky130_fd_sc_hd__nand2b_1
XFILLER_101_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7105_ _2712_ _2734_ VGND VGND VPWR VPWR _2735_ sky130_fd_sc_hd__xnor2_1
X_5297_ _0825_ _0827_ _0826_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__o21ai_1
XFILLER_101_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7036_ net217 net460 net467 net214 VGND VGND VPWR VPWR _2666_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_87_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8987_ net516 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__inv_2
XFILLER_82_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7938_ net115 _3535_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__and2_1
XFILLER_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7869_ net494 _3432_ VGND VGND VPWR VPWR _3475_ sky130_fd_sc_hd__nor2_1
XFILLER_51_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5220_ _0833_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_71_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5151_ _0463_ _0779_ _0778_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__a21o_1
XFILLER_110_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5082_ net221 net412 net418 net215 VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__a22oi_1
X_8910_ net522 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
XFILLER_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8841_ _3270_ _4328_ _4329_ VGND VGND VPWR VPWR multiplier_inst.man_final\[18\] sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_55_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8772_ _2257_ _2571_ _2250_ VGND VGND VPWR VPWR _4279_ sky130_fd_sc_hd__o21bai_1
X_7723_ _3344_ _3345_ VGND VGND VPWR VPWR _3346_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_82_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5984_ _1503_ _1505_ _1613_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__o21bai_1
XFILLER_24_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4935_ net260 net400 _0563_ _0561_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a31o_1
X_7654_ _3280_ _3281_ VGND VGND VPWR VPWR _3282_ sky130_fd_sc_hd__or2_1
XANTENNA_11 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_22 net479 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4866_ net383 net279 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__nand2_1
X_6605_ _2163_ _2234_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__nor2_1
X_7585_ _1156_ _3214_ _1135_ VGND VGND VPWR VPWR _3215_ sky130_fd_sc_hd__a21oi_1
X_4797_ _0424_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nor2_1
X_9324_ clknet_leaf_8_clk net611 _0234_ VGND VGND VPWR VPWR adder_inst.man_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_6536_ _2160_ _2164_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__xnor2_1
X_9255_ clknet_leaf_6_clk net50 _0165_ VGND VGND VPWR VPWR adder_inst.exp_b\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6467_ _2073_ _2075_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__a21o_1
X_9186_ net546 VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__inv_2
X_8206_ net483 net165 VGND VGND VPWR VPWR _3780_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_93_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5418_ net226 net402 _1000_ _1001_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__o2bb2a_1
X_6398_ _1924_ _1925_ _1939_ _1940_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__a22o_1
X_8137_ _4358_ _3679_ _3694_ _3698_ VGND VGND VPWR VPWR _3711_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_7_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5349_ _0449_ _0451_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__xor2_1
X_8068_ _3628_ _3646_ net205 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__o21a_1
XFILLER_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7019_ _2646_ _2647_ _2645_ VGND VGND VPWR VPWR _2649_ sky130_fd_sc_hd__a21bo_1
XFILLER_55_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4720_ net229 net365 net235 net358 VGND VGND VPWR VPWR _4491_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_32_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4651_ _4408_ _4421_ VGND VGND VPWR VPWR _4422_ sky130_fd_sc_hd__or2_1
Xinput31 i_a[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput20 i_a[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput53 i_b[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
X_4582_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] _4351_ VGND VGND VPWR VPWR
+ _4353_ sky130_fd_sc_hd__or3_1
Xinput42 i_b[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
Xinput64 i_b[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7370_ _2996_ _2997_ VGND VGND VPWR VPWR _3000_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_116_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6321_ net257 net480 _1950_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__and3_1
X_9040_ net527 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__inv_2
X_6252_ _1774_ _1776_ _1796_ _1797_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__o22ai_1
XFILLER_115_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5203_ _0574_ _0817_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__and3_1
X_6183_ net411 net329 VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__nand2_1
XFILLER_97_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5134_ _0593_ _0760_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__or4_4
XFILLER_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5065_ _0690_ _0693_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand3_1
XFILLER_37_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8824_ _3213_ _3218_ _4317_ VGND VGND VPWR VPWR _4320_ sky130_fd_sc_hd__nor3_2
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8755_ multiplier_inst.is_zero_r net205 VGND VGND VPWR VPWR _4272_ sky130_fd_sc_hd__and2b_2
XFILLER_80_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5967_ net217 net467 net477 net210 VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__a22oi_1
X_7706_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] _3328_ VGND VGND VPWR VPWR
+ _3330_ sky130_fd_sc_hd__and3_1
X_8686_ _4234_ _4235_ _4043_ VGND VGND VPWR VPWR _4240_ sky130_fd_sc_hd__a21o_1
X_4918_ _0542_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__and2_1
X_7637_ _3265_ _3266_ VGND VGND VPWR VPWR _3267_ sky130_fd_sc_hd__and2_1
XFILLER_21_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5898_ _1521_ _1522_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__nand3_1
X_4849_ net372 net285 adder_inst.man_b_r\[9\] net366 VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a22oi_2
XFILLER_21_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7568_ net109 _3197_ _3195_ VGND VGND VPWR VPWR _3198_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9307_ clknet_leaf_1_clk net619 _0217_ VGND VGND VPWR VPWR adder_inst.man_a_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_6519_ _2146_ _2147_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__xnor2_1
X_7499_ _3124_ _3127_ _3128_ VGND VGND VPWR VPWR _3129_ sky130_fd_sc_hd__a21oi_1
XFILLER_106_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9238_ clknet_leaf_3_clk net63 _0148_ VGND VGND VPWR VPWR adder_inst.i_b\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9169_ net529 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__inv_2
XFILLER_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6870_ net317 net324 net474 net482 VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_66_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5821_ net278 net415 VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8540_ _4083_ _4084_ _4112_ VGND VGND VPWR VPWR _4113_ sky130_fd_sc_hd__o21a_1
X_5752_ _1379_ _1380_ _1375_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__a21o_1
XFILLER_34_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_4703_ _4473_ _4472_ VGND VGND VPWR VPWR _4474_ sky130_fd_sc_hd__and2b_1
X_8471_ _4033_ _4042_ VGND VGND VPWR VPWR _4044_ sky130_fd_sc_hd__or2_1
XFILLER_30_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5683_ _1309_ _1312_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__xnor2_1
X_7422_ net213 net219 net364 net370 VGND VGND VPWR VPWR _3052_ sky130_fd_sc_hd__and4_1
X_4634_ _4400_ _4404_ VGND VGND VPWR VPWR _4405_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4565_ adder_inst.sum_raw_r\[3\] VGND VGND VPWR VPWR _4337_ sky130_fd_sc_hd__inv_2
X_7353_ _2981_ _2982_ VGND VGND VPWR VPWR _2983_ sky130_fd_sc_hd__and2b_1
XFILLER_116_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6304_ _1932_ _1933_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__and2_1
XFILLER_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9023_ net509 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7284_ _2843_ _2912_ _2913_ VGND VGND VPWR VPWR _2914_ sky130_fd_sc_hd__and3_1
XFILLER_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6235_ _1771_ _1863_ net157 _1844_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__a211oi_2
XFILLER_69_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6166_ _1793_ _1795_ _1778_ _1779_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__a211oi_1
X_5117_ _0743_ _0744_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__and2_1
X_6097_ net418 net311 VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__nand2_1
XFILLER_84_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5048_ net373 net267 net275 net366 VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a22o_1
XFILLER_38_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8807_ _4310_ _4311_ VGND VGND VPWR VPWR multiplier_inst.man_final\[2\] sky130_fd_sc_hd__nor2_1
X_8738_ net621 net187 net183 VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__and3_1
XFILLER_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6999_ _2625_ _2628_ VGND VGND VPWR VPWR _2629_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8669_ _4052_ _4053_ VGND VGND VPWR VPWR _4225_ sky130_fd_sc_hd__and2_1
XFILLER_111_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_3_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_6020_ _1171_ _1647_ _1648_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__or3_1
XFILLER_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7971_ adder_inst.sum_raw_r\[10\] _3563_ net197 VGND VGND VPWR VPWR _3564_ sky130_fd_sc_hd__mux2_1
XFILLER_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6922_ _2548_ _2551_ VGND VGND VPWR VPWR _2552_ sky130_fd_sc_hd__nand2_1
X_6853_ _2409_ _2413_ _2446_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__a21o_1
XFILLER_62_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5804_ _1377_ _1379_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__nand2_1
XFILLER_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6784_ _2401_ _2405_ _2404_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__o21ai_1
X_8523_ _3830_ _3849_ _3851_ _3829_ VGND VGND VPWR VPWR _4096_ sky130_fd_sc_hd__o31a_1
XFILLER_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5735_ net387 net310 VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__nand2_1
X_8454_ net124 _3790_ _3979_ net171 net372 VGND VGND VPWR VPWR _4027_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_79_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5666_ _1293_ _1294_ _1289_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__a21o_1
X_4617_ _4373_ _4387_ VGND VGND VPWR VPWR _4388_ sky130_fd_sc_hd__nor2_1
X_7405_ _3029_ _3030_ _3034_ VGND VGND VPWR VPWR _3035_ sky130_fd_sc_hd__a21o_1
X_8385_ net150 _3844_ _3914_ net127 VGND VGND VPWR VPWR _3958_ sky130_fd_sc_hd__a211o_1
X_5597_ net252 net441 net447 net245 VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__a22o_1
XFILLER_89_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7336_ _2964_ _2965_ VGND VGND VPWR VPWR _2966_ sky130_fd_sc_hd__and2b_1
X_7267_ _2809_ _2817_ VGND VGND VPWR VPWR _2897_ sky130_fd_sc_hd__xor2_1
X_9006_ net520 VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__inv_2
X_6218_ net280 net453 VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__nand2_1
X_7198_ _2810_ _2814_ _2813_ VGND VGND VPWR VPWR _2828_ sky130_fd_sc_hd__a21bo_1
XFILLER_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6149_ _1697_ _1777_ _1769_ _1767_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__a211oi_1
XFILLER_38_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5520_ _1147_ _1148_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__and2_1
XFILLER_8_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5451_ _1036_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__or2_1
X_8170_ net137 _3737_ _3735_ net143 VGND VGND VPWR VPWR _3744_ sky130_fd_sc_hd__o211a_1
X_5382_ _0996_ _0997_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_74_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7121_ _2747_ _2748_ _2749_ VGND VGND VPWR VPWR _2751_ sky130_fd_sc_hd__a21oi_1
XFILLER_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout207 net208 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__clkbuf_4
X_7052_ _2680_ _2681_ _2679_ VGND VGND VPWR VPWR _2682_ sky130_fd_sc_hd__a21oi_1
Xfanout229 net230 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_2
Xfanout218 net219 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__buf_2
XFILLER_99_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6003_ net398 net404 net314 net321 VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__and4_1
XFILLER_94_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7954_ adder_inst.sum_raw_r\[5\] net177 _3548_ VGND VGND VPWR VPWR _3549_ sky130_fd_sc_hd__o21a_1
XFILLER_67_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6905_ _2488_ _2516_ _2530_ _2534_ VGND VGND VPWR VPWR _2535_ sky130_fd_sc_hd__nor4_1
XFILLER_82_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7885_ net489 _3485_ VGND VGND VPWR VPWR _3491_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6836_ _2463_ _2464_ _2457_ VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_59_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6767_ _2394_ _2395_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__xor2_1
XFILLER_109_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8506_ _4077_ _4078_ VGND VGND VPWR VPWR _4079_ sky130_fd_sc_hd__or2_1
X_5718_ _1346_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__and2b_1
XFILLER_109_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6698_ _2269_ _2322_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__nand3_1
X_9486_ clknet_leaf_20_clk net684 _0396_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
XFILLER_108_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8437_ _4009_ VGND VGND VPWR VPWR _4010_ sky130_fd_sc_hd__inv_2
X_5649_ _1269_ _1270_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__nor3_2
X_8368_ net124 _3940_ _3938_ net121 VGND VGND VPWR VPWR _3941_ sky130_fd_sc_hd__a211o_1
XFILLER_116_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_68_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7319_ _2948_ _2947_ VGND VGND VPWR VPWR _2949_ sky130_fd_sc_hd__and2b_1
XFILLER_104_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8299_ net129 _3871_ VGND VGND VPWR VPWR _3872_ sky130_fd_sc_hd__nand2_1
XFILLER_104_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 i_a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_108_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4951_ _0579_ _0580_ net226 net427 VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and4bb_1
XFILLER_51_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7670_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR _3296_
+ sky130_fd_sc_hd__nand2b_1
X_4882_ net255 net395 net400 net250 VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a22oi_1
XFILLER_60_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6621_ _2046_ _2117_ _2119_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__and3_1
X_9340_ clknet_leaf_4_clk net595 _0250_ VGND VGND VPWR VPWR adder_inst.man_b_r\[18\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_32_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6552_ _2176_ _2177_ _2181_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__nand3_1
XFILLER_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9271_ clknet_leaf_17_clk adder_inst.sum_raw\[8\] _0181_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[8\]
+ sky130_fd_sc_hd__dfrtp_4
X_5503_ _1116_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nor2_1
X_6483_ _2036_ _2111_ _2110_ _2103_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__a211o_1
X_8222_ _3711_ _3719_ _3793_ net145 VGND VGND VPWR VPWR _3795_ sky130_fd_sc_hd__o211a_1
X_5434_ _0984_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__nor2_1
X_8153_ net144 _3721_ _3724_ _3726_ net128 VGND VGND VPWR VPWR _3727_ sky130_fd_sc_hd__o221a_1
XFILLER_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5365_ _0992_ _0993_ _0991_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a21bo_1
X_7104_ _2732_ _2733_ VGND VGND VPWR VPWR _2734_ sky130_fd_sc_hd__and2_1
XFILLER_113_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8084_ _3657_ VGND VGND VPWR VPWR _3658_ sky130_fd_sc_hd__inv_2
XFILLER_87_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5296_ net263 net413 _0924_ _0922_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a31o_1
XFILLER_87_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7035_ net214 net217 net460 net467 VGND VGND VPWR VPWR _2665_ sky130_fd_sc_hd__and4_1
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8986_ net509 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_2_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7937_ net484 adder_inst.sum_raw_r\[9\] adder_inst.sum_raw_r\[8\] net178 _3534_ VGND
+ VGND VPWR VPWR _3535_ sky130_fd_sc_hd__a221o_1
XFILLER_35_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7868_ _3388_ _3406_ VGND VGND VPWR VPWR _3474_ sky130_fd_sc_hd__nand2b_1
XFILLER_70_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6819_ _2433_ _2439_ _2438_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__a21oi_1
XFILLER_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7799_ net198 net500 VGND VGND VPWR VPWR _3405_ sky130_fd_sc_hd__nand2_1
XFILLER_50_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9469_ clknet_leaf_11_clk _0088_ _0379_ VGND VGND VPWR VPWR mul_res\[24\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_85_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_94_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5150_ _0463_ _0778_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nand3_1
X_5081_ net215 net221 net412 net418 VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__and4_1
XFILLER_111_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8840_ _3244_ _3253_ _3257_ _3260_ VGND VGND VPWR VPWR _4329_ sky130_fd_sc_hd__nand4_1
XFILLER_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5983_ _1495_ _1499_ _1494_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__a21oi_1
XFILLER_25_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8771_ _1975_ _3164_ VGND VGND VPWR VPWR _4278_ sky130_fd_sc_hd__xor2_1
X_7722_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR _3345_
+ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4934_ _0561_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_35_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7653_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] _3279_ VGND VGND VPWR VPWR
+ _3281_ sky130_fd_sc_hd__and3_1
XANTENNA_23 adder_inst.exp_larger\[2\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_12 net251 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4865_ net369 net376 net285 net289 VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__and4_1
X_6604_ net280 net480 _2161_ _2162_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__o2bb2a_1
X_7584_ _0977_ _3207_ _1152_ VGND VGND VPWR VPWR _3214_ sky130_fd_sc_hd__a21o_1
X_4796_ _0424_ _0425_ net226 net397 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and4bb_1
X_9323_ clknet_leaf_8_clk net594 _0233_ VGND VGND VPWR VPWR adder_inst.man_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_4
X_6535_ _2086_ _2159_ _2164_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__or3_1
X_9254_ clknet_leaf_5_clk net49 _0164_ VGND VGND VPWR VPWR adder_inst.exp_b\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8205_ net172 _3777_ _3778_ VGND VGND VPWR VPWR _3779_ sky130_fd_sc_hd__a21o_1
X_6466_ _2018_ _2019_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__xnor2_1
X_9185_ net547 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__inv_2
X_5417_ _0994_ _1044_ _1045_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a21oi_1
X_6397_ _2009_ _2010_ _2024_ _2025_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__or4bb_1
X_8136_ net175 _3680_ _3693_ _3699_ VGND VGND VPWR VPWR _3710_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_93_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5348_ _0453_ _0454_ _0444_ _0447_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__a211o_1
X_8067_ _3642_ _3645_ _3643_ _3644_ VGND VGND VPWR VPWR _3646_ sky130_fd_sc_hd__and4bb_1
XFILLER_102_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7018_ _2645_ _2646_ _2647_ VGND VGND VPWR VPWR _2648_ sky130_fd_sc_hd__nand3b_1
X_5279_ _0819_ _0821_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__xnor2_1
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8969_ net542 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__inv_2
XFILLER_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout390 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_105_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4650_ _4414_ _4420_ VGND VGND VPWR VPWR _4421_ sky130_fd_sc_hd__and2_1
Xinput21 i_a[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput10 i_a[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput54 i_b[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
X_4581_ adder_inst.exp_a_r\[0\] adder_inst.exp_b_r\[0\] _4351_ VGND VGND VPWR VPWR
+ _4352_ sky130_fd_sc_hd__o21ai_1
Xinput43 i_b[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput32 i_a[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
X_6320_ net259 net480 _1948_ _1946_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_12_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput65 i_vld VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6251_ _1864_ _1865_ _1879_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__or3_2
X_5202_ _0829_ _0830_ _0824_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a21bo_1
X_6182_ net400 net407 net332 net338 VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__and4_1
XFILLER_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5133_ _0743_ _0755_ _0759_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a21oi_1
XFILLER_84_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5064_ net242 net392 _0691_ _0692_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a22o_1
XFILLER_72_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8823_ _3213_ _4317_ _3218_ VGND VGND VPWR VPWR _4319_ sky130_fd_sc_hd__o21a_1
XFILLER_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8754_ multiplier_inst.is_nan_r _4271_ net204 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o21a_1
XFILLER_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5966_ net210 net217 net467 net477 VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__and4_1
X_7705_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] _3328_ VGND VGND VPWR VPWR
+ _3329_ sky130_fd_sc_hd__a21oi_1
X_8685_ _4238_ _4237_ net107 VGND VGND VPWR VPWR _4239_ sky130_fd_sc_hd__mux2_1
X_4917_ net227 net423 _0544_ _0543_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a31o_1
X_5897_ _1523_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__xnor2_1
X_4848_ net379 net279 VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nand2_1
X_7636_ _3249_ _3264_ net112 VGND VGND VPWR VPWR _3266_ sky130_fd_sc_hd__mux2_1
XFILLER_21_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9306_ clknet_leaf_1_clk net593 _0216_ VGND VGND VPWR VPWR adder_inst.man_a_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_7567_ _2888_ _3196_ VGND VGND VPWR VPWR _3197_ sky130_fd_sc_hd__xnor2_1
X_4779_ _4547_ _4549_ VGND VGND VPWR VPWR _4550_ sky130_fd_sc_hd__and2b_1
X_6518_ _2146_ _2147_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__nand2b_1
X_7498_ _3118_ _3121_ _3117_ VGND VGND VPWR VPWR _3128_ sky130_fd_sc_hd__a21bo_1
X_9237_ clknet_leaf_0_clk net62 _0147_ VGND VGND VPWR VPWR adder_inst.i_b\[7\] sky130_fd_sc_hd__dfrtp_1
X_6449_ _1993_ _1994_ _2005_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__a21oi_1
X_9168_ net529 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__inv_2
X_8119_ _3685_ _3686_ _3691_ _3692_ VGND VGND VPWR VPWR _3693_ sky130_fd_sc_hd__nor4_1
XFILLER_88_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9099_ net525 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__inv_2
XFILLER_75_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5820_ _1374_ _1382_ _1381_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__a21o_1
XFILLER_22_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5751_ _1375_ _1379_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_45_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8470_ _4042_ VGND VGND VPWR VPWR _4043_ sky130_fd_sc_hd__inv_2
X_4702_ _4458_ _4459_ _4461_ _4468_ VGND VGND VPWR VPWR _4473_ sky130_fd_sc_hd__o31a_1
X_7421_ _3049_ _3050_ VGND VGND VPWR VPWR _3051_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5682_ _1310_ _1311_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__nor2_1
X_4633_ _4402_ _4403_ VGND VGND VPWR VPWR _4404_ sky130_fd_sc_hd__nor2_1
X_4564_ net484 VGND VGND VPWR VPWR _4336_ sky130_fd_sc_hd__inv_2
X_7352_ _2953_ _2977_ _2980_ VGND VGND VPWR VPWR _2982_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_77_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7283_ _2739_ _2746_ _2745_ VGND VGND VPWR VPWR _2913_ sky130_fd_sc_hd__a21bo_1
X_6303_ _1867_ _1869_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__xnor2_1
X_9022_ net512 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_31_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6234_ _1844_ net157 _1863_ _1771_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__o211a_4
XTAP_TAPCELL_ROW_90_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6165_ _1271_ _1794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__or2_1
XFILLER_85_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5116_ _0659_ _0660_ _0536_ _0556_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__o211a_1
X_6096_ _1627_ _1724_ _1723_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a21o_1
X_5047_ net366 net373 net268 net275 VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__and4_1
XFILLER_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6998_ _2626_ _2627_ VGND VGND VPWR VPWR _2628_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_40_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8806_ _3173_ _3183_ VGND VGND VPWR VPWR _4311_ sky130_fd_sc_hd__and2_1
XFILLER_80_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8737_ net668 net187 net183 VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__and3_1
X_5949_ _1576_ _1577_ _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__nand3b_1
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8668_ _4057_ _4220_ _4221_ VGND VGND VPWR VPWR _4224_ sky130_fd_sc_hd__and3b_1
X_8599_ _4100_ _4163_ net105 VGND VGND VPWR VPWR _4164_ sky130_fd_sc_hd__mux2_1
X_7619_ _3248_ VGND VGND VPWR VPWR _3249_ sky130_fd_sc_hd__inv_2
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7970_ adder_inst.sum_raw_r\[9\] net496 _3561_ _3562_ VGND VGND VPWR VPWR _3563_
+ sky130_fd_sc_hd__a22o_1
X_6921_ _2412_ _2481_ _2549_ _2550_ VGND VGND VPWR VPWR _2551_ sky130_fd_sc_hd__o211a_1
XFILLER_94_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6852_ _2409_ _2413_ _2446_ VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__nand3_2
XFILLER_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5803_ _1430_ _1431_ _1415_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__a21oi_1
XFILLER_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8522_ _3779_ _3781_ _4091_ _4024_ VGND VGND VPWR VPWR _4095_ sky130_fd_sc_hd__a31oi_2
X_6783_ _2407_ _2408_ _2402_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__a21o_1
XFILLER_50_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5734_ _1361_ _1362_ _1357_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__a21o_1
XFILLER_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8453_ net121 _3791_ VGND VGND VPWR VPWR _4026_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_79_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5665_ _1289_ _1293_ _1294_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__nand3_1
X_8384_ _3956_ VGND VGND VPWR VPWR _3957_ sky130_fd_sc_hd__inv_2
X_7404_ _1136_ _1152_ _3031_ _3033_ VGND VGND VPWR VPWR _3034_ sky130_fd_sc_hd__or4_1
X_4616_ _4385_ _4386_ VGND VGND VPWR VPWR _4387_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5596_ net245 net252 net441 net447 VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__nand4_1
X_7335_ _2911_ _2935_ VGND VGND VPWR VPWR _2965_ sky130_fd_sc_hd__xor2_1
XFILLER_116_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap151 _1018_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_1
Xmax_cap173 _1501_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_1
X_7266_ _2834_ _2895_ VGND VGND VPWR VPWR _2896_ sky130_fd_sc_hd__nand2_1
X_9005_ net522 VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
X_7197_ _2823_ _2826_ VGND VGND VPWR VPWR _2827_ sky130_fd_sc_hd__nand2_1
X_6217_ net281 net290 net443 net449 VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__and4_1
X_6148_ _1767_ _1769_ _1777_ _1697_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__o211a_1
XFILLER_38_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6079_ _1276_ _1699_ _1701_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__or3_1
XFILLER_57_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5450_ _1027_ _1037_ _1077_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__o31a_1
X_5381_ _1004_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_74_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7120_ _2747_ _2748_ _2749_ VGND VGND VPWR VPWR _2750_ sky130_fd_sc_hd__and3_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_2
X_7051_ _2578_ _2579_ VGND VGND VPWR VPWR _2681_ sky130_fd_sc_hd__xnor2_1
Xfanout219 net220 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_105_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6002_ net410 net311 VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__nand2_1
XFILLER_67_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7953_ adder_inst.sum_raw_r\[6\] _4341_ net188 adder_inst.sum_raw_r\[4\] net198 VGND
+ VGND VPWR VPWR _3548_ sky130_fd_sc_hd__o221a_1
XFILLER_82_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6904_ _2532_ _2533_ VGND VGND VPWR VPWR _2534_ sky130_fd_sc_hd__or2_1
XFILLER_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7884_ net492 _3386_ _3415_ _3489_ net489 VGND VGND VPWR VPWR _3490_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_85_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6835_ _2457_ _2464_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__and2b_1
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_114_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6766_ _2394_ _2395_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__and2_1
X_8505_ net355 net172 _3917_ _3979_ VGND VGND VPWR VPWR _4078_ sky130_fd_sc_hd__a22o_1
X_5717_ _1344_ _1345_ _1340_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__a21o_1
XFILLER_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6697_ _2324_ _2325_ _2323_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__o21bai_1
X_9485_ clknet_leaf_20_clk net677 _0395_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
XFILLER_40_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8436_ _3997_ _4007_ VGND VGND VPWR VPWR _4009_ sky130_fd_sc_hd__or2_1
X_5648_ _1276_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__or2_1
X_8367_ net129 _3858_ _3939_ VGND VGND VPWR VPWR _3940_ sky130_fd_sc_hd__a21oi_1
X_5579_ _1200_ _1207_ _1208_ _1193_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__o211ai_4
X_8298_ net146 _3784_ _3870_ VGND VGND VPWR VPWR _3871_ sky130_fd_sc_hd__o21a_1
X_7318_ _2892_ _2946_ VGND VGND VPWR VPWR _2948_ sky130_fd_sc_hd__xnor2_1
X_7249_ _2876_ _2877_ VGND VGND VPWR VPWR _2879_ sky130_fd_sc_hd__xor2_1
XFILLER_49_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput8 i_a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4950_ net237 net417 net421 net231 VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a22oi_1
X_4881_ net242 net407 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
XFILLER_32_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6620_ _2191_ _2249_ _2192_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__o21bai_1
X_6551_ _2091_ _2178_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__xnor2_1
X_5502_ _1129_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nor2_1
X_9270_ clknet_leaf_16_clk adder_inst.sum_raw\[7\] _0180_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[7\]
+ sky130_fd_sc_hd__dfrtp_4
X_6482_ _2103_ _2110_ _2111_ _2036_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__o211ai_4
X_8221_ _3711_ _3719_ _3793_ VGND VGND VPWR VPWR _3794_ sky130_fd_sc_hd__o21a_1
X_5433_ _0724_ _0982_ _0983_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__nor3_1
X_8152_ net139 _3725_ net142 VGND VGND VPWR VPWR _3726_ sky130_fd_sc_hd__a21o_1
X_5364_ _0991_ _0992_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nand3_1
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7103_ _2729_ _2731_ _2623_ _2630_ VGND VGND VPWR VPWR _2733_ sky130_fd_sc_hd__o211ai_1
X_8083_ adder_inst.exp_a_r\[0\] _4332_ _4348_ _4349_ VGND VGND VPWR VPWR _3657_ sky130_fd_sc_hd__a31oi_2
XFILLER_59_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5295_ _0922_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__and2b_1
XFILLER_59_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7034_ _2661_ _2662_ VGND VGND VPWR VPWR _2664_ sky130_fd_sc_hd__xnor2_1
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8985_ net516 VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_2_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7936_ adder_inst.sum_raw_r\[5\] _3504_ _3532_ _3533_ VGND VGND VPWR VPWR _3534_
+ sky130_fd_sc_hd__o211a_1
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7867_ _4343_ _3413_ VGND VGND VPWR VPWR _3473_ sky130_fd_sc_hd__nand2_2
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6818_ _2442_ _2443_ _2437_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__a21o_1
XFILLER_23_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7798_ net498 _4341_ VGND VGND VPWR VPWR _3404_ sky130_fd_sc_hd__nor2_2
XFILLER_50_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6749_ _2376_ _2377_ _2378_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_98_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9468_ clknet_leaf_12_clk _0087_ _0378_ VGND VGND VPWR VPWR mul_res\[23\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8419_ net163 _3991_ VGND VGND VPWR VPWR _3992_ sky130_fd_sc_hd__or2_1
X_9399_ clknet_leaf_6_clk net607 _0309_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_78_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5080_ _0707_ _0708_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5982_ _1609_ _1610_ _1472_ net134 VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__a211oi_1
XFILLER_18_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8770_ _1972_ _4276_ VGND VGND VPWR VPWR _4277_ sky130_fd_sc_hd__nor2_1
X_7721_ _3341_ _3343_ VGND VGND VPWR VPWR _3344_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_82_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4933_ net269 net395 net273 net388 VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a22o_1
XFILLER_33_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7652_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] _3279_ VGND VGND VPWR VPWR
+ _3280_ sky130_fd_sc_hd__a21oi_1
XANTENNA_13 net257 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4864_ _0477_ _0479_ _0478_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__o21ai_1
X_6603_ _2231_ _2232_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__xor2_1
XANTENNA_24 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7583_ _3209_ _3212_ net113 VGND VGND VPWR VPWR _3213_ sky130_fd_sc_hd__mux2_2
X_4795_ net237 net386 net392 net231 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a22oi_1
XFILLER_20_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9322_ clknet_leaf_6_clk net597 _0232_ VGND VGND VPWR VPWR adder_inst.man_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_4
X_6534_ _2161_ _2163_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__nor2_1
X_9253_ clknet_leaf_5_clk net48 _0163_ VGND VGND VPWR VPWR adder_inst.exp_b\[0\] sky130_fd_sc_hd__dfrtp_1
X_6465_ _2015_ _2082_ _2087_ _2094_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__o31ai_1
X_8204_ net550 net172 VGND VGND VPWR VPWR _3778_ sky130_fd_sc_hd__nor2_1
X_5416_ _0994_ _1044_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__and3_1
X_9184_ net548 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__inv_2
X_6396_ _2009_ _2010_ _2024_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__and4bb_1
XFILLER_114_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8135_ net156 net154 net153 _3707_ VGND VGND VPWR VPWR _3709_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_93_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5347_ _0870_ _0976_ _0871_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_7_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8066_ net487 net203 net201 _3387_ VGND VGND VPWR VPWR _3645_ sky130_fd_sc_hd__and4_1
XFILLER_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5278_ _0800_ _0901_ _0906_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a21o_1
X_7017_ net253 net429 net431 net247 VGND VGND VPWR VPWR _2647_ sky130_fd_sc_hd__a22o_1
XFILLER_101_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8968_ net541 VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7919_ _4337_ _3504_ VGND VGND VPWR VPWR _3519_ sky130_fd_sc_hd__nor2_1
XFILLER_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8899_ net513 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__inv_2
XFILLER_51_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout391 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkbuf_4
Xfanout380 adder_inst.man_a_r\[18\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_105_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 i_a[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_4580_ _4348_ _4350_ VGND VGND VPWR VPWR _4351_ sky130_fd_sc_hd__nand2_1
Xinput11 i_a[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
Xinput44 i_b[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
Xinput55 i_b[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput33 i_b[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput66 opcode VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6250_ _1864_ _1865_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__nor3_1
XFILLER_69_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6181_ _1718_ _1810_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__nand2_1
X_5201_ _0824_ _0829_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nand3_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_5132_ _0558_ _0559_ _0576_ _0592_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__o211a_1
XFILLER_69_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5063_ net243 net392 _0691_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nand4_1
XFILLER_57_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8822_ net104 _4318_ VGND VGND VPWR VPWR multiplier_inst.man_final\[10\] sky130_fd_sc_hd__nor2_1
X_8753_ multiplier_inst.is_inf_r multiplier_inst.man_final_r\[22\] net185 VGND VGND
+ VPWR VPWR _4271_ sky130_fd_sc_hd__and3b_1
XFILLER_80_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5965_ _1592_ _1593_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__xnor2_1
X_7704_ _3326_ _3327_ VGND VGND VPWR VPWR _3328_ sky130_fd_sc_hd__nand2b_1
X_8684_ _4039_ _4108_ _4041_ VGND VGND VPWR VPWR _4238_ sky130_fd_sc_hd__o21a_1
X_4916_ net227 net423 VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nand2_1
X_5896_ _1524_ _1525_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__nor2_1
X_7635_ _3264_ _3158_ net112 VGND VGND VPWR VPWR _3265_ sky130_fd_sc_hd__mux2_1
X_4847_ net366 net372 net284 adder_inst.man_b_r\[9\] VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and4_1
XFILLER_21_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9305_ clknet_leaf_1_clk net598 _0215_ VGND VGND VPWR VPWR adder_inst.man_a_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_7566_ _2952_ _3186_ _2951_ VGND VGND VPWR VPWR _3196_ sky130_fd_sc_hd__a21oi_1
X_4778_ net360 net267 net274 net354 VGND VGND VPWR VPWR _4549_ sky130_fd_sc_hd__a22o_1
X_6517_ _2067_ _2069_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__xnor2_1
X_7497_ _0457_ _3075_ _3073_ VGND VGND VPWR VPWR _3127_ sky130_fd_sc_hd__o21ai_1
X_9236_ clknet_leaf_0_clk net61 _0146_ VGND VGND VPWR VPWR adder_inst.i_b\[6\] sky130_fd_sc_hd__dfrtp_1
X_6448_ _2064_ _2065_ _2076_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__nand3_1
X_9167_ net528 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__inv_2
X_6379_ _1993_ _2007_ _2008_ _1921_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__a211oi_4
X_8118_ _3328_ _3689_ _3690_ VGND VGND VPWR VPWR _3692_ sky130_fd_sc_hd__and3_1
XFILLER_88_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9098_ net527 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__inv_2
X_8049_ adder_inst.is_zero_r _3493_ VGND VGND VPWR VPWR _3630_ sky130_fd_sc_hd__nor2_1
XFILLER_75_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5750_ _1377_ _1378_ _1376_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_45_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5681_ net393 net314 net321 net387 VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__a22oi_1
XFILLER_30_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4701_ _4471_ _4443_ VGND VGND VPWR VPWR _4472_ sky130_fd_sc_hd__and2b_1
X_7420_ _4518_ _4520_ _4517_ VGND VGND VPWR VPWR _3050_ sky130_fd_sc_hd__o21ba_1
X_4632_ net359 net248 net253 net353 VGND VGND VPWR VPWR _4403_ sky130_fd_sc_hd__a22oi_1
XFILLER_30_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4563_ adder_inst.exp_a_r\[3\] VGND VGND VPWR VPWR _4335_ sky130_fd_sc_hd__inv_2
X_7351_ _2977_ _2980_ _2953_ VGND VGND VPWR VPWR _2981_ sky130_fd_sc_hd__a21oi_1
X_7282_ _2840_ _2842_ _2841_ VGND VGND VPWR VPWR _2912_ sky130_fd_sc_hd__a21o_1
X_6302_ _1926_ _1930_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9021_ net513 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_77_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6233_ _1751_ _1753_ _1769_ _1770_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_90_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6164_ _1780_ _1792_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5115_ _0743_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__nor2_1
X_6095_ _1627_ _1723_ _1724_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__nand3_1
X_5046_ net379 net261 VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__nand2_1
XFILLER_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6997_ net271 net410 net415 net266 VGND VGND VPWR VPWR _2627_ sky130_fd_sc_hd__a22o_1
XFILLER_25_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8805_ _3173_ _3183_ VGND VGND VPWR VPWR _4310_ sky130_fd_sc_hd__nor2_1
X_8736_ net697 net187 net183 VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and3_1
X_5948_ net253 net431 net437 net245 VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__a22o_1
XFILLER_21_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8667_ _4057_ _4223_ VGND VGND VPWR VPWR adder_inst.sum_raw\[16\] sky130_fd_sc_hd__xor2_1
X_5879_ _1472_ _1473_ _1505_ _1506_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__o22ai_1
X_8598_ _3927_ _4149_ _4162_ VGND VGND VPWR VPWR _4163_ sky130_fd_sc_hd__o21a_1
X_7618_ _3130_ _3147_ VGND VGND VPWR VPWR _3248_ sky130_fd_sc_hd__xnor2_1
XFILLER_5_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7549_ _3019_ _3170_ _3018_ VGND VGND VPWR VPWR _3179_ sky130_fd_sc_hd__o21ba_1
X_9219_ clknet_leaf_5_clk net14 _0129_ VGND VGND VPWR VPWR adder_inst.i_a\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_108_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6920_ _2412_ _2482_ VGND VGND VPWR VPWR _2550_ sky130_fd_sc_hd__or2_1
XFILLER_82_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6851_ _2480_ _2413_ _2409_ VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand3b_2
X_5802_ _1415_ _1430_ _1431_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__and3_1
X_6782_ _2371_ _2410_ VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__xor2_1
X_8521_ _3976_ _3985_ _3984_ VGND VGND VPWR VPWR _4094_ sky130_fd_sc_hd__o21a_1
XFILLER_22_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5733_ _1357_ _1361_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__nand3_1
XFILLER_50_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8452_ _4020_ _4021_ _4022_ _4023_ VGND VGND VPWR VPWR _4025_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_79_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5664_ _1291_ _1292_ _1290_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__o21ai_1
X_8383_ _3954_ _3955_ VGND VGND VPWR VPWR _3956_ sky130_fd_sc_hd__nand2b_2
X_7403_ _0976_ _3032_ VGND VGND VPWR VPWR _3033_ sky130_fd_sc_hd__or2_1
X_5595_ net240 net453 VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__nand2_1
X_4615_ _4363_ _4365_ VGND VGND VPWR VPWR _4386_ sky130_fd_sc_hd__xnor2_1
X_7334_ _2957_ _2963_ _2956_ VGND VGND VPWR VPWR _2964_ sky130_fd_sc_hd__a21oi_1
Xmax_cap152 _0854_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_1
Xmax_cap174 _3435_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_2
X_7265_ _2819_ _2820_ _2832_ _2833_ VGND VGND VPWR VPWR _2895_ sky130_fd_sc_hd__a22o_1
X_9004_ net522 VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__inv_2
X_7196_ _2823_ _2824_ _2825_ VGND VGND VPWR VPWR _2826_ sky130_fd_sc_hd__nand3_1
X_6216_ _1755_ _1757_ _1756_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__o21ai_1
X_6147_ _1694_ _1695_ _1696_ _1273_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__a22o_1
XFILLER_38_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6078_ _1699_ _1701_ _1276_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__o21ai_1
X_5029_ _0623_ _0626_ _0656_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__a211oi_2
XFILLER_81_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8719_ _4087_ _4268_ VGND VGND VPWR VPWR adder_inst.sum_raw\[23\] sky130_fd_sc_hd__xor2_1
XFILLER_70_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5380_ _1004_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_74_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout209 adder_inst.man_b_r\[23\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_4
X_7050_ _2582_ _2678_ VGND VGND VPWR VPWR _2680_ sky130_fd_sc_hd__xnor2_1
XFILLER_113_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6001_ _1288_ _1629_ _1628_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__a21o_1
XFILLER_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7952_ net115 _3547_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and2_1
X_6903_ _2500_ _2506_ VGND VGND VPWR VPWR _2533_ sky130_fd_sc_hd__xor2_1
X_7883_ net495 _3487_ _3488_ _4342_ VGND VGND VPWR VPWR _3489_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_85_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6834_ _2422_ _2451_ _2456_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__a21o_1
XFILLER_23_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6765_ net300 net308 net473 net481 VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__and4_1
X_8504_ net216 net166 _3917_ _3981_ VGND VGND VPWR VPWR _4077_ sky130_fd_sc_hd__a22oi_2
X_9484_ clknet_leaf_20_clk net713 _0394_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
X_5716_ _1340_ _1344_ _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__and3_1
XFILLER_50_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6696_ _2323_ _2324_ _2325_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__or3_1
X_8435_ _4007_ VGND VGND VPWR VPWR _4008_ sky130_fd_sc_hd__inv_2
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5647_ _1272_ _1275_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__nor2_1
X_8366_ net149 _3865_ _3866_ VGND VGND VPWR VPWR _3939_ sky130_fd_sc_hd__and3_1
X_5578_ _1168_ _1174_ _1192_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__nand3_2
X_8297_ net140 _3764_ _3786_ net143 VGND VGND VPWR VPWR _3870_ sky130_fd_sc_hd__a211o_1
X_7317_ _2942_ _2944_ VGND VGND VPWR VPWR _2947_ sky130_fd_sc_hd__nand2_1
X_7248_ _2877_ _2876_ VGND VGND VPWR VPWR _2878_ sky130_fd_sc_hd__and2b_1
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7179_ _2807_ _2808_ VGND VGND VPWR VPWR _2809_ sky130_fd_sc_hd__and2b_1
XFILLER_58_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 i_a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_76_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4880_ net250 net255 net395 net400 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and4_1
XFILLER_32_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6550_ _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__inv_2
X_5501_ _1121_ _1125_ _1129_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__a211oi_4
XFILLER_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6481_ _2029_ _2035_ _2034_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__a21o_1
X_8220_ net175 _3680_ _3693_ _3699_ _3716_ VGND VGND VPWR VPWR _3793_ sky130_fd_sc_hd__a41o_1
X_5432_ _1042_ _1043_ _1060_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a21o_1
X_8151_ net342 net483 net161 VGND VGND VPWR VPWR _3725_ sky130_fd_sc_hd__mux2_1
X_5363_ _4557_ _0990_ _0989_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__a21o_1
XFILLER_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7102_ _2623_ _2630_ _2729_ _2731_ VGND VGND VPWR VPWR _2732_ sky130_fd_sc_hd__a211o_1
XFILLER_114_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8082_ adder_inst.exp_b_r\[3\] _4335_ _3653_ _3654_ _3655_ VGND VGND VPWR VPWR _3656_
+ sky130_fd_sc_hd__o221ai_4
X_5294_ net272 net403 net406 net266 VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a22o_1
XFILLER_101_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7033_ _2662_ _2661_ VGND VGND VPWR VPWR _2663_ sky130_fd_sc_hd__and2b_1
XFILLER_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8984_ net509 VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__inv_2
XFILLER_55_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7935_ adder_inst.sum_raw_r\[7\] net195 net176 adder_inst.sum_raw_r\[6\] net189 VGND
+ VGND VPWR VPWR _3533_ sky130_fd_sc_hd__o221a_1
XFILLER_70_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7866_ net493 _3414_ VGND VGND VPWR VPWR _3472_ sky130_fd_sc_hd__nor2_1
XFILLER_82_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6817_ _2415_ _2445_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__xnor2_2
XFILLER_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7797_ _3402_ _3400_ net502 VGND VGND VPWR VPWR _3403_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_21_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6748_ net451 net335 net341 net445 VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__a22oi_2
XFILLER_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9467_ clknet_leaf_13_clk _0086_ _0377_ VGND VGND VPWR VPWR mul_res\[22\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_98_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6679_ _2261_ _2308_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__nor2_1
X_9398_ clknet_leaf_6_clk net609 _0308_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
X_8418_ net124 _3790_ _3990_ net122 VGND VGND VPWR VPWR _3991_ sky130_fd_sc_hd__o211a_1
X_8349_ net446 _3342_ _3664_ VGND VGND VPWR VPWR _3922_ sky130_fd_sc_hd__and3_1
XFILLER_116_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout540 net549 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__clkbuf_4
XFILLER_116_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5981_ _1472_ net134 _1609_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__o211a_1
XFILLER_37_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7720_ adder_inst.exp_b_r\[7\] adder_inst.exp_a_r\[7\] VGND VGND VPWR VPWR _3343_
+ sky130_fd_sc_hd__and2b_1
XFILLER_52_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4932_ net259 net401 VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nand2_1
X_7651_ adder_inst.exp_b_r\[2\] adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR _3279_
+ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_82_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6602_ _2090_ _2166_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__xnor2_1
X_4863_ _0489_ _0490_ _0471_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a21o_1
XANTENNA_14 net303 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_25 net280 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7582_ _1146_ _3211_ VGND VGND VPWR VPWR _3212_ sky130_fd_sc_hd__xnor2_1
X_4794_ net231 net237 net386 net392 VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__and4_1
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9321_ clknet_leaf_11_clk _0033_ _0231_ VGND VGND VPWR VPWR adder_inst.is_inf_r sky130_fd_sc_hd__dfrtp_1
X_6533_ _2161_ _2162_ net280 net480 VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__and4bb_1
X_9252_ clknet_leaf_4_clk net47 _0162_ VGND VGND VPWR VPWR adder_inst.i_b\[22\] sky130_fd_sc_hd__dfrtp_1
X_6464_ _2088_ _2089_ _2092_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__nand3_1
XFILLER_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8203_ net121 _3775_ _3760_ _3730_ VGND VGND VPWR VPWR _3777_ sky130_fd_sc_hd__o2bb2a_1
X_5415_ _0689_ _0696_ _0695_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__a21bo_1
X_9183_ net548 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__inv_2
X_6395_ _2022_ _2023_ _2017_ _2020_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__a211o_1
XFILLER_114_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8134_ net154 _3707_ _3699_ _3680_ VGND VGND VPWR VPWR _3708_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_93_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5346_ _0873_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_7_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8065_ net487 adder_inst.exp_larger_r\[0\] _3387_ net192 net201 VGND VGND VPWR VPWR
+ _3644_ sky130_fd_sc_hd__a311o_1
XFILLER_102_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5277_ _0800_ _0901_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nand3_1
X_7016_ net247 net253 net429 net431 VGND VGND VPWR VPWR _2646_ sky130_fd_sc_hd__nand4_1
XFILLER_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8967_ net541 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__inv_2
XFILLER_83_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7918_ adder_inst.sum_raw_r\[5\] net488 _3462_ adder_inst.sum_raw_r\[4\] _3394_ VGND
+ VGND VPWR VPWR _3518_ sky130_fd_sc_hd__a221o_1
XFILLER_43_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8898_ net516 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__inv_2
X_7849_ net492 net197 _3453_ _3454_ VGND VGND VPWR VPWR _3455_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_102_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout392 adder_inst.man_a_r\[16\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkbuf_2
Xfanout381 net383 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__buf_2
Xfanout370 net373 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__buf_2
XFILLER_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_105_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput12 i_a[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
Xinput45 i_b[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput34 i_b[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput23 i_a[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput56 i_b[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput67 rst VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_2
X_6180_ _1808_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__and2_1
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5200_ _0571_ _0823_ _0822_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a21o_1
XFILLER_111_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5131_ _0743_ _0755_ _0759_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nand3_1
X_5062_ net379 net256 net385 net249 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a22o_1
XFILLER_69_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8821_ _3213_ _4317_ VGND VGND VPWR VPWR _4318_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8752_ net722 net186 net184 VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__and3_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7703_ adder_inst.exp_a_r\[6\] adder_inst.exp_b_r\[6\] VGND VGND VPWR VPWR _3327_
+ sky130_fd_sc_hd__nand2b_2
Xclkbuf_leaf_17_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_5964_ _1593_ _1592_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__and2b_1
X_8683_ _4041_ _4231_ _4039_ VGND VGND VPWR VPWR _4237_ sky130_fd_sc_hd__a21oi_1
X_4915_ _0543_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__and2b_1
X_5895_ net368 net315 net323 net362 VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__a22oi_1
XFILLER_33_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4846_ _0473_ _0474_ _0472_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__o21ai_1
X_7634_ net118 _3144_ _3148_ _3263_ VGND VGND VPWR VPWR _3264_ sky130_fd_sc_hd__o211a_1
XFILLER_20_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7565_ _4370_ net136 _3151_ _3187_ VGND VGND VPWR VPWR _3195_ sky130_fd_sc_hd__and4_1
X_9304_ clknet_leaf_3_clk net578 _0214_ VGND VGND VPWR VPWR adder_inst.man_a_r\[16\]
+ sky130_fd_sc_hd__dfrtp_4
X_6516_ _2131_ _2133_ _2132_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__o21ba_1
X_4777_ net365 net262 VGND VGND VPWR VPWR _4548_ sky130_fd_sc_hd__nand2_1
XFILLER_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7496_ _1158_ _3035_ _3125_ _0458_ VGND VGND VPWR VPWR _3126_ sky130_fd_sc_hd__a211o_1
X_9235_ clknet_leaf_0_clk net60 _0145_ VGND VGND VPWR VPWR adder_inst.i_b\[5\] sky130_fd_sc_hd__dfrtp_1
X_6447_ _2064_ _2065_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__and3_1
X_9166_ net530 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__inv_2
X_6378_ _1908_ _1909_ _1920_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__a21oi_2
XFILLER_102_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8117_ _3689_ _3690_ _3328_ VGND VGND VPWR VPWR _3691_ sky130_fd_sc_hd__a21oi_1
XFILLER_88_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5329_ _0917_ _0955_ _0956_ _0957_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__nand4_1
X_9097_ net540 VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__inv_2
XFILLER_102_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8048_ _3628_ _3629_ net204 VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__o21a_1
XFILLER_71_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5680_ net387 net393 net314 net321 VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__and4_1
X_4700_ _4454_ _4470_ VGND VGND VPWR VPWR _4471_ sky130_fd_sc_hd__xnor2_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4631_ net353 net359 net248 net253 VGND VGND VPWR VPWR _4402_ sky130_fd_sc_hd__and4_1
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4562_ net452 VGND VGND VPWR VPWR _4334_ sky130_fd_sc_hd__inv_2
X_7350_ _2979_ _2978_ VGND VGND VPWR VPWR _2980_ sky130_fd_sc_hd__nand2b_1
X_7281_ _2896_ _2909_ VGND VGND VPWR VPWR _2911_ sky130_fd_sc_hd__xor2_1
X_6301_ _1930_ _1926_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__and2b_1
Xclkbuf_leaf_6_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_77_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9020_ net510 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__inv_2
X_6232_ _1844_ _1845_ _1860_ _1861_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__nor4_4
XTAP_TAPCELL_ROW_90_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6163_ _1780_ _1792_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__or2_1
XFILLER_111_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5114_ _0685_ _0687_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__xnor2_1
X_6094_ _1624_ _1626_ _1625_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__o21ai_1
X_5045_ _0671_ _0672_ _0673_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6996_ net266 net271 net410 net415 VGND VGND VPWR VPWR _2626_ sky130_fd_sc_hd__and4_1
X_8804_ _3173_ _4309_ VGND VGND VPWR VPWR multiplier_inst.man_final\[1\] sky130_fd_sc_hd__and2_1
X_8735_ net658 net187 net183 VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__and3_1
XFILLER_53_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5947_ net247 net253 net431 net437 VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__nand4_1
X_8666_ _4217_ _4222_ net193 VGND VGND VPWR VPWR _4223_ sky130_fd_sc_hd__mux2_1
X_5878_ _1472_ _1473_ _1505_ _1506_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__or4_1
X_7617_ _3119_ _3246_ VGND VGND VPWR VPWR _3247_ sky130_fd_sc_hd__xnor2_1
X_8597_ _3909_ _3925_ _3910_ VGND VGND VPWR VPWR _4162_ sky130_fd_sc_hd__a21oi_1
X_4829_ net355 net302 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__and2_1
XFILLER_107_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7548_ _3153_ _3177_ VGND VGND VPWR VPWR _3178_ sky130_fd_sc_hd__nor2_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7479_ _3108_ _3081_ VGND VGND VPWR VPWR _3109_ sky130_fd_sc_hd__and2b_1
XFILLER_108_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9218_ clknet_leaf_4_clk net13 _0128_ VGND VGND VPWR VPWR adder_inst.i_a\[20\] sky130_fd_sc_hd__dfrtp_1
X_9149_ net534 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__inv_2
XFILLER_68_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_113_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6850_ _2447_ _2479_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__nand2_1
XFILLER_81_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6781_ _2371_ _2410_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5801_ _1423_ _1424_ _1429_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__a21o_1
X_8520_ adder_inst.sum_raw\[0\] _3928_ _4090_ _4092_ VGND VGND VPWR VPWR _4093_ sky130_fd_sc_hd__or4b_1
X_5732_ _1359_ _1360_ _1358_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__a21o_1
X_8451_ _4020_ _4021_ _4022_ _4023_ VGND VGND VPWR VPWR _4024_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_79_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5663_ _1290_ _1291_ _1292_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__or3_1
X_8382_ _3951_ _3953_ VGND VGND VPWR VPWR _3955_ sky130_fd_sc_hd__nand2_1
X_7402_ _0873_ _0975_ VGND VGND VPWR VPWR _3032_ sky130_fd_sc_hd__and2_1
X_5594_ _1186_ _1188_ _1187_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__o21bai_1
X_4614_ _4383_ _4384_ VGND VGND VPWR VPWR _4385_ sky130_fd_sc_hd__and2_1
XFILLER_116_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7333_ _2958_ _2962_ VGND VGND VPWR VPWR _2963_ sky130_fd_sc_hd__xor2_1
XFILLER_116_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap120 _4536_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
X_9003_ net522 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__inv_2
XFILLER_104_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7264_ _2871_ _2893_ VGND VGND VPWR VPWR _2894_ sky130_fd_sc_hd__nand2_1
X_7195_ _0923_ _0925_ VGND VGND VPWR VPWR _2825_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6215_ _1749_ _1843_ _1842_ _1829_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a211oi_4
XFILLER_85_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6146_ _1675_ _1773_ _1772_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__o21a_1
XFILLER_112_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6077_ net135 _1705_ _1704_ _1678_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__o211ai_2
XFILLER_45_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5028_ _0639_ _0641_ _0655_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__o21a_1
XFILLER_72_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6979_ _2606_ _2607_ _2602_ VGND VGND VPWR VPWR _2609_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8718_ _4265_ _4266_ _4267_ _4264_ VGND VGND VPWR VPWR _4268_ sky130_fd_sc_hd__a31o_1
XFILLER_70_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8649_ _3962_ _3963_ VGND VGND VPWR VPWR _4207_ sky130_fd_sc_hd__nand2b_1
XFILLER_107_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6000_ _1288_ _1628_ _1629_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7951_ net484 adder_inst.sum_raw_r\[11\] adder_inst.sum_raw_r\[10\] net178 _3546_
+ VGND VGND VPWR VPWR _3547_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_19_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6902_ _2508_ _2531_ VGND VGND VPWR VPWR _2532_ sky130_fd_sc_hd__nand2b_1
X_7882_ net493 _3483_ VGND VGND VPWR VPWR _3488_ sky130_fd_sc_hd__nand2_1
XFILLER_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6833_ _2460_ _2461_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_85_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6764_ _2391_ _2392_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__xor2_1
X_8503_ _4075_ VGND VGND VPWR VPWR _4076_ sky130_fd_sc_hd__inv_2
X_6695_ net445 net335 net341 net440 VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__a22oi_2
X_9483_ clknet_leaf_19_clk net690 _0393_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
X_5715_ _1342_ _1343_ _1341_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__a21bo_1
X_8434_ _4004_ _4005_ VGND VGND VPWR VPWR _4007_ sky130_fd_sc_hd__or2_1
X_5646_ _1272_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_28_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8365_ net124 _3937_ VGND VGND VPWR VPWR _3938_ sky130_fd_sc_hd__nor2_1
X_5577_ _1201_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__and2_1
X_8296_ net149 _3864_ _3867_ net124 VGND VGND VPWR VPWR _3869_ sky130_fd_sc_hd__a211o_1
X_7316_ _2938_ _2945_ _2937_ VGND VGND VPWR VPWR _2946_ sky130_fd_sc_hd__a21oi_2
XFILLER_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7247_ _0947_ _0949_ _0946_ VGND VGND VPWR VPWR _2877_ sky130_fd_sc_hd__o21ba_1
XFILLER_77_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7178_ _2587_ _2692_ _2806_ VGND VGND VPWR VPWR _2808_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_37_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6129_ _1756_ _1757_ _1755_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__o21bai_1
XFILLER_105_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_55_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5500_ _1106_ _1117_ _1119_ _1128_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__o211a_1
X_6480_ _2103_ _2104_ _2109_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__nor3b_2
XFILLER_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5431_ _1042_ _1043_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand3_1
XFILLER_114_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8150_ net139 _3723_ VGND VGND VPWR VPWR _3724_ sky130_fd_sc_hd__nor2_1
X_5362_ _0691_ _0693_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__nand2_1
XFILLER_113_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8081_ adder_inst.exp_b_r\[3\] _4335_ _3277_ VGND VGND VPWR VPWR _3655_ sky130_fd_sc_hd__a21o_1
XFILLER_99_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7101_ _2727_ _2728_ _2713_ VGND VGND VPWR VPWR _2731_ sky130_fd_sc_hd__a21oi_1
XFILLER_114_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7032_ _1588_ _1590_ _1589_ VGND VGND VPWR VPWR _2662_ sky130_fd_sc_hd__o21ba_1
X_5293_ net263 net413 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nand2_1
XFILLER_101_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8983_ net513 VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__inv_2
X_7934_ adder_inst.sum_raw_r\[4\] net496 _3530_ _3531_ _3473_ VGND VGND VPWR VPWR
+ _3532_ sky130_fd_sc_hd__a221o_1
XFILLER_42_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7865_ _3445_ _3470_ net491 VGND VGND VPWR VPWR _3471_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6816_ _2415_ _2445_ VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__and2b_1
X_7796_ net201 _3401_ VGND VGND VPWR VPWR _3402_ sky130_fd_sc_hd__or2_1
XFILLER_50_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6747_ net330 net457 VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__nand2_1
XFILLER_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9466_ clknet_leaf_15_clk _0085_ _0376_ VGND VGND VPWR VPWR mul_res\[21\] sky130_fd_sc_hd__dfrtp_1
X_6678_ _2305_ _2307_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__nor2_1
XFILLER_109_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9397_ clknet_leaf_6_clk net608 _0307_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
X_8417_ _3677_ _3811_ _3816_ VGND VGND VPWR VPWR _3990_ sky130_fd_sc_hd__or3_1
X_5629_ net240 net465 _1217_ _1218_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_105_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8348_ _3920_ VGND VGND VPWR VPWR _3921_ sky130_fd_sc_hd__inv_2
X_8279_ _3851_ VGND VGND VPWR VPWR _3852_ sky130_fd_sc_hd__inv_2
XFILLER_116_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout541 net542 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__buf_4
Xfanout530 net536 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__buf_2
XFILLER_116_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_107_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5980_ _1571_ _1572_ _1608_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a21o_1
XFILLER_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4931_ net388 net269 net393 net273 VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and4_1
X_7650_ adder_inst.exp_a_r\[2\] adder_inst.exp_b_r\[2\] VGND VGND VPWR VPWR _3278_
+ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_82_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4862_ _0471_ _0489_ _0490_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand3_1
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6601_ _2217_ _2223_ _2216_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__a21o_1
X_9320_ clknet_leaf_6_clk net610 _0230_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_15 net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7581_ _1151_ _3208_ _1149_ VGND VGND VPWR VPWR _3211_ sky130_fd_sc_hd__o21ba_1
X_4793_ _4430_ _4432_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xnor2_1
XANTENNA_26 net423 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6532_ net291 net470 net475 net284 VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__a22oi_1
X_9251_ clknet_leaf_4_clk net46 _0161_ VGND VGND VPWR VPWR adder_inst.i_b\[21\] sky130_fd_sc_hd__dfrtp_1
X_6463_ _2089_ _2092_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__nand2_1
Xoutput100 net100 VGND VGND VPWR VPWR o_res_vld sky130_fd_sc_hd__buf_2
XFILLER_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8202_ net124 _3775_ VGND VGND VPWR VPWR _3776_ sky130_fd_sc_hd__and2_1
X_9182_ net548 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__inv_2
X_5414_ _0991_ _0993_ _0992_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a21o_1
X_8133_ _3705_ _3706_ VGND VGND VPWR VPWR _3707_ sky130_fd_sc_hd__xnor2_1
X_6394_ _2017_ _2020_ _2022_ _2023_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_93_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5345_ _0971_ _0973_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nor2_1
X_8064_ adder_inst.is_zero_r net174 VGND VGND VPWR VPWR _3643_ sky130_fd_sc_hd__nor2_1
XFILLER_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5276_ _0903_ _0904_ _0902_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o21bai_1
X_7015_ net241 net437 VGND VGND VPWR VPWR _2645_ sky130_fd_sc_hd__nand2_1
XFILLER_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8966_ net541 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__inv_2
XFILLER_55_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7917_ adder_inst.sum_raw_r\[2\] net199 _3472_ _3516_ VGND VGND VPWR VPWR _3517_
+ sky130_fd_sc_hd__o211a_1
XFILLER_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8897_ net516 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
XFILLER_62_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7848_ _3388_ _3395_ VGND VGND VPWR VPWR _3454_ sky130_fd_sc_hd__nor2_1
XFILLER_51_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_102_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7779_ net202 adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _3385_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_62_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9449_ clknet_leaf_20_clk _0098_ _0359_ VGND VGND VPWR VPWR mul_res\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout371 net373 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout360 net361 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout382 net383 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout393 net394 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__buf_2
XFILLER_86_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 i_a[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
XFILLER_30_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput24 i_a[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput46 i_b[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput35 i_b[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput57 i_b[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_116_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5130_ _0743_ _0755_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__and3_1
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5061_ net379 net249 net256 net385 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nand4_1
XFILLER_96_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8820_ _3210_ _4315_ VGND VGND VPWR VPWR multiplier_inst.man_final\[9\] sky130_fd_sc_hd__xnor2_1
XFILLER_92_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8751_ multiplier_inst.man_final_r\[20\] net186 net184 VGND VGND VPWR VPWR _0084_
+ sky130_fd_sc_hd__and3_1
X_5963_ _1488_ _1490_ _1489_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__o21ba_1
XFILLER_25_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7702_ adder_inst.exp_b_r\[6\] adder_inst.exp_a_r\[6\] VGND VGND VPWR VPWR _3326_
+ sky130_fd_sc_hd__and2b_2
X_4914_ net239 net411 net417 net233 VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a22o_1
X_8682_ _4042_ _4236_ VGND VGND VPWR VPWR adder_inst.sum_raw\[18\] sky130_fd_sc_hd__xnor2_1
XFILLER_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5894_ net362 net368 net315 net323 VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__and4_1
XFILLER_33_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4845_ _0472_ _0473_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__or3_1
XFILLER_20_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7633_ _3140_ net118 _3147_ _3130_ _3144_ VGND VGND VPWR VPWR _3263_ sky130_fd_sc_hd__o221ai_1
XFILLER_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4776_ net354 net360 net267 net274 VGND VGND VPWR VPWR _4547_ sky130_fd_sc_hd__and4_1
X_7564_ _3185_ _3193_ VGND VGND VPWR VPWR _3194_ sky130_fd_sc_hd__and2b_1
X_9303_ clknet_leaf_3_clk net584 _0213_ VGND VGND VPWR VPWR adder_inst.man_a_r\[15\]
+ sky130_fd_sc_hd__dfrtp_4
X_6515_ _2141_ _2144_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__nor2_1
X_7495_ _3076_ _3124_ VGND VGND VPWR VPWR _3125_ sky130_fd_sc_hd__nand2_1
X_9234_ clknet_leaf_0_clk net59 _0144_ VGND VGND VPWR VPWR adder_inst.i_b\[4\] sky130_fd_sc_hd__dfrtp_1
X_6446_ _2070_ _2074_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__xor2_1
XFILLER_88_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6377_ _1993_ _1994_ _2005_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__nand3_2
X_9165_ net530 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__inv_2
X_9096_ net549 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__inv_2
X_8116_ _3341_ _3663_ _3688_ VGND VGND VPWR VPWR _3690_ sky130_fd_sc_hd__or3_1
XFILLER_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5328_ _0917_ _0955_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__and4_1
X_8047_ adder_inst.is_zero_r _3481_ VGND VGND VPWR VPWR _3629_ sky130_fd_sc_hd__nor2_1
XFILLER_75_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5259_ _0885_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nand2b_1
XFILLER_68_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8949_ net541 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__inv_2
XFILLER_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout190 net192 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4630_ net352 net247 VGND VGND VPWR VPWR _4401_ sky130_fd_sc_hd__nand2_1
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4561_ net292 VGND VGND VPWR VPWR _4333_ sky130_fd_sc_hd__inv_2
X_6300_ _1927_ _1929_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__nor2_1
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7280_ _2896_ _2909_ VGND VGND VPWR VPWR _2910_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_77_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6231_ _1858_ _1859_ _1852_ _1855_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_90_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6162_ _1789_ _1791_ _1788_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5113_ _0459_ _0602_ _0626_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__or4bb_2
XFILLER_97_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6093_ _1720_ _1721_ _1719_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__o21bai_1
X_5044_ _0671_ _0672_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__and3_1
XFILLER_93_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8803_ _3163_ _3169_ _3172_ VGND VGND VPWR VPWR _4309_ sky130_fd_sc_hd__o21ai_1
XFILLER_53_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6995_ net263 net420 VGND VGND VPWR VPWR _2625_ sky130_fd_sc_hd__nand2_1
XFILLER_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5946_ net240 net442 VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__nand2_1
X_8734_ net704 net187 net183 VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__and3_1
X_8665_ _4220_ _4221_ VGND VGND VPWR VPWR _4222_ sky130_fd_sc_hd__nand2_1
X_5877_ _1472_ _1473_ _1505_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__nor4_1
X_7616_ _3123_ _3245_ _3121_ VGND VGND VPWR VPWR _3246_ sky130_fd_sc_hd__o21ba_1
X_4828_ _4542_ _0456_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__xnor2_1
X_8596_ _4159_ _4160_ net180 VGND VGND VPWR VPWR _4161_ sky130_fd_sc_hd__a21oi_1
X_4759_ _4524_ _4529_ VGND VGND VPWR VPWR _4530_ sky130_fd_sc_hd__xnor2_1
X_7547_ _3176_ VGND VGND VPWR VPWR _3177_ sky130_fd_sc_hd__inv_2
X_7478_ _3106_ _3107_ VGND VGND VPWR VPWR _3108_ sky130_fd_sc_hd__or2_1
XFILLER_104_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9217_ clknet_leaf_4_clk net11 _0127_ VGND VGND VPWR VPWR adder_inst.i_a\[19\] sky130_fd_sc_hd__dfrtp_1
X_6429_ _2057_ _2058_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__nor2_1
XFILLER_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9148_ net535 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__inv_2
XFILLER_68_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9079_ net537 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__inv_2
XFILLER_102_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6780_ _2407_ _2409_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__nand2_1
X_5800_ _1423_ _1424_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__nand3_1
X_5731_ _1358_ _1359_ _1360_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__nand3_1
X_8450_ net476 net162 VGND VGND VPWR VPWR _4023_ sky130_fd_sc_hd__or2_1
X_5662_ net381 net332 net338 net374 VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a22oi_2
X_8381_ _3951_ _3953_ VGND VGND VPWR VPWR _3954_ sky130_fd_sc_hd__nor2_1
X_7401_ _0870_ _0871_ VGND VGND VPWR VPWR _3031_ sky130_fd_sc_hd__nand2_1
X_5593_ net240 net459 _1214_ _1212_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__a31o_1
X_4613_ _4376_ _4380_ _4382_ VGND VGND VPWR VPWR _4384_ sky130_fd_sc_hd__or3_1
XFILLER_116_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7332_ _2960_ _2961_ VGND VGND VPWR VPWR _2962_ sky130_fd_sc_hd__nand2_1
Xmax_cap132 net133 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_1
X_7263_ _2835_ _2836_ _2869_ _2870_ VGND VGND VPWR VPWR _2893_ sky130_fd_sc_hd__a22o_1
XFILLER_116_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9002_ net523 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__inv_2
X_6214_ _1829_ _1842_ _1843_ _1749_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__o211a_4
X_7194_ _0905_ _2821_ _2822_ VGND VGND VPWR VPWR _2824_ sky130_fd_sc_hd__a21o_1
X_6145_ _1675_ _1772_ _1773_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__or3_1
X_6076_ _1678_ _1704_ _1705_ net135 VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__a211o_1
X_5027_ _0639_ _0641_ _0655_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__or3_1
XFILLER_57_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8717_ _4081_ _4115_ _4112_ net182 VGND VGND VPWR VPWR _4267_ sky130_fd_sc_hd__o211a_1
XFILLER_80_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6978_ _2602_ _2606_ _2607_ VGND VGND VPWR VPWR _2608_ sky130_fd_sc_hd__and3_1
X_5929_ net272 net415 net420 net266 VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__a22o_1
XFILLER_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8648_ _4204_ _3966_ VGND VGND VPWR VPWR _4206_ sky130_fd_sc_hd__nand2b_1
X_8579_ _3877_ _3876_ VGND VGND VPWR VPWR _4146_ sky130_fd_sc_hd__nand2b_1
XFILLER_21_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7950_ adder_inst.sum_raw_r\[7\] _3504_ _3544_ _3545_ VGND VGND VPWR VPWR _3546_
+ sky130_fd_sc_hd__o211a_1
XFILLER_54_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6901_ _2490_ _2507_ VGND VGND VPWR VPWR _2531_ sky130_fd_sc_hd__nand2_1
X_7881_ net202 _3486_ net199 VGND VGND VPWR VPWR _3487_ sky130_fd_sc_hd__mux2_1
X_6832_ net312 net481 _2460_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__and3_1
XFILLER_35_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6763_ _2391_ _2392_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__and2_1
X_6694_ net450 net330 VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__nand2_1
X_8502_ _4067_ _4074_ VGND VGND VPWR VPWR _4075_ sky130_fd_sc_hd__or2_2
X_9482_ clknet_leaf_20_clk net673 _0392_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
X_5714_ _1341_ _1342_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__nand3b_1
X_8433_ _4005_ VGND VGND VPWR VPWR _4006_ sky130_fd_sc_hd__inv_2
X_5645_ _1245_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__nor2_1
XFILLER_108_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8364_ _3864_ _3871_ net149 VGND VGND VPWR VPWR _3937_ sky130_fd_sc_hd__mux2_1
X_5576_ _1202_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8295_ net149 _3864_ _3867_ VGND VGND VPWR VPWR _3868_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7315_ _2939_ _2943_ VGND VGND VPWR VPWR _2945_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7246_ _2874_ _2875_ VGND VGND VPWR VPWR _2876_ sky130_fd_sc_hd__xor2_1
XFILLER_104_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7177_ _2587_ _2692_ _2806_ VGND VGND VPWR VPWR _2807_ sky130_fd_sc_hd__o21a_1
XFILLER_112_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6128_ _1755_ _1756_ _1757_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__or3_1
XFILLER_105_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6059_ net254 net466 net471 net246 VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__a22o_1
XFILLER_45_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5430_ _1046_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__nand2b_1
XFILLER_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5361_ _4557_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__nand3_1
XFILLER_113_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8080_ _3273_ _3279_ VGND VGND VPWR VPWR _3654_ sky130_fd_sc_hd__or2_1
XFILLER_99_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7100_ _2713_ _2727_ _2728_ VGND VGND VPWR VPWR _2730_ sky130_fd_sc_hd__nand3_1
X_5292_ net266 net272 net403 net406 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__and4_1
XFILLER_114_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7031_ _2657_ _2660_ VGND VGND VPWR VPWR _2661_ sky130_fd_sc_hd__xnor2_1
XFILLER_67_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8982_ net516 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__inv_2
XFILLER_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7933_ adder_inst.sum_raw_r\[3\] _4341_ net177 adder_inst.sum_raw_r\[2\] net198 VGND
+ VGND VPWR VPWR _3531_ sky130_fd_sc_hd__o221a_1
XFILLER_55_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7864_ net498 net494 VGND VGND VPWR VPWR _3470_ sky130_fd_sc_hd__nor2_1
X_6815_ _2442_ _2444_ VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__nand2_1
X_7795_ net203 adder_inst.exp_larger_r\[1\] net202 adder_inst.exp_larger_r\[3\] VGND
+ VGND VPWR VPWR _3401_ sky130_fd_sc_hd__a31o_1
X_6746_ net445 net450 net335 net341 VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__and4_1
XFILLER_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9465_ clknet_leaf_15_clk _0084_ _0375_ VGND VGND VPWR VPWR mul_res\[20\] sky130_fd_sc_hd__dfrtp_1
X_6677_ _2298_ _2304_ _2306_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__and3_1
X_9396_ clknet_leaf_6_clk net600 _0306_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_8416_ _3988_ VGND VGND VPWR VPWR _3989_ sky130_fd_sc_hd__inv_2
X_5628_ _1255_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nor2_1
X_8347_ net309 _3919_ net168 VGND VGND VPWR VPWR _3920_ sky130_fd_sc_hd__mux2_2
X_5559_ _1187_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__nor2_1
X_8278_ net162 _3848_ _3850_ VGND VGND VPWR VPWR _3851_ sky130_fd_sc_hd__a21oi_4
XFILLER_78_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout520 net521 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__clkbuf_4
Xfanout542 net548 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__buf_4
Xfanout531 net532 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__buf_4
X_7229_ net207 net454 _2856_ _2858_ VGND VGND VPWR VPWR _2859_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_58_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4930_ _0526_ _0532_ _0531_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21o_1
XFILLER_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4861_ _0471_ _0489_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and3_1
XFILLER_33_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6600_ _2229_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__inv_2
XANTENNA_27 net476 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_16 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7580_ _3206_ _3209_ net112 VGND VGND VPWR VPWR _3210_ sky130_fd_sc_hd__mux2_1
X_4792_ _4420_ _4546_ _0420_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6531_ net284 net291 net470 net475 VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__and4_1
X_9250_ clknet_leaf_4_clk net45 _0160_ VGND VGND VPWR VPWR adder_inst.i_b\[20\] sky130_fd_sc_hd__dfrtp_1
X_6462_ _2091_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__inv_2
Xoutput101 net101 VGND VGND VPWR VPWR overflow sky130_fd_sc_hd__buf_2
X_8201_ _3767_ _3774_ net129 VGND VGND VPWR VPWR _3775_ sky130_fd_sc_hd__mux2_1
X_9181_ net535 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__inv_2
X_6393_ _2002_ _2004_ _2021_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__nand3_1
X_5413_ _1012_ _1041_ _1040_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a21o_1
X_8132_ _4351_ _4355_ VGND VGND VPWR VPWR _3706_ sky130_fd_sc_hd__xnor2_1
X_5344_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_93_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8063_ _3638_ _3639_ _3641_ VGND VGND VPWR VPWR _3642_ sky130_fd_sc_hd__a21oi_1
XFILLER_101_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5275_ _0902_ _0903_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__or3_1
XFILLER_102_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7014_ net263 net425 _1559_ _1558_ VGND VGND VPWR VPWR _2644_ sky130_fd_sc_hd__a31o_1
XFILLER_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8965_ net532 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__inv_2
XFILLER_55_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7916_ adder_inst.sum_raw_r\[1\] net500 _3445_ adder_inst.sum_raw_r\[0\] net498 VGND
+ VGND VPWR VPWR _3516_ sky130_fd_sc_hd__a221o_1
X_8896_ net510 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__inv_2
XFILLER_15_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7847_ adder_inst.exp_larger_r\[2\] _3388_ adder_inst.exp_larger_r\[3\] VGND VGND
+ VPWR VPWR _3453_ sky130_fd_sc_hd__o21a_1
XFILLER_23_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7778_ adder_inst.sum_raw_r\[1\] net485 net179 adder_inst.sum_raw_r\[0\] VGND VGND
+ VPWR VPWR _3384_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_62_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6729_ _2293_ _2320_ _2337_ _2351_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__o211ai_2
X_9448_ clknet_leaf_20_clk _0097_ _0358_ VGND VGND VPWR VPWR mul_res\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_109_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9379_ clknet_leaf_12_clk _0053_ _0289_ VGND VGND VPWR VPWR add_res\[25\] sky130_fd_sc_hd__dfrtp_1
XFILLER_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout350 net351 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_2
Xfanout372 net373 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkbuf_4
Xfanout361 adder_inst.man_a_r\[21\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_4
Xfanout383 net386 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout394 net395 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_4
XFILLER_15_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput25 i_a[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput14 i_a[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput36 i_b[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput58 i_b[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput47 i_b[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5060_ net379 net261 _0678_ _0677_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a31o_1
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8750_ net723 net186 net184 VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__and3_1
X_5962_ _1588_ _1591_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7701_ _3319_ _3325_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[4\] sky130_fd_sc_hd__and2b_1
X_4913_ net233 net239 net411 net417 VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__and4_1
X_8681_ net194 _4234_ _4235_ _4233_ VGND VGND VPWR VPWR _4236_ sky130_fd_sc_hd__a31o_1
X_5893_ net375 net310 VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__nand2_1
X_4844_ net366 net286 net292 net361 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a22oi_2
X_7632_ _3244_ _3261_ VGND VGND VPWR VPWR _3262_ sky130_fd_sc_hd__and2_1
XFILLER_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4775_ _4414_ _4419_ _4418_ VGND VGND VPWR VPWR _4546_ sky130_fd_sc_hd__a21o_1
X_7563_ net109 _3176_ _3189_ _3190_ VGND VGND VPWR VPWR _3193_ sky130_fd_sc_hd__o211a_1
X_6514_ net295 net461 _2142_ _2143_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__and4_1
X_9302_ clknet_leaf_1_clk net596 _0212_ VGND VGND VPWR VPWR adder_inst.man_a_r\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_9233_ clknet_leaf_6_clk net58 _0143_ VGND VGND VPWR VPWR adder_inst.i_b\[3\] sky130_fd_sc_hd__dfrtp_1
X_7494_ _3119_ _3123_ VGND VGND VPWR VPWR _3124_ sky130_fd_sc_hd__nor2_1
X_6445_ _2070_ _2074_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__nand2_1
X_6376_ _1993_ _1994_ _2005_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__and3_1
X_9164_ net530 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__inv_2
XFILLER_114_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8115_ _3341_ _3663_ _3662_ _3661_ VGND VGND VPWR VPWR _3689_ sky130_fd_sc_hd__o211ai_1
X_9095_ net540 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__inv_2
XFILLER_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5327_ _0810_ _0876_ _0896_ _0916_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__o211ai_2
X_8046_ _3627_ _3628_ net204 VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__o21a_1
X_5258_ _0885_ _0886_ _0887_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__or3_1
XFILLER_68_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5189_ net259 net405 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nand2_1
XFILLER_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8948_ net546 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_104_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8879_ add_res\[31\] net663 net506 VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__mux2_1
XFILLER_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout191 net192 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_2
Xfanout180 net182 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
XFILLER_19_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4560_ adder_inst.exp_b_r\[0\] VGND VGND VPWR VPWR _4332_ sky130_fd_sc_hd__inv_2
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6230_ _1852_ _1855_ _1858_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__a211oi_2
X_6161_ _1785_ _1787_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_90_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5112_ _0623_ _0624_ _0625_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a21o_1
XFILLER_111_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6092_ _1719_ _1720_ _1721_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__or3_1
XFILLER_97_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5043_ _0608_ _0611_ _0610_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a21bo_1
XFILLER_69_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8802_ _3169_ _4308_ _3163_ VGND VGND VPWR VPWR multiplier_inst.man_final\[0\] sky130_fd_sc_hd__mux2_1
X_6994_ _2620_ _2621_ _2622_ VGND VGND VPWR VPWR _2624_ sky130_fd_sc_hd__a21o_1
XFILLER_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8733_ net671 net187 net183 VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__and3_1
X_5945_ net258 net431 _1461_ _1460_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__a31o_1
X_8664_ _3977_ _3987_ _4190_ _4203_ _4219_ VGND VGND VPWR VPWR _4221_ sky130_fd_sc_hd__a311o_1
X_5876_ _1503_ _1504_ _1235_ _1251_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__o211a_1
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7615_ _3036_ _3076_ _3127_ VGND VGND VPWR VPWR _3245_ sky130_fd_sc_hd__a21oi_1
X_4827_ _4542_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__nand2_1
X_8595_ _4153_ _4154_ _3911_ VGND VGND VPWR VPWR _4160_ sky130_fd_sc_hd__a21o_1
XFILLER_21_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4758_ _4527_ _4528_ VGND VGND VPWR VPWR _4529_ sky130_fd_sc_hd__xnor2_1
X_7546_ _3004_ _3174_ VGND VGND VPWR VPWR _3176_ sky130_fd_sc_hd__xnor2_2
X_7477_ _3101_ _3105_ VGND VGND VPWR VPWR _3107_ sky130_fd_sc_hd__and2_1
X_4689_ _4458_ _4459_ VGND VGND VPWR VPWR _4460_ sky130_fd_sc_hd__nor2_1
X_9216_ clknet_leaf_8_clk net10 _0126_ VGND VGND VPWR VPWR adder_inst.i_a\[18\] sky130_fd_sc_hd__dfrtp_1
X_6428_ net433 net318 net325 net426 VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__a22oi_1
X_9147_ net534 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__inv_2
X_6359_ _1985_ _1988_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__xnor2_1
X_9078_ net543 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_110_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8029_ net197 _3398_ _3612_ _3613_ VGND VGND VPWR VPWR _3614_ sky130_fd_sc_hd__a31o_1
XFILLER_84_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5730_ net362 net333 net339 net356 VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__a22o_1
XFILLER_30_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5661_ net374 net381 net332 net338 VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__and4_1
X_7400_ _3027_ _2568_ _2573_ VGND VGND VPWR VPWR _3030_ sky130_fd_sc_hd__nand3b_4
X_8380_ net164 _3950_ _3952_ VGND VGND VPWR VPWR _3953_ sky130_fd_sc_hd__a21oi_1
X_5592_ _1220_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__nand2_1
X_4612_ _4376_ _4380_ _4382_ VGND VGND VPWR VPWR _4383_ sky130_fd_sc_hd__o21ai_1
X_7331_ _2929_ _2959_ _2730_ _2732_ VGND VGND VPWR VPWR _2961_ sky130_fd_sc_hd__o211ai_1
XFILLER_116_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7262_ _2880_ _2891_ VGND VGND VPWR VPWR _2892_ sky130_fd_sc_hd__or2_1
XFILLER_116_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9001_ net522 VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__inv_2
Xmax_cap155 _3693_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_2
X_6213_ _1735_ _1736_ _1748_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__a21o_1
X_7193_ _0905_ _2821_ _2822_ VGND VGND VPWR VPWR _2823_ sky130_fd_sc_hd__nand3_1
X_6144_ _1675_ _1772_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__nor3_1
XFILLER_58_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6075_ _1411_ _1412_ _1413_ _1281_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__o22a_1
XFILLER_85_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5026_ _0639_ _0641_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__nor3_1
XFILLER_65_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6977_ _2604_ _2605_ _2603_ VGND VGND VPWR VPWR _2607_ sky130_fd_sc_hd__a21bo_1
XFILLER_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8716_ _4080_ net107 _4110_ VGND VGND VPWR VPWR _4266_ sky130_fd_sc_hd__or3b_1
XFILLER_81_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5928_ net266 net271 net415 net420 VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__and4_1
X_8647_ _3966_ _4205_ VGND VGND VPWR VPWR adder_inst.sum_raw\[14\] sky130_fd_sc_hd__xnor2_1
X_5859_ net228 net234 net454 net464 VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__and4_1
X_8578_ _3880_ _4145_ VGND VGND VPWR VPWR adder_inst.sum_raw\[5\] sky130_fd_sc_hd__xor2_1
X_7529_ net112 _3158_ VGND VGND VPWR VPWR _3159_ sky130_fd_sc_hd__or2_1
XFILLER_5_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6900_ _2529_ VGND VGND VPWR VPWR _2530_ sky130_fd_sc_hd__inv_2
X_7880_ _3431_ _3483_ _3485_ net500 _3484_ VGND VGND VPWR VPWR _3486_ sky130_fd_sc_hd__a221o_1
XFILLER_94_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6831_ net312 net481 VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8501_ _4071_ _4073_ VGND VGND VPWR VPWR _4074_ sky130_fd_sc_hd__nand2_1
X_6762_ _2343_ _2345_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__xnor2_1
X_6693_ net440 net445 net335 net341 VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__and4_1
X_9481_ clknet_leaf_19_clk net641 _0391_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
X_5713_ net404 net298 net304 net398 VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a22o_1
XFILLER_50_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8432_ _4000_ _4002_ VGND VGND VPWR VPWR _4005_ sky130_fd_sc_hd__and2_1
X_5644_ net225 net478 _1243_ _1244_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__o2bb2a_1
X_8363_ _3933_ _3934_ VGND VGND VPWR VPWR _3936_ sky130_fd_sc_hd__or2_1
X_5575_ _1203_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__nor2_1
X_7314_ _2939_ _2943_ VGND VGND VPWR VPWR _2944_ sky130_fd_sc_hd__nand2b_1
X_8294_ net129 _3865_ _3866_ VGND VGND VPWR VPWR _3867_ sky130_fd_sc_hd__and3_1
XFILLER_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7245_ _0839_ _0939_ _0944_ _0951_ VGND VGND VPWR VPWR _2875_ sky130_fd_sc_hd__o31a_1
X_7176_ _0878_ _0880_ VGND VGND VPWR VPWR _2806_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6127_ net290 net438 net443 net281 VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a22oi_2
XFILLER_58_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6058_ net246 net254 net466 net471 VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__nand4_1
XFILLER_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5009_ _0636_ _0637_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__and3_1
XFILLER_26_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_665 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5360_ _4554_ _4556_ _4555_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__o21ai_1
X_5291_ _0824_ _0830_ _0829_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__a21o_1
XFILLER_113_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7030_ _2658_ _2659_ VGND VGND VPWR VPWR _2660_ sky130_fd_sc_hd__nor2_1
XFILLER_67_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8981_ net508 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__inv_2
X_7932_ adder_inst.sum_raw_r\[1\] net188 VGND VGND VPWR VPWR _3530_ sky130_fd_sc_hd__or2_1
XFILLER_55_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7863_ net191 _3465_ _3466_ _3468_ VGND VGND VPWR VPWR _3469_ sky130_fd_sc_hd__a31o_1
XFILLER_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6814_ _2437_ _2442_ _2443_ VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__nand3_2
X_7794_ _4347_ _3399_ VGND VGND VPWR VPWR _3400_ sky130_fd_sc_hd__nand2_1
XFILLER_63_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6745_ _2323_ _2325_ _2324_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_21_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9464_ clknet_leaf_15_clk _0082_ _0374_ VGND VGND VPWR VPWR mul_res\[19\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_98_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6676_ _2240_ _2262_ _2295_ _2303_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__o211ai_1
X_8415_ _3977_ _3987_ VGND VGND VPWR VPWR _3988_ sky130_fd_sc_hd__or2_1
X_9395_ clknet_leaf_6_clk net606 _0305_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[0\]
+ sky130_fd_sc_hd__dfrtp_2
X_5627_ _1255_ _1256_ net258 net453 VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__and4bb_1
X_8346_ net123 _3913_ _3915_ _3918_ VGND VGND VPWR VPWR _3919_ sky130_fd_sc_hd__a31o_1
X_5558_ net270 net430 net436 net264 VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__a22oi_1
XFILLER_105_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8277_ adder_inst.man_a_r\[2\] _3342_ _3664_ VGND VGND VPWR VPWR _3850_ sky130_fd_sc_hd__and3_1
X_5489_ _0740_ _1095_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__or3_2
X_7228_ _2857_ VGND VGND VPWR VPWR _2858_ sky130_fd_sc_hd__inv_2
Xfanout521 net523 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__clkbuf_2
Xfanout510 net524 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_2
Xfanout532 net536 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__buf_4
Xfanout543 net548 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__buf_4
X_7159_ _2787_ _2788_ VGND VGND VPWR VPWR _2789_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_29_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_102_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_111_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4860_ _0482_ _0483_ _0488_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a21o_1
XFILLER_60_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_17 net380 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6530_ _2086_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__nor2_1
X_4791_ _4420_ _4546_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and3_1
XFILLER_20_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6461_ net269 net273 net475 net483 VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and4_1
XFILLER_9_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8200_ _3770_ _3773_ net146 VGND VGND VPWR VPWR _3774_ sky130_fd_sc_hd__mux2_1
X_9180_ net535 VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__inv_2
X_5412_ _1012_ _1040_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand3_1
X_6392_ _2002_ _2004_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__a21o_1
X_8131_ _4358_ net162 VGND VGND VPWR VPWR _3705_ sky130_fd_sc_hd__nand2_1
XFILLER_99_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5343_ _0963_ _0966_ _0971_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_93_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8062_ net490 net201 _3420_ _3640_ VGND VGND VPWR VPWR _3641_ sky130_fd_sc_hd__a31o_1
X_5274_ net389 net283 net289 net386 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a22oi_2
XFILLER_68_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7013_ _1577_ _1579_ VGND VGND VPWR VPWR _2643_ sky130_fd_sc_hd__nand2_1
XFILLER_101_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8964_ net532 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8895_ net519 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__inv_2
X_7915_ net200 adder_inst.sum_raw_r\[6\] net117 _3515_ VGND VGND VPWR VPWR _0063_
+ sky130_fd_sc_hd__o211a_1
XFILLER_70_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7846_ adder_inst.exp_larger_r\[3\] _3415_ _3417_ VGND VGND VPWR VPWR _3452_ sky130_fd_sc_hd__a21o_1
XFILLER_23_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7777_ net200 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3383_ sky130_fd_sc_hd__nand2_2
X_4989_ _0617_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_62_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6728_ _2355_ _2357_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__nor2_1
XFILLER_109_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6659_ _2286_ _2287_ _2285_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__o21ba_1
X_9447_ clknet_leaf_20_clk _0094_ _0357_ VGND VGND VPWR VPWR mul_res\[2\] sky130_fd_sc_hd__dfrtp_1
X_9378_ clknet_leaf_11_clk _0052_ _0288_ VGND VGND VPWR VPWR add_res\[24\] sky130_fd_sc_hd__dfrtp_1
X_8329_ net127 _3901_ VGND VGND VPWR VPWR _3902_ sky130_fd_sc_hd__nand2_1
XFILLER_11_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout340 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout373 adder_inst.man_a_r\[19\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_4
Xfanout384 net386 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__buf_2
Xfanout351 net355 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__buf_2
XFILLER_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout362 net367 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__buf_2
XFILLER_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout395 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput15 i_a[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput37 i_b[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput26 i_a[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput48 i_b[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput59 i_b[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5961_ _1589_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nor2_1
X_7700_ net103 _3290_ _3321_ VGND VGND VPWR VPWR _3325_ sky130_fd_sc_hd__a21o_1
X_8680_ _4046_ _4047_ _4051_ _4225_ VGND VGND VPWR VPWR _4235_ sky130_fd_sc_hd__a22oi_2
X_4912_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__xnor2_1
X_7631_ _3250_ _3253_ _3257_ _3260_ VGND VGND VPWR VPWR _3261_ sky130_fd_sc_hd__and4b_1
X_5892_ _1519_ _1520_ _1515_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__a21o_1
X_4843_ net361 net366 net286 net292 VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_31_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4774_ _4441_ _4442_ VGND VGND VPWR VPWR _4545_ sky130_fd_sc_hd__xnor2_1
X_7562_ _3176_ _3189_ net109 VGND VGND VPWR VPWR _3192_ sky130_fd_sc_hd__mux2_1
X_9301_ clknet_leaf_1_clk net599 _0211_ VGND VGND VPWR VPWR adder_inst.man_a_r\[13\]
+ sky130_fd_sc_hd__dfrtp_2
X_6513_ net309 net450 net456 net300 VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__a22o_1
X_7493_ _3121_ _3122_ VGND VGND VPWR VPWR _3123_ sky130_fd_sc_hd__nand2b_1
X_9232_ clknet_leaf_6_clk net55 _0142_ VGND VGND VPWR VPWR adder_inst.i_b\[2\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_6444_ _2071_ _2072_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6375_ _1999_ _2003_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__xor2_1
X_9163_ net527 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__inv_2
X_9094_ net538 VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__inv_2
X_8114_ _3661_ _3662_ _3687_ VGND VGND VPWR VPWR _3688_ sky130_fd_sc_hd__a21o_1
XFILLER_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5326_ _0919_ _0920_ _0954_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a21o_1
X_8045_ adder_inst.is_nan_r adder_inst.is_inf_r VGND VGND VPWR VPWR _3628_ sky130_fd_sc_hd__or2_2
XFILLER_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5257_ net369 net298 net305 net363 VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a22oi_1
XFILLER_87_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_39_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5188_ net265 net394 net271 net399 VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__and4_1
XFILLER_83_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8947_ net537 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__inv_2
XFILLER_16_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8878_ net636 mul_res\[30\] net506 VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__mux2_1
X_7829_ _3425_ _3433_ _3434_ VGND VGND VPWR VPWR _3435_ sky130_fd_sc_hd__nor3_1
XFILLER_12_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout192 _3393_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_2
Xfanout170 net171 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_4
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6160_ net250 net255 net472 net479 VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__nand4_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5111_ _0722_ _0723_ _0739_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a21o_1
XFILLER_85_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6091_ net400 net332 net338 net394 VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__a22oi_2
X_5042_ net361 net279 _0669_ _0670_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__a22o_1
XFILLER_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8801_ _4274_ _4307_ _3169_ VGND VGND VPWR VPWR _4308_ sky130_fd_sc_hd__o21ba_1
XFILLER_92_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6993_ _2620_ _2621_ _2622_ VGND VGND VPWR VPWR _2623_ sky130_fd_sc_hd__nand3_2
X_8732_ net694 net187 net183 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__and3_1
X_5944_ _1478_ _1480_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__nand2_1
X_8663_ _3956_ _3966_ _4219_ VGND VGND VPWR VPWR _4220_ sky130_fd_sc_hd__a21o_1
XFILLER_61_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5875_ _1235_ _1251_ _1503_ _1504_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__a211oi_2
X_8594_ _3908_ _3906_ VGND VGND VPWR VPWR _4159_ sky130_fd_sc_hd__nand2b_1
X_7614_ _3199_ _3203_ _3221_ _3243_ VGND VGND VPWR VPWR _3244_ sky130_fd_sc_hd__and4_2
XFILLER_21_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4826_ _0453_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__nand2_1
XFILLER_21_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7545_ _3021_ _3170_ _3026_ VGND VGND VPWR VPWR _3175_ sky130_fd_sc_hd__o21ai_1
X_4757_ net206 net384 VGND VGND VPWR VPWR _4528_ sky130_fd_sc_hd__nand2_1
XFILLER_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7476_ _3101_ _3105_ VGND VGND VPWR VPWR _3106_ sky130_fd_sc_hd__nor2_1
X_4688_ net223 net377 _4457_ VGND VGND VPWR VPWR _4459_ sky130_fd_sc_hd__a21oi_1
XFILLER_107_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9215_ clknet_leaf_8_clk net9 _0125_ VGND VGND VPWR VPWR adder_inst.i_a\[17\] sky130_fd_sc_hd__dfrtp_1
X_6427_ net426 net433 net318 net325 VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__and4_1
X_6358_ _1986_ _1987_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__nor2_1
XFILLER_68_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9146_ net534 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__inv_2
XFILLER_88_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5309_ net226 net431 _0837_ _0838_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o2bb2a_1
X_9077_ net546 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__inv_2
X_6289_ _1917_ _1918_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_110_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8028_ net500 net495 _3404_ adder_inst.sum_raw_r\[16\] net488 VGND VGND VPWR VPWR
+ _3613_ sky130_fd_sc_hd__a221o_1
XFILLER_88_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold4 add_vld VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5660_ net387 net328 VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__nand2_1
X_4611_ _4374_ _4381_ net345 net223 VGND VGND VPWR VPWR _4382_ sky130_fd_sc_hd__o211a_1
X_5591_ _1210_ _1215_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7330_ _2730_ _2732_ _2929_ _2959_ VGND VGND VPWR VPWR _2960_ sky130_fd_sc_hd__a211o_1
X_7261_ _2872_ _2873_ _2879_ VGND VGND VPWR VPWR _2891_ sky130_fd_sc_hd__o21a_1
X_9000_ net537 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__inv_2
X_6212_ _1828_ _1830_ _1841_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__and3_4
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7192_ _2714_ _2716_ _2715_ VGND VGND VPWR VPWR _2822_ sky130_fd_sc_hd__o21bai_1
XFILLER_112_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6143_ _1656_ _1657_ _1673_ _1674_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__a2bb2oi_1
X_6074_ _1677_ _1679_ _1701_ _1702_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__or4_1
X_5025_ _0649_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__xnor2_1
XFILLER_65_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6976_ _2603_ _2604_ _2605_ VGND VGND VPWR VPWR _2606_ sky130_fd_sc_hd__nand3b_1
X_8715_ _4079_ _4258_ VGND VGND VPWR VPWR _4265_ sky130_fd_sc_hd__nand2_1
X_5927_ net263 net425 VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__nand2_1
XFILLER_41_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8646_ _4202_ _4204_ net193 VGND VGND VPWR VPWR _4205_ sky130_fd_sc_hd__mux2_1
X_5858_ net224 net467 VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__nand2_1
X_8577_ net180 _4144_ _4141_ VGND VGND VPWR VPWR _4145_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5789_ net350 net356 net333 net339 VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__and4_1
X_4809_ _4545_ _0437_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__xor2_1
XFILLER_5_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7528_ _4393_ _3150_ VGND VGND VPWR VPWR _3158_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7459_ _3045_ _3048_ _3088_ VGND VGND VPWR VPWR _3089_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_112_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9129_ net538 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__inv_2
XFILLER_49_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6830_ _2458_ _2459_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__nor2_1
XFILLER_35_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6761_ net312 net468 _2383_ _2382_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_85_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8500_ _4072_ VGND VGND VPWR VPWR _4073_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5712_ net399 net404 net298 net304 VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__nand4_1
X_6692_ _2266_ _2268_ _2267_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__o21ai_1
X_9480_ clknet_leaf_20_clk net634 _0390_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
XFILLER_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8431_ _4000_ _4002_ VGND VGND VPWR VPWR _4004_ sky130_fd_sc_hd__nor2_1
X_5643_ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__inv_2
X_8362_ _3931_ _3932_ VGND VGND VPWR VPWR _3935_ sky130_fd_sc_hd__nand2_1
X_5574_ net270 net436 net441 net264 VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a22oi_1
X_7313_ _2940_ _2941_ VGND VGND VPWR VPWR _2943_ sky130_fd_sc_hd__xnor2_1
X_8293_ net141 _3733_ _3808_ net146 VGND VGND VPWR VPWR _3866_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7244_ _2865_ _2868_ _2867_ VGND VGND VPWR VPWR _2874_ sky130_fd_sc_hd__a21boi_1
X_7175_ _0890_ _0891_ _0893_ VGND VGND VPWR VPWR _2805_ sky130_fd_sc_hd__a21oi_1
X_6126_ net277 net449 VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__nand2_1
XFILLER_105_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6057_ _1264_ _1684_ _1685_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__or3_1
X_5008_ _0514_ _0521_ _0520_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21bo_1
XFILLER_38_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6959_ _2587_ _2588_ VGND VGND VPWR VPWR _2589_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_52_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8629_ _3947_ _3997_ _4007_ _4169_ _4189_ VGND VGND VPWR VPWR _4190_ sky130_fd_sc_hd__a41o_1
XPHY_EDGE_ROW_15_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_33_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5290_ _0849_ _0918_ _0912_ _0899_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o211ai_2
XFILLER_99_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8980_ net511 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__inv_2
X_7931_ _3528_ _3529_ net115 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__o21a_1
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7862_ net486 net203 net174 _3467_ VGND VGND VPWR VPWR _3468_ sky130_fd_sc_hd__a211o_1
X_6813_ _2399_ _2416_ _2433_ _2441_ VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__o211ai_2
X_7793_ _4346_ _3386_ VGND VGND VPWR VPWR _3399_ sky130_fd_sc_hd__and2_1
X_6744_ _2328_ _2334_ _2333_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__a21o_1
X_6675_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__inv_2
X_9463_ clknet_leaf_18_clk _0081_ _0373_ VGND VGND VPWR VPWR mul_res\[18\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_21_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8414_ _3984_ _3986_ VGND VGND VPWR VPWR _3987_ sky130_fd_sc_hd__nand2_2
X_5626_ net270 net441 net447 net264 VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a22oi_1
X_9394_ clknet_leaf_10_clk adder_inst.is_inf_a _0304_ VGND VGND VPWR VPWR adder_inst.is_inf_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_8345_ net123 _3916_ VGND VGND VPWR VPWR _3918_ sky130_fd_sc_hd__nor2_1
X_5557_ net264 net270 net430 net436 VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__and4_1
X_8276_ net331 _3848_ net168 VGND VGND VPWR VPWR _3849_ sky130_fd_sc_hd__mux2_2
X_5488_ _1091_ _1092_ _1094_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__a21oi_1
XFILLER_104_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7227_ net218 net442 net448 net212 VGND VGND VPWR VPWR _2857_ sky130_fd_sc_hd__a22o_1
Xfanout522 net523 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__buf_4
Xfanout500 adder_inst.sum_raw_r\[18\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__buf_2
Xfanout533 net535 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_4
Xfanout511 net524 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__buf_4
Xfanout544 net548 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_2
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7158_ _2680_ _2681_ VGND VGND VPWR VPWR _2788_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7089_ _2617_ _2619_ _2618_ VGND VGND VPWR VPWR _2719_ sky130_fd_sc_hd__o21bai_1
X_6109_ net297 net425 net306 net419 VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__a22oi_1
XFILLER_86_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_107_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4790_ _4558_ _4559_ _4553_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a21bo_1
XFILLER_32_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_18 net443 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6460_ net273 net480 VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__nand2_1
X_5411_ _0996_ _0997_ _1011_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o21ai_1
X_6391_ _1932_ _1933_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__xnor2_1
X_8130_ _3679_ _3694_ _3698_ _3702_ VGND VGND VPWR VPWR _3704_ sky130_fd_sc_hd__or4_2
X_5342_ _0865_ _0874_ _0960_ _0969_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a211oi_2
X_8061_ net191 _3421_ VGND VGND VPWR VPWR _3640_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7012_ _1548_ _1562_ _1563_ _1566_ VGND VGND VPWR VPWR _2642_ sky130_fd_sc_hd__a31o_1
X_5273_ net396 net277 VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nand2_1
XFILLER_101_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8963_ net532 VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__inv_2
X_8894_ net515 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__inv_2
X_7914_ adder_inst.sum_raw_r\[5\] _3383_ _3513_ _3514_ VGND VGND VPWR VPWR _3515_
+ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_54_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7845_ _3385_ _3395_ net199 VGND VGND VPWR VPWR _3451_ sky130_fd_sc_hd__a21oi_1
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_102_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7776_ net200 adder_inst.sum_raw_r\[23\] VGND VGND VPWR VPWR _3382_ sky130_fd_sc_hd__and2_1
X_4988_ net379 net267 net275 net372 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_62_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6727_ _2340_ _2347_ _2354_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__and3_1
X_6658_ _2285_ _2287_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__nor2_1
X_9446_ clknet_leaf_21_clk _0083_ _0356_ VGND VGND VPWR VPWR mul_res\[1\] sky130_fd_sc_hd__dfrtp_1
X_9377_ clknet_leaf_12_clk _0051_ _0287_ VGND VGND VPWR VPWR add_res\[23\] sky130_fd_sc_hd__dfrtp_1
X_5609_ net230 net236 net459 net465 VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__and4_1
X_6589_ net295 net469 VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__nand2_1
X_8328_ net129 _3809_ _3810_ _3900_ VGND VGND VPWR VPWR _3901_ sky130_fd_sc_hd__a31oi_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8259_ net137 _3755_ _3753_ net143 VGND VGND VPWR VPWR _3832_ sky130_fd_sc_hd__o211a_1
XFILLER_87_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout341 net343 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__buf_2
Xfanout330 net331 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout363 net367 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__buf_1
Xfanout352 net353 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__buf_2
Xfanout374 net376 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__buf_2
XFILLER_100_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout385 net386 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_2
Xfanout396 net552 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__buf_4
XFILLER_74_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput16 i_a[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput27 i_a[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput49 i_b[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
Xinput38 i_b[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5960_ net234 net448 net454 net228 VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__a22oi_1
XFILLER_37_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4911_ net227 net417 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand2_1
XFILLER_52_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5891_ _1515_ _1519_ _1520_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__nand3_1
X_7630_ _3259_ VGND VGND VPWR VPWR _3260_ sky130_fd_sc_hd__inv_2
X_4842_ net372 adder_inst.man_b_r\[11\] VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand2_1
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7561_ net109 _3189_ _3190_ VGND VGND VPWR VPWR _3191_ sky130_fd_sc_hd__o21a_1
X_4773_ net347 net261 VGND VGND VPWR VPWR _4544_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6512_ net300 net309 net450 net456 VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nand4_1
X_9300_ clknet_leaf_0_clk net601 _0210_ VGND VGND VPWR VPWR adder_inst.man_a_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
X_7492_ _3068_ _3071_ _3120_ VGND VGND VPWR VPWR _3122_ sky130_fd_sc_hd__or3b_1
X_9231_ clknet_leaf_7_clk net44 _0141_ VGND VGND VPWR VPWR adder_inst.i_b\[1\] sky130_fd_sc_hd__dfrtp_1
X_6443_ _2071_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__nand2b_1
X_9162_ net539 VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__inv_2
X_6374_ _1999_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__nand2_1
X_9093_ net520 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__inv_2
X_8113_ _3298_ _3305_ _3656_ VGND VGND VPWR VPWR _3687_ sky130_fd_sc_hd__and3_1
X_5325_ _0919_ _0920_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand3_1
X_8044_ adder_inst.is_zero_r _3469_ VGND VGND VPWR VPWR _3627_ sky130_fd_sc_hd__nor2_1
XFILLER_102_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5256_ net374 net294 VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nand2_1
XFILLER_87_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5187_ _0567_ _0573_ _0572_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__a21o_1
XFILLER_110_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8946_ net519 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__inv_2
XFILLER_113_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_104_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8877_ add_res\[29\] net669 net506 VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__mux2_1
XFILLER_24_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7828_ _3426_ _3427_ _3429_ VGND VGND VPWR VPWR _3434_ sky130_fd_sc_hd__or3_1
XFILLER_12_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7759_ adder_inst.exp_b\[1\] adder_inst.exp_b\[0\] adder_inst.exp_b\[3\] adder_inst.exp_b\[2\]
+ VGND VGND VPWR VPWR _3373_ sky130_fd_sc_hd__and4_1
XFILLER_11_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9429_ clknet_leaf_17_clk multiplier_inst.man_final\[17\] _0339_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout182 multiplier_inst.sign_res VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_4
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
Xfanout160 net167 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_2
Xfanout193 net194 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_2
XFILLER_34_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5110_ _0722_ _0723_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nand3_1
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6090_ net407 net329 VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__nand2_1
X_5041_ adder_inst.man_a_r\[21\] net279 _0669_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__nand4_2
XFILLER_85_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8800_ net340 net479 _3153_ _4306_ VGND VGND VPWR VPWR _4307_ sky130_fd_sc_hd__a31o_1
XFILLER_92_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6992_ _1549_ _1551_ _1550_ VGND VGND VPWR VPWR _2622_ sky130_fd_sc_hd__o21bai_1
X_8731_ net678 net187 net183 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__and3_1
X_5943_ _1486_ _1501_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__nor2_1
XFILLER_18_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8662_ _4218_ VGND VGND VPWR VPWR _4219_ sky130_fd_sc_hd__inv_2
X_5874_ net173 _1502_ _1405_ _1407_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__o211a_1
X_8593_ _3911_ _4158_ VGND VGND VPWR VPWR adder_inst.sum_raw\[7\] sky130_fd_sc_hd__xor2_1
X_7613_ _3232_ _3235_ _3238_ _3240_ VGND VGND VPWR VPWR _3243_ sky130_fd_sc_hd__nor4b_1
XFILLER_33_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4825_ _0444_ _0447_ _0453_ _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__o211ai_2
XFILLER_21_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7544_ _3021_ _3170_ _3026_ VGND VGND VPWR VPWR _3174_ sky130_fd_sc_hd__o21a_1
X_4756_ _4525_ _4526_ VGND VGND VPWR VPWR _4527_ sky130_fd_sc_hd__nor2_1
X_7475_ _3103_ _3104_ VGND VGND VPWR VPWR _3105_ sky130_fd_sc_hd__or2_1
X_4687_ net223 net377 _4457_ VGND VGND VPWR VPWR _4458_ sky130_fd_sc_hd__and3_1
X_9214_ clknet_leaf_3_clk net8 _0124_ VGND VGND VPWR VPWR adder_inst.i_a\[16\] sky130_fd_sc_hd__dfrtp_1
X_6426_ net440 net312 VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__nand2_1
X_9145_ net533 VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__inv_2
X_6357_ net428 net318 net325 net422 VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5308_ _0831_ _0921_ _0936_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21oi_1
X_9076_ net547 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__inv_2
X_6288_ _1834_ _1916_ _1915_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__a21o_1
XFILLER_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8027_ adder_inst.sum_raw_r\[14\] adder_inst.sum_raw_r\[15\] net502 VGND VGND VPWR
+ VPWR _3612_ sky130_fd_sc_hd__mux2_1
X_5239_ _0858_ _0861_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__o21a_1
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8929_ net512 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__inv_2
XFILLER_17_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold5 adder_inst.i_vld VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_35_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4610_ _4379_ _4380_ VGND VGND VPWR VPWR _4381_ sky130_fd_sc_hd__nor2_1
XFILLER_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5590_ _1217_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__or2_1
Xmax_cap102 _4320_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_2
Xmax_cap135 _1414_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_1
X_7260_ _2885_ _2889_ VGND VGND VPWR VPWR _2890_ sky130_fd_sc_hd__or2_1
XFILLER_104_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7191_ _0902_ _0904_ _0903_ VGND VGND VPWR VPWR _2821_ sky130_fd_sc_hd__o21ai_1
X_6211_ _1835_ _1840_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__xnor2_1
Xmax_cap157 _1862_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_2
X_6142_ _1753_ _1769_ _1770_ _1752_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__o31a_1
XFILLER_112_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6073_ _1677_ _1679_ _1701_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__nor4_1
X_5024_ _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__xor2_1
XFILLER_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6975_ net382 net299 net304 net375 VGND VGND VPWR VPWR _2605_ sky130_fd_sc_hd__a22o_1
X_8714_ net194 _4082_ _4261_ _4263_ _4078_ VGND VGND VPWR VPWR _4264_ sky130_fd_sc_hd__a32o_1
X_5926_ _1552_ _1553_ _1554_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__a21o_1
XFILLER_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8645_ _3977_ _3987_ _4190_ _4203_ VGND VGND VPWR VPWR _4204_ sky130_fd_sc_hd__a31oi_1
XFILLER_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5857_ _1484_ _1485_ _1474_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8576_ net106 _4142_ _4143_ VGND VGND VPWR VPWR _4144_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5788_ net350 net333 VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nand2_1
X_4808_ _4545_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__and2b_1
X_7527_ _3154_ _3156_ VGND VGND VPWR VPWR _3157_ sky130_fd_sc_hd__nand2_1
X_4739_ _4497_ _4502_ _4496_ VGND VGND VPWR VPWR _4510_ sky130_fd_sc_hd__a21oi_1
X_7458_ net345 net224 _4374_ _3087_ VGND VGND VPWR VPWR _3088_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_112_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6409_ _1962_ _2037_ _2036_ _2029_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__o211ai_2
X_7389_ _3016_ _3017_ VGND VGND VPWR VPWR _3019_ sky130_fd_sc_hd__xnor2_2
X_9128_ net538 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__inv_2
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9059_ net542 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__inv_2
XFILLER_49_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_97_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6760_ _2335_ _2374_ _2389_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_85_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5711_ net409 net293 VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__nand2_1
X_6691_ _2271_ _2277_ _2276_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__a21o_1
XFILLER_31_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8430_ _3998_ _3999_ _4001_ VGND VGND VPWR VPWR _4003_ sky130_fd_sc_hd__or3_1
X_5642_ net230 net236 net471 net478 VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__and4_1
XFILLER_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8361_ _3931_ _3932_ VGND VGND VPWR VPWR _3934_ sky130_fd_sc_hd__and2_1
X_5573_ net264 net270 net436 net441 VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__and4_1
X_7312_ _2854_ _2862_ _2940_ VGND VGND VPWR VPWR _2942_ sky130_fd_sc_hd__o21ai_1
XFILLER_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8292_ net138 _3738_ _3812_ net142 VGND VGND VPWR VPWR _3865_ sky130_fd_sc_hd__a211o_1
XFILLER_116_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7243_ _0958_ _2803_ _2835_ _2871_ VGND VGND VPWR VPWR _2873_ sky130_fd_sc_hd__o211a_1
X_7174_ _0912_ _0913_ _0914_ _0896_ VGND VGND VPWR VPWR _2804_ sky130_fd_sc_hd__a22oi_2
XFILLER_85_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6125_ net281 net287 net438 net443 VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__and4_1
X_6056_ _1264_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__nor2_1
X_5007_ _0634_ _0635_ _0627_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a21o_1
XFILLER_39_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6958_ net351 net329 net333 net344 VGND VGND VPWR VPWR _2588_ sky130_fd_sc_hd__a22oi_1
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6889_ _2495_ _2518_ VGND VGND VPWR VPWR _2519_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_52_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5909_ _1533_ _1537_ _1538_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__and3_1
X_8628_ _3997_ _4188_ _4187_ VGND VGND VPWR VPWR _4189_ sky130_fd_sc_hd__a21o_1
XFILLER_108_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8559_ _3854_ _4123_ VGND VGND VPWR VPWR _4129_ sky130_fd_sc_hd__nand2b_1
XFILLER_14_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7930_ net484 adder_inst.sum_raw_r\[8\] _3526_ _3527_ VGND VGND VPWR VPWR _3529_
+ sky130_fd_sc_hd__a22o_1
X_7861_ net203 _3383_ VGND VGND VPWR VPWR _3467_ sky130_fd_sc_hd__nor2_1
XFILLER_82_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6812_ _2433_ _2441_ _2399_ _2416_ VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__a211o_1
X_7792_ net497 net500 VGND VGND VPWR VPWR _3398_ sky130_fd_sc_hd__nor2_1
XFILLER_23_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6743_ _2337_ _2349_ _2348_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__a21oi_1
X_6674_ _2295_ _2303_ _2240_ _2262_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__a211o_1
X_9462_ clknet_leaf_18_clk _0080_ _0372_ VGND VGND VPWR VPWR mul_res\[17\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_21_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8413_ _3980_ _3982_ VGND VGND VPWR VPWR _3986_ sky130_fd_sc_hd__or2_1
X_5625_ net264 net270 net441 net447 VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__and4_1
X_9393_ clknet_leaf_9_clk adder_inst.exp_larger\[7\] _0303_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[7\]
+ sky130_fd_sc_hd__dfrtp_2
X_8344_ _3916_ VGND VGND VPWR VPWR _3917_ sky130_fd_sc_hd__inv_2
X_5556_ net258 net441 VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__nand2_1
X_8275_ net123 _3836_ _3843_ _3847_ VGND VGND VPWR VPWR _3848_ sky130_fd_sc_hd__a31o_1
X_5487_ _1097_ _1105_ _1104_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__a21oi_1
XFILLER_104_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7226_ net212 net218 net443 net449 VGND VGND VPWR VPWR _2856_ sky130_fd_sc_hd__and4_1
XFILLER_116_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout523 net524 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__clkbuf_2
XFILLER_104_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout512 net514 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__buf_4
Xfanout501 adder_inst.sum_raw_r\[18\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout545 net548 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__buf_4
Xfanout534 net535 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7157_ _1612_ _1617_ _1611_ VGND VGND VPWR VPWR _2787_ sky130_fd_sc_hd__o21ba_1
XFILLER_58_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7088_ _2715_ _2716_ _2714_ VGND VGND VPWR VPWR _2718_ sky130_fd_sc_hd__o21ai_1
X_6108_ net293 net432 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__nand2_1
XFILLER_46_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6039_ _1666_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_29_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_19 net460 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6390_ _2018_ _2019_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__and2_1
X_5410_ _0728_ _0735_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__a21oi_1
X_5341_ _0960_ _0969_ _0865_ _0874_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__o211a_1
X_8060_ _3412_ _3632_ _3633_ _3418_ net490 VGND VGND VPWR VPWR _3639_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_93_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7011_ _1586_ _1603_ VGND VGND VPWR VPWR _2641_ sky130_fd_sc_hd__or2_1
X_5272_ net383 net389 net283 net289 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__and4_1
XFILLER_102_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8962_ net549 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__inv_2
XFILLER_28_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7913_ adder_inst.sum_raw_r\[4\] net488 _3462_ adder_inst.sum_raw_r\[3\] _3394_ VGND
+ VGND VPWR VPWR _3514_ sky130_fd_sc_hd__a221o_1
XFILLER_102_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8893_ net512 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__inv_2
X_7844_ _3430_ _3444_ _3449_ VGND VGND VPWR VPWR _3450_ sky130_fd_sc_hd__o21a_1
XFILLER_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7775_ _3371_ _3375_ _3376_ VGND VGND VPWR VPWR adder_inst.is_nan_a sky130_fd_sc_hd__and3b_1
XFILLER_63_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6726_ _2355_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__inv_2
X_4987_ net372 net379 net267 net275 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_62_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6657_ net308 net461 net468 net300 VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__a22oi_1
X_9445_ clknet_leaf_20_clk _0072_ _0355_ VGND VGND VPWR VPWR mul_res\[0\] sky130_fd_sc_hd__dfrtp_1
X_9376_ clknet_leaf_13_clk _0050_ _0286_ VGND VGND VPWR VPWR add_res\[22\] sky130_fd_sc_hd__dfrtp_1
X_6588_ net301 net308 net457 net462 VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__and4_1
X_5608_ net225 net471 VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__nand2_1
X_8327_ net149 _3788_ _3789_ VGND VGND VPWR VPWR _3900_ sky130_fd_sc_hd__and3_1
XFILLER_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5539_ net409 net414 net297 net305 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__and4_1
XFILLER_105_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8258_ _3828_ _3830_ VGND VGND VPWR VPWR _3831_ sky130_fd_sc_hd__nor2_1
XFILLER_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout331 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_2
X_8189_ _3761_ _3762_ net140 VGND VGND VPWR VPWR _3763_ sky130_fd_sc_hd__mux2_1
Xfanout320 adder_inst.man_b_r\[4\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7209_ _0929_ _0931_ _0930_ VGND VGND VPWR VPWR _2839_ sky130_fd_sc_hd__o21ai_1
Xfanout342 net343 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__clkbuf_2
Xfanout353 net354 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_2
Xfanout364 net365 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__buf_2
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_101_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout386 adder_inst.man_a_r\[17\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__buf_4
Xfanout397 net551 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput17 i_a[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 i_a[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput39 i_b[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_70_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4910_ _0538_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2b_1
X_5890_ _1517_ _1518_ _1516_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__a21o_1
XFILLER_45_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4841_ _0464_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and2_1
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4772_ _4478_ _4508_ VGND VGND VPWR VPWR _4543_ sky130_fd_sc_hd__and2_1
X_7560_ _4370_ net136 _3151_ _3187_ VGND VGND VPWR VPWR _3190_ sky130_fd_sc_hd__a31o_1
X_6511_ net300 net309 net451 net457 VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__and4_1
X_7491_ _3068_ _3071_ _3120_ VGND VGND VPWR VPWR _3121_ sky130_fd_sc_hd__o21ba_1
X_9230_ clknet_leaf_6_clk net33 _0140_ VGND VGND VPWR VPWR adder_inst.i_b\[0\] sky130_fd_sc_hd__dfrtp_1
X_6442_ _1996_ _1998_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__xnor2_1
X_9161_ net543 VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__inv_2
X_8112_ _3298_ _3683_ _3684_ VGND VGND VPWR VPWR _3686_ sky130_fd_sc_hd__and3_1
X_6373_ _2000_ _2001_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__xnor2_1
X_9092_ net538 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__inv_2
X_5324_ _0937_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__or2_1
X_8043_ net205 _3626_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and2_1
X_5255_ net363 net369 net298 net305 VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__and4_1
XFILLER_87_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_671 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5186_ _0591_ _0813_ _0807_ _0794_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__o211ai_1
XFILLER_56_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8945_ net524 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__inv_2
X_8876_ add_res\[28\] net652 net506 VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_104_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7827_ adder_inst.sum_raw_r\[2\] net498 _3430_ VGND VGND VPWR VPWR _3433_ sky130_fd_sc_hd__or3_1
XFILLER_51_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7758_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r net182 net695 net698 VGND VGND
+ VPWR VPWR _0034_ sky130_fd_sc_hd__a311o_1
XFILLER_11_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7689_ net114 _3286_ _3314_ VGND VGND VPWR VPWR _3315_ sky130_fd_sc_hd__and3_1
X_6709_ _2286_ _2288_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__xnor2_1
X_9428_ clknet_leaf_19_clk multiplier_inst.man_final\[16\] _0338_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_98_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_115_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9359_ clknet_leaf_19_clk _0063_ _0269_ VGND VGND VPWR VPWR add_res\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_105_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout172 _3665_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout161 net167 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_2
Xfanout150 _3704_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout183 net185 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_2
Xfanout194 _3355_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
XFILLER_93_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5040_ net355 net285 net292 net349 VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_108_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6991_ _2618_ _2619_ _2617_ VGND VGND VPWR VPWR _2621_ sky130_fd_sc_hd__o21ai_1
X_8730_ multiplier_inst.overflow_calc_r multiplier_inst.is_zero_r VGND VGND VPWR VPWR
+ _4270_ sky130_fd_sc_hd__nor2_1
XFILLER_80_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5942_ _1569_ _1570_ _1447_ _1470_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__o211ai_2
XFILLER_25_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8661_ _3949_ _3950_ _3952_ _3957_ _4207_ VGND VGND VPWR VPWR _4218_ sky130_fd_sc_hd__o32a_1
X_5873_ _1405_ _1407_ net173 _1502_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__a211oi_2
X_8592_ net193 _4153_ _4154_ _4157_ VGND VGND VPWR VPWR _4158_ sky130_fd_sc_hd__a31o_1
X_7612_ _3238_ _3241_ VGND VGND VPWR VPWR _3242_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_44_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4824_ _4509_ _4543_ _0442_ _0452_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__o211ai_2
X_4755_ net219 net370 net377 net210 VGND VGND VPWR VPWR _4526_ sky130_fd_sc_hd__a22oi_1
X_7543_ net109 _3171_ _3168_ _3162_ _3160_ VGND VGND VPWR VPWR _3173_ sky130_fd_sc_hd__a2111o_1
X_9213_ clknet_leaf_3_clk net7 _0123_ VGND VGND VPWR VPWR adder_inst.i_a\[15\] sky130_fd_sc_hd__dfrtp_1
X_7474_ _3059_ _3092_ VGND VGND VPWR VPWR _3104_ sky130_fd_sc_hd__xor2_1
X_4686_ _4455_ _4456_ VGND VGND VPWR VPWR _4457_ sky130_fd_sc_hd__nor2_1
X_6425_ _1980_ _2053_ _2052_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__a21o_1
X_6356_ net422 net426 net318 net325 VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__and4_1
X_9144_ net533 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__inv_2
XFILLER_115_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9075_ net545 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__inv_2
X_5307_ _0831_ _0921_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__and3_1
X_8026_ net117 _3611_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__and2_1
X_6287_ _1834_ _1915_ _1916_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_110_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5238_ _0866_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nor2_1
X_5169_ net383 net283 net289 net376 VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a22oi_2
XFILLER_84_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8928_ net509 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
XFILLER_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8859_ net650 mul_res\[11\] net505 VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__mux2_1
XFILLER_71_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold6 adder_inst.i_a\[31\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_7_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap158 _2474_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_1
X_7190_ _0894_ _2805_ _2818_ VGND VGND VPWR VPWR _2820_ sky130_fd_sc_hd__o21bai_1
X_6210_ _1838_ _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__nand2b_1
X_6141_ _1751_ _1753_ _1769_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__or4_4
XFILLER_97_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6072_ _1699_ _1700_ _1694_ _1697_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__o211a_1
X_5023_ net209 net427 VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__nand2_1
XFILLER_57_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6974_ net375 net382 net299 net304 VGND VGND VPWR VPWR _2604_ sky130_fd_sc_hd__nand4_1
XFILLER_110_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8713_ net182 _4077_ VGND VGND VPWR VPWR _4263_ sky130_fd_sc_hd__nor2_1
XFILLER_80_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5925_ _1552_ _1553_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__nand3_2
X_8644_ _3972_ _3973_ _3987_ _3983_ _3980_ VGND VGND VPWR VPWR _4203_ sky130_fd_sc_hd__a32o_1
X_5856_ _1474_ _1484_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__and3_1
X_4807_ _0421_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8575_ _3894_ _4098_ _4115_ _3892_ VGND VGND VPWR VPWR _4143_ sky130_fd_sc_hd__o211a_1
XFILLER_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5787_ net362 net329 VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__nand2_1
X_7526_ net175 net114 VGND VGND VPWR VPWR _3156_ sky130_fd_sc_hd__or2_1
X_4738_ _4478_ _4508_ VGND VGND VPWR VPWR _4509_ sky130_fd_sc_hd__nor2_1
XFILLER_107_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7457_ net352 net224 net228 net345 VGND VGND VPWR VPWR _3087_ sky130_fd_sc_hd__a22oi_1
X_4669_ _4438_ _4439_ VGND VGND VPWR VPWR _4440_ sky130_fd_sc_hd__xnor2_1
X_6408_ _2029_ _2036_ _2037_ _1962_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__a211o_1
X_9127_ net538 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__inv_2
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7388_ _3016_ _3017_ VGND VGND VPWR VPWR _3018_ sky130_fd_sc_hd__nor2_1
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6339_ _1964_ _1967_ _1968_ _1885_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__a211o_1
XFILLER_103_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9058_ net535 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__inv_2
XFILLER_76_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8009_ net503 net195 net176 adder_inst.sum_raw_r\[16\] VGND VGND VPWR VPWR _3597_
+ sky130_fd_sc_hd__o22a_1
XFILLER_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5710_ _1309_ _1311_ _1310_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__o21bai_1
XFILLER_50_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6690_ _2280_ _2292_ _2291_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__a21oi_1
XFILLER_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5641_ net236 net479 VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__nand2_1
X_8360_ _3931_ _3932_ VGND VGND VPWR VPWR _3933_ sky130_fd_sc_hd__nor2_1
X_5572_ net258 net447 VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__nand2_1
X_8291_ _3862_ _3863_ VGND VGND VPWR VPWR _3864_ sky130_fd_sc_hd__and2_1
X_7311_ _2854_ _2862_ VGND VGND VPWR VPWR _2941_ sky130_fd_sc_hd__nor2_1
X_7242_ _2835_ _2871_ _0958_ _2803_ VGND VGND VPWR VPWR _2872_ sky130_fd_sc_hd__a211oi_2
XFILLER_116_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7173_ _0955_ _0956_ _0957_ _0917_ VGND VGND VPWR VPWR _2803_ sky130_fd_sc_hd__a22oi_2
XFILLER_112_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6124_ _1660_ _1662_ _1661_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__o21ai_1
XFILLER_85_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6055_ net240 net471 _1262_ _1263_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__o2bb2a_1
X_5006_ _0627_ _0634_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__nand3_1
XFILLER_39_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6957_ net350 net344 net328 net333 VGND VGND VPWR VPWR _2587_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_62_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6888_ net330 net474 _2493_ _2494_ VGND VGND VPWR VPWR _2518_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_52_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5908_ _1535_ _1536_ _1534_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__a21bo_1
X_8627_ _4008_ _4174_ _4003_ VGND VGND VPWR VPWR _4188_ sky130_fd_sc_hd__o21ai_1
X_5839_ _1466_ _1467_ _1449_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a21o_1
X_8558_ _3854_ _4095_ _3853_ VGND VGND VPWR VPWR _4128_ sky130_fd_sc_hd__o21ba_1
X_7509_ _3136_ _3138_ VGND VGND VPWR VPWR _3139_ sky130_fd_sc_hd__and2b_1
X_8489_ net366 net165 VGND VGND VPWR VPWR _4062_ sky130_fd_sc_hd__or2_1
XFILLER_30_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7860_ _3462_ _3464_ net203 VGND VGND VPWR VPWR _3466_ sky130_fd_sc_hd__o21ai_1
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6811_ _2433_ _2438_ _2439_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__nand3_1
X_7791_ _3388_ _3396_ net494 VGND VGND VPWR VPWR _3397_ sky130_fd_sc_hd__o21ai_1
X_6742_ _2352_ _2359_ _2358_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__a21o_1
XFILLER_23_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6673_ _2295_ _2300_ _2301_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__nand3_1
X_9461_ clknet_leaf_18_clk _0079_ _0371_ VGND VGND VPWR VPWR mul_res\[16\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_21_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9392_ clknet_leaf_11_clk adder_inst.exp_larger\[6\] _0302_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[6\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_98_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8412_ _3980_ _3982_ VGND VGND VPWR VPWR _3985_ sky130_fd_sc_hd__nor2_1
X_5624_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__inv_2
XFILLER_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8343_ net150 net143 net127 _3763_ VGND VGND VPWR VPWR _3916_ sky130_fd_sc_hd__or4b_2
X_5555_ _1178_ _1183_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__xnor2_1
XFILLER_104_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8274_ net149 _3844_ _3845_ net126 net121 VGND VGND VPWR VPWR _3847_ sky130_fd_sc_hd__o2111a_1
X_5486_ _1109_ _1111_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7225_ _2849_ _2853_ VGND VGND VPWR VPWR _2855_ sky130_fd_sc_hd__xnor2_1
Xfanout524 net67 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__buf_4
Xfanout502 net503 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__buf_2
Xfanout513 net514 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__buf_2
X_7156_ _2581_ _2785_ VGND VGND VPWR VPWR _2786_ sky130_fd_sc_hd__xnor2_1
Xfanout546 net547 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__buf_4
XFILLER_116_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout535 net536 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__buf_2
X_6107_ net419 net297 net425 net305 VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__and4_1
XFILLER_86_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7087_ _2714_ _2715_ _2716_ VGND VGND VPWR VPWR _2717_ sky130_fd_sc_hd__or3_1
XFILLER_100_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_57_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6038_ _1257_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__nor2_1
XFILLER_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7989_ net484 adder_inst.sum_raw_r\[16\] net178 adder_inst.sum_raw_r\[15\] _3579_
+ VGND VGND VPWR VPWR _3580_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_37_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5340_ _0960_ _0967_ _0968_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__or3_1
XFILLER_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5271_ _0797_ _0799_ _0798_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__o21ai_1
X_7010_ _2583_ _2638_ VGND VGND VPWR VPWR _2640_ sky130_fd_sc_hd__xnor2_1
XFILLER_68_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8961_ net531 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__inv_2
X_7912_ adder_inst.sum_raw_r\[2\] _4343_ _3413_ _3512_ VGND VGND VPWR VPWR _3513_
+ sky130_fd_sc_hd__o211a_1
X_8892_ net516 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__inv_2
X_7843_ _3387_ _3399_ _3446_ _3447_ _3448_ VGND VGND VPWR VPWR _3449_ sky130_fd_sc_hd__o32a_1
XFILLER_24_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7774_ _3363_ _3373_ _3374_ VGND VGND VPWR VPWR adder_inst.is_nan_b sky130_fd_sc_hd__and3b_1
X_4986_ net385 net261 VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nand2_1
XFILLER_24_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6725_ _2340_ _2347_ _2354_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_62_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9444_ clknet_leaf_11_clk _0104_ _0354_ VGND VGND VPWR VPWR mul_ovf sky130_fd_sc_hd__dfrtp_1
X_6656_ net295 net473 VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__nand2_1
X_9375_ clknet_leaf_15_clk _0049_ _0285_ VGND VGND VPWR VPWR add_res\[21\] sky130_fd_sc_hd__dfrtp_1
X_6587_ _2213_ _2215_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__xor2_1
X_5607_ net220 net478 VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__nand2_1
X_8326_ net128 _3803_ _3804_ net127 VGND VGND VPWR VPWR _3899_ sky130_fd_sc_hd__a31o_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5538_ _1162_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__nand2b_1
XFILLER_105_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8257_ _3822_ _3823_ _3825_ _3826_ VGND VGND VPWR VPWR _3830_ sky130_fd_sc_hd__o22a_1
XFILLER_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5469_ _1002_ _1048_ _1050_ _1057_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__o31a_1
X_7208_ net263 net415 _2724_ _2723_ VGND VGND VPWR VPWR _2838_ sky130_fd_sc_hd__a31o_1
X_8188_ net355 net216 net168 VGND VGND VPWR VPWR _3762_ sky130_fd_sc_hd__mux2_1
Xfanout310 net311 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout321 net327 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__buf_2
Xfanout332 net334 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__clkbuf_4
Xfanout343 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__clkbuf_4
Xfanout354 net355 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_2
Xfanout365 net367 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_2
X_7139_ _2633_ _2635_ _2767_ _2768_ VGND VGND VPWR VPWR _2769_ sky130_fd_sc_hd__a211o_1
XFILLER_101_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout387 net388 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkbuf_4
Xfanout398 net401 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkbuf_4
Xfanout376 net380 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkbuf_2
XFILLER_100_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 i_a[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput29 i_a[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4840_ _0465_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xor2_1
XFILLER_21_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6510_ _2061_ _2138_ _2137_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_31_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4771_ _4540_ _4541_ VGND VGND VPWR VPWR _4542_ sky130_fd_sc_hd__and2_1
X_7490_ _3114_ _3115_ VGND VGND VPWR VPWR _3120_ sky130_fd_sc_hd__xnor2_1
X_6441_ _2056_ _2058_ _2057_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__o21ba_1
X_9160_ net539 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__inv_2
X_6372_ _2000_ _2001_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_11_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8111_ _3683_ _3684_ _3298_ VGND VGND VPWR VPWR _3685_ sky130_fd_sc_hd__a21oi_1
X_5323_ _0937_ _0938_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nor3_1
X_9091_ net537 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__inv_2
XFILLER_114_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8042_ _3497_ _3498_ _3625_ adder_inst.is_nan_r VGND VGND VPWR VPWR _3626_ sky130_fd_sc_hd__a31o_1
X_5254_ _0785_ _0882_ _0881_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a21o_1
X_5185_ _0794_ _0807_ _0813_ _0591_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a211o_1
XFILLER_96_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8944_ net524 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__inv_2
XFILLER_83_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8875_ net654 mul_res\[27\] net507 VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_104_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7826_ net497 _3430_ VGND VGND VPWR VPWR _3432_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_19_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7757_ net714 _3372_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__nor2_1
X_4969_ _0598_ _0597_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__and2b_1
XFILLER_24_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7688_ _3313_ VGND VGND VPWR VPWR _3314_ sky130_fd_sc_hd__inv_2
X_6708_ _2330_ _2332_ _2329_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__o21ba_1
X_6639_ _2266_ _2267_ _2268_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__or3_1
X_9427_ clknet_leaf_19_clk multiplier_inst.man_final\[15\] _0337_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[15\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_115_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9358_ clknet_leaf_19_clk _0062_ _0268_ VGND VGND VPWR VPWR add_res\[4\] sky130_fd_sc_hd__dfrtp_1
X_8309_ net131 _3756_ _3757_ VGND VGND VPWR VPWR _3882_ sky130_fd_sc_hd__nor3_1
X_9289_ clknet_leaf_22_clk net571 _0199_ VGND VGND VPWR VPWR adder_inst.man_a_r\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_1
Xfanout162 net167 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_2
XFILLER_93_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout195 net196 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
Xfanout184 net185 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6990_ _2617_ _2618_ _2619_ VGND VGND VPWR VPWR _2620_ sky130_fd_sc_hd__or3_1
XFILLER_65_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5941_ _1447_ _1470_ _1569_ _1570_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__a211o_1
XFILLER_25_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8660_ _4106_ _4216_ net105 VGND VGND VPWR VPWR _4217_ sky130_fd_sc_hd__mux2_1
XFILLER_61_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5872_ _1486_ _1487_ _1500_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__o21a_1
X_8591_ net106 _4156_ _4155_ net193 VGND VGND VPWR VPWR _4157_ sky130_fd_sc_hd__a211oi_1
X_7611_ _3240_ VGND VGND VPWR VPWR _3241_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_44_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4823_ _0442_ _0452_ _4509_ _4543_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a211o_1
X_4754_ net211 net219 net370 net377 VGND VGND VPWR VPWR _4525_ sky130_fd_sc_hd__and4_1
X_7542_ _3162_ _3171_ net109 VGND VGND VPWR VPWR _3172_ sky130_fd_sc_hd__mux2_1
X_7473_ _3080_ _3102_ VGND VGND VPWR VPWR _3103_ sky130_fd_sc_hd__nand2_1
X_9212_ clknet_leaf_1_clk net6 _0122_ VGND VGND VPWR VPWR adder_inst.i_a\[14\] sky130_fd_sc_hd__dfrtp_1
X_4685_ net364 net235 net370 net229 VGND VGND VPWR VPWR _4456_ sky130_fd_sc_hd__a22oi_1
XFILLER_108_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6424_ _1980_ _2052_ _2053_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__nand3_1
X_9143_ net533 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__inv_2
X_6355_ net433 net312 VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__nand2_1
X_9074_ net545 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__inv_2
XFILLER_88_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5306_ _0933_ _0934_ _0928_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__a21bo_1
X_6286_ _1831_ _1833_ _1832_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__o21ai_1
X_8025_ net486 net491 net495 net179 _3610_ VGND VGND VPWR VPWR _3611_ sky130_fd_sc_hd__a221o_1
X_5237_ _0769_ _0775_ _0855_ _0864_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_110_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5168_ net388 net278 VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nand2_1
XFILLER_110_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5099_ _0726_ _0727_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8927_ net512 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
XFILLER_71_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8858_ net661 mul_res\[10\] net504 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__mux2_1
X_8789_ _2547_ _4288_ _4290_ _2542_ _4295_ VGND VGND VPWR VPWR _4296_ sky130_fd_sc_hd__a221o_1
X_7809_ adder_inst.exp_larger_r\[1\] net202 VGND VGND VPWR VPWR _3415_ sky130_fd_sc_hd__or2_1
XFILLER_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 adder_inst.i_vld_r VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_47_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6140_ _1767_ _1768_ _1760_ _1765_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__o211a_1
XFILLER_57_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6071_ _1694_ _1697_ _1699_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__a211oi_2
X_5022_ _0650_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__or2_1
XFILLER_66_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6973_ net389 net294 VGND VGND VPWR VPWR _2603_ sky130_fd_sc_hd__nand2_1
X_8712_ _4082_ _4262_ VGND VGND VPWR VPWR adder_inst.sum_raw\[22\] sky130_fd_sc_hd__xor2_1
X_5924_ _1451_ _1453_ _1452_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8643_ _4104_ _4201_ net105 VGND VGND VPWR VPWR _4202_ sky130_fd_sc_hd__mux2_1
X_5855_ _1482_ _1483_ _1475_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__a21o_1
X_4806_ _0421_ _0422_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__or3_1
X_8574_ _3894_ _4135_ _3892_ VGND VGND VPWR VPWR _4142_ sky130_fd_sc_hd__o21ai_1
X_5786_ _1358_ _1360_ _1359_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a21bo_1
X_7525_ _4354_ _3154_ VGND VGND VPWR VPWR _3155_ sky130_fd_sc_hd__xor2_1
X_4737_ _4479_ _4506_ VGND VGND VPWR VPWR _4508_ sky130_fd_sc_hd__xnor2_1
XFILLER_107_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7456_ _3084_ _3085_ VGND VGND VPWR VPWR _3086_ sky130_fd_sc_hd__xor2_4
X_4668_ net207 net403 VGND VGND VPWR VPWR _4439_ sky130_fd_sc_hd__nand2_1
XFILLER_107_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6407_ _1943_ _1945_ _1961_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__a21oi_1
X_9126_ net538 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__inv_2
XFILLER_88_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7387_ _2581_ _2785_ _2784_ VGND VGND VPWR VPWR _3017_ sky130_fd_sc_hd__a21oi_2
X_4599_ _4359_ _4369_ _4360_ VGND VGND VPWR VPWR _4370_ sky130_fd_sc_hd__a21o_2
X_6338_ _1883_ _1884_ _1876_ _1878_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__o211a_1
X_9057_ net535 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__inv_2
X_6269_ _1815_ _1897_ _1896_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8008_ _3414_ _3595_ VGND VGND VPWR VPWR _3596_ sky130_fd_sc_hd__or2_1
XFILLER_76_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5640_ _1261_ _1267_ _1268_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__and3_1
X_5571_ _1197_ _1199_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8290_ net141 _3768_ _3787_ net146 VGND VGND VPWR VPWR _3863_ sky130_fd_sc_hd__a211o_1
X_7310_ _2930_ _2934_ _2933_ VGND VGND VPWR VPWR _2940_ sky130_fd_sc_hd__a21o_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7241_ _2835_ _2836_ _2869_ _2870_ VGND VGND VPWR VPWR _2871_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_96_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7172_ _0960_ _0968_ _0967_ VGND VGND VPWR VPWR _2802_ sky130_fd_sc_hd__o21ai_1
X_6123_ _1654_ _1750_ _1749_ _1735_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__o211a_1
XFILLER_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6054_ _1681_ _1683_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5005_ _0632_ _0633_ _0628_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a21o_1
XFILLER_39_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6956_ _1516_ _1518_ _1517_ VGND VGND VPWR VPWR _2586_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_62_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5907_ _1534_ _1535_ _1536_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__nand3b_1
XFILLER_41_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6887_ _2501_ _2502_ VGND VGND VPWR VPWR _2517_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_24_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8626_ _3993_ _3994_ VGND VGND VPWR VPWR _4187_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_52_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5838_ _1449_ _1466_ _1467_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8557_ _3849_ _3852_ VGND VGND VPWR VPWR _4127_ sky130_fd_sc_hd__nand2_1
X_5769_ net264 net270 net424 net430 VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__and4_1
X_7508_ _3135_ _3137_ VGND VGND VPWR VPWR _3138_ sky130_fd_sc_hd__nor2_1
XFILLER_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8488_ net166 _4059_ _4060_ VGND VGND VPWR VPWR _4061_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7439_ _4536_ _3067_ VGND VGND VPWR VPWR _3069_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_73_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9109_ net531 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__inv_2
XFILLER_76_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6810_ _2433_ _2438_ _2439_ VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__and3_1
X_7790_ net201 _3395_ VGND VGND VPWR VPWR _3396_ sky130_fd_sc_hd__or2_1
XFILLER_63_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6741_ _2356_ _2364_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__xnor2_1
X_6672_ _2295_ _2300_ _2301_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__and3_1
X_9460_ clknet_leaf_19_clk _0078_ _0370_ VGND VGND VPWR VPWR mul_res\[15\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_21_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9391_ clknet_leaf_13_clk adder_inst.exp_larger\[5\] _0301_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_98_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8411_ _3980_ _3982_ VGND VGND VPWR VPWR _3984_ sky130_fd_sc_hd__nand2_1
X_5623_ _1193_ _1209_ _1250_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__a211o_1
XFILLER_31_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8342_ net150 _3844_ _3914_ net126 VGND VGND VPWR VPWR _3915_ sky130_fd_sc_hd__a211o_1
X_5554_ _1178_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__and2b_1
XFILLER_105_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8273_ net150 _3844_ _3845_ VGND VGND VPWR VPWR _3846_ sky130_fd_sc_hd__o21ai_1
X_5485_ _1113_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__nand2b_1
XFILLER_116_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7224_ _2853_ _2849_ VGND VGND VPWR VPWR _2854_ sky130_fd_sc_hd__and2b_1
Xfanout514 net515 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__clkbuf_4
Xfanout503 adder_inst.sum_raw_r\[17\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_2
X_7155_ _2682_ _2783_ VGND VGND VPWR VPWR _2785_ sky130_fd_sc_hd__xor2_1
Xfanout547 net548 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__clkbuf_4
XFILLER_98_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout536 net549 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__clkbuf_2
Xfanout525 net536 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__buf_4
X_6106_ _1637_ _1734_ _1733_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__a21o_1
XFILLER_86_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7086_ net396 net282 net288 net389 VGND VGND VPWR VPWR _2716_ sky130_fd_sc_hd__a22oi_2
XFILLER_100_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6037_ net258 net453 _1255_ _1256_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_100_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_107_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7988_ adder_inst.sum_raw_r\[12\] _3504_ _3577_ _3578_ VGND VGND VPWR VPWR _3579_
+ sky130_fd_sc_hd__o211a_1
XFILLER_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6939_ _2193_ _2247_ _2248_ _2189_ VGND VGND VPWR VPWR _2569_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_37_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8609_ _3947_ _4172_ VGND VGND VPWR VPWR adder_inst.sum_raw\[9\] sky130_fd_sc_hd__xnor2_1
XFILLER_22_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5270_ _0805_ _0898_ _0897_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a21o_1
XFILLER_102_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8960_ net532 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__inv_2
XFILLER_68_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7911_ adder_inst.sum_raw_r\[1\] net497 _3404_ adder_inst.sum_raw_r\[0\] net493 VGND
+ VGND VPWR VPWR _3512_ sky130_fd_sc_hd__a221o_1
XFILLER_55_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8891_ net508 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__inv_2
XFILLER_48_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7842_ net202 adder_inst.exp_larger_r\[3\] _3406_ _3398_ VGND VGND VPWR VPWR _3448_
+ sky130_fd_sc_hd__a31o_1
XFILLER_24_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7773_ multiplier_inst.exp_final\[5\] _3380_ _3381_ _3378_ VGND VGND VPWR VPWR multiplier_inst.overflow_calc
+ sky130_fd_sc_hd__a31o_1
X_4985_ _0612_ _0613_ _0607_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a21o_1
XFILLER_51_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6724_ _2236_ _2353_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_34_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9443_ clknet_leaf_10_clk net182 _0353_ VGND VGND VPWR VPWR multiplier_inst.sign_res_r
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6655_ net300 net308 net461 net468 VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__and4_1
X_9374_ clknet_leaf_15_clk _0048_ _0284_ VGND VGND VPWR VPWR add_res\[20\] sky130_fd_sc_hd__dfrtp_1
X_6586_ _2213_ _2215_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__and2_1
X_5606_ _1216_ _1222_ _1234_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__nand3_1
X_8325_ net148 _3814_ _3815_ VGND VGND VPWR VPWR _3898_ sky130_fd_sc_hd__and3_1
X_5537_ _1163_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__xnor2_1
X_8256_ _3822_ _3823_ _3825_ _3826_ VGND VGND VPWR VPWR _3829_ sky130_fd_sc_hd__or4_1
XFILLER_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5468_ _1089_ _1091_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__nand2b_1
X_7207_ _0928_ _0934_ _0933_ VGND VGND VPWR VPWR _2837_ sky130_fd_sc_hd__a21o_1
X_8187_ adder_inst.man_b_r\[23\] net349 net162 VGND VGND VPWR VPWR _3761_ sky130_fd_sc_hd__mux2_1
Xfanout300 net301 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_2
X_5399_ _0979_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__and2_1
Xfanout311 adder_inst.man_b_r\[5\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout322 net323 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__buf_2
XFILLER_98_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout355 adder_inst.man_a_r\[22\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout366 net367 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout344 net348 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_2
X_7138_ _2750_ _2751_ _2766_ VGND VGND VPWR VPWR _2768_ sky130_fd_sc_hd__o21a_1
Xfanout333 net334 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_2
XFILLER_86_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7069_ _2604_ _2606_ VGND VGND VPWR VPWR _2699_ sky130_fd_sc_hd__nand2_1
Xfanout388 net390 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__clkbuf_4
Xfanout399 net401 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_2
Xfanout377 net380 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_2
XFILLER_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput19 i_a[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_111_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4770_ _4538_ _4539_ _4474_ _4477_ VGND VGND VPWR VPWR _4541_ sky130_fd_sc_hd__a211o_1
X_6440_ net296 net458 _2068_ _2066_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__a31o_1
X_6371_ _1911_ _1913_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_11_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8110_ _3342_ _3664_ _3682_ VGND VGND VPWR VPWR _3684_ sky130_fd_sc_hd__a21o_1
X_5322_ _0945_ _0950_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__xnor2_1
XFILLER_114_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9090_ net538 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__inv_2
X_8041_ net191 _3622_ _3624_ _3619_ VGND VGND VPWR VPWR _3625_ sky130_fd_sc_hd__a31o_1
XFILLER_87_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5253_ _0785_ _0881_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nand3_1
X_5184_ _0794_ _0807_ _0813_ _0591_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a211oi_1
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8943_ net519 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__inv_2
XFILLER_56_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8874_ net707 mul_res\[26\] net506 VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_104_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7825_ _3430_ VGND VGND VPWR VPWR _3431_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7756_ adder_inst.is_inf_b_r adder_inst.is_inf_a_r VGND VGND VPWR VPWR _3372_ sky130_fd_sc_hd__nor2_1
X_4968_ _0551_ _0553_ _0550_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__o21ba_1
X_7687_ _3309_ _3310_ VGND VGND VPWR VPWR _3313_ sky130_fd_sc_hd__xnor2_1
X_6707_ _2278_ _2321_ _2336_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__nand3_2
X_4899_ net255 net400 net407 net250 VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a22oi_1
X_6638_ net440 net336 net342 net434 VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__a22oi_2
X_9426_ clknet_leaf_17_clk multiplier_inst.man_final\[14\] _0336_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[14\] sky130_fd_sc_hd__dfrtp_1
X_9357_ clknet_leaf_20_clk _0061_ _0267_ VGND VGND VPWR VPWR add_res\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_115_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8308_ net319 net161 VGND VGND VPWR VPWR _3881_ sky130_fd_sc_hd__nand2_1
X_6569_ _2196_ _2197_ _2198_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__or3_1
XFILLER_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9288_ clknet_leaf_22_clk net588 _0198_ VGND VGND VPWR VPWR adder_inst.man_a_r\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8239_ _4358_ net156 net154 net153 _3736_ VGND VGND VPWR VPWR _3812_ sky130_fd_sc_hd__o41a_1
XFILLER_78_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout130 net131 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout141 _3710_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_2
Xfanout163 net166 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_4
Xfanout185 _4270_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_2
Xfanout196 _4344_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__buf_2
XFILLER_47_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5940_ _1545_ _1546_ _1568_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__a21oi_1
XFILLER_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7610_ net113 _3237_ _3239_ VGND VGND VPWR VPWR _3240_ sky130_fd_sc_hd__o21ai_1
X_5871_ _1486_ _1487_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_16_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8590_ _3925_ _4150_ _3924_ VGND VGND VPWR VPWR _4156_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_44_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4822_ _0449_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nand2_1
X_4753_ _4521_ _4522_ VGND VGND VPWR VPWR _4524_ sky130_fd_sc_hd__xnor2_1
X_7541_ _3019_ _3170_ VGND VGND VPWR VPWR _3171_ sky130_fd_sc_hd__xnor2_2
X_7472_ _3078_ _3079_ VGND VGND VPWR VPWR _3102_ sky130_fd_sc_hd__nand2_1
X_9211_ clknet_leaf_8_clk net5 _0121_ VGND VGND VPWR VPWR adder_inst.i_a\[13\] sky130_fd_sc_hd__dfrtp_1
X_6423_ _1977_ _1979_ _1978_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__o21ai_1
X_4684_ net229 net364 net235 net370 VGND VGND VPWR VPWR _4455_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9142_ net533 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__inv_2
X_6354_ _1895_ _1982_ _1981_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__a21o_1
X_9073_ net545 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__inv_2
X_6285_ _1900_ _1902_ _1901_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__o21bai_1
X_5305_ _0928_ _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nand3_1
X_8024_ net497 net196 net191 _3609_ VGND VGND VPWR VPWR _3610_ sky130_fd_sc_hd__o211a_1
XFILLER_88_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5236_ _0855_ _0864_ _0769_ _0775_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_110_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_3_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5167_ net376 net383 net283 net289 VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and4_1
XFILLER_110_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5098_ _0669_ _0671_ _0726_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a21o_1
XFILLER_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8926_ net508 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__inv_2
XFILLER_71_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8857_ add_res\[9\] net683 net504 VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__mux2_1
XFILLER_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8788_ _2537_ _2545_ _4294_ VGND VGND VPWR VPWR _4295_ sky130_fd_sc_hd__a21oi_1
X_7808_ net492 net488 VGND VGND VPWR VPWR _3414_ sky130_fd_sc_hd__or2_2
X_7739_ adder_inst.i_b\[9\] adder_inst.i_b\[10\] adder_inst.i_b\[12\] adder_inst.i_b\[15\]
+ VGND VGND VPWR VPWR _3358_ sky130_fd_sc_hd__or4_1
XFILLER_8_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9409_ clknet_leaf_11_clk _0069_ _0319_ VGND VGND VPWR VPWR multiplier_inst.is_inf_r
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_116_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold8 adder_inst.i_b\[31\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_87_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_67_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_76_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6070_ _1279_ _1698_ _1673_ _1671_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__o211a_1
XFILLER_112_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5021_ net221 net418 net421 net215 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_49_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8711_ _4259_ _4261_ _3355_ VGND VGND VPWR VPWR _4262_ sky130_fd_sc_hd__mux2_1
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6972_ _1523_ _1525_ _1524_ VGND VGND VPWR VPWR _2602_ sky130_fd_sc_hd__o21bai_1
X_5923_ _1550_ _1551_ _1549_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__o21ai_1
X_8642_ _3988_ _4186_ _4200_ VGND VGND VPWR VPWR _4201_ sky130_fd_sc_hd__o21ai_1
X_5854_ _1475_ _1482_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__nand3_1
X_8573_ net193 _4139_ _4140_ VGND VGND VPWR VPWR _4141_ sky130_fd_sc_hd__and3_1
X_4805_ _0429_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__xnor2_1
X_7524_ net175 net114 VGND VGND VPWR VPWR _3154_ sky130_fd_sc_hd__nand2_1
X_5785_ _1364_ _1369_ _1363_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__a21bo_1
X_4736_ _4479_ _4506_ VGND VGND VPWR VPWR _4507_ sky130_fd_sc_hd__nor2_1
X_7455_ net206 net370 VGND VGND VPWR VPWR _3085_ sky130_fd_sc_hd__nand2_2
X_4667_ _4436_ _4437_ VGND VGND VPWR VPWR _4438_ sky130_fd_sc_hd__nor2_1
X_6406_ _2029_ _2034_ _2035_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__nand3_2
X_7386_ _3010_ _3011_ VGND VGND VPWR VPWR _3016_ sky130_fd_sc_hd__xnor2_2
X_9125_ net539 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__inv_2
XFILLER_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4598_ _4366_ _4368_ VGND VGND VPWR VPWR _4369_ sky130_fd_sc_hd__nand2_1
X_6337_ _1957_ _1960_ _1964_ _1965_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__o211ai_1
X_9056_ net533 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__inv_2
X_6268_ _1815_ _1896_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__nand3_1
X_8007_ adder_inst.sum_raw_r\[15\] net493 _3593_ _3594_ VGND VGND VPWR VPWR _3595_
+ sky130_fd_sc_hd__a22o_1
XFILLER_57_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5219_ _0833_ _0834_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nor3_1
X_6199_ _1828_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__inv_2
XFILLER_29_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8909_ net522 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__inv_2
XFILLER_44_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5570_ _1197_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__and2b_1
XFILLER_116_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7240_ _2867_ _2868_ _2865_ VGND VGND VPWR VPWR _2870_ sky130_fd_sc_hd__a21o_1
XFILLER_116_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_84_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7171_ _0971_ _0972_ _0963_ _0966_ VGND VGND VPWR VPWR _2801_ sky130_fd_sc_hd__o211ai_1
X_6122_ _1735_ _1749_ _1750_ _1654_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__a211o_1
XFILLER_105_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6053_ _1681_ _1682_ net258 net459 VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__and4bb_1
X_5004_ _0628_ _0632_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nand3_1
XFILLER_39_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6955_ _1522_ _1527_ _1521_ VGND VGND VPWR VPWR _2585_ sky130_fd_sc_hd__a21bo_1
X_5906_ net388 net298 net304 net382 VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__a22o_1
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6886_ _2509_ _2515_ VGND VGND VPWR VPWR _2516_ sky130_fd_sc_hd__or2_1
X_8625_ _4010_ _4177_ _4185_ VGND VGND VPWR VPWR _4186_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_24_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5837_ _1464_ _1465_ _1450_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__a21o_1
X_8556_ _4120_ _4121_ _3855_ VGND VGND VPWR VPWR _4126_ sky130_fd_sc_hd__a21o_1
X_5768_ net259 net436 VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__nand2_1
X_8487_ net227 net171 VGND VGND VPWR VPWR _4060_ sky130_fd_sc_hd__or2_1
X_4719_ net359 net229 net365 net235 VGND VGND VPWR VPWR _4490_ sky130_fd_sc_hd__and4_1
X_7507_ _3098_ _3099_ _3134_ VGND VGND VPWR VPWR _3137_ sky130_fd_sc_hd__o21a_1
X_5699_ net393 net310 VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__nand2_1
X_7438_ _4536_ _3065_ _3066_ VGND VGND VPWR VPWR _3068_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_73_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7369_ _2992_ _2994_ VGND VGND VPWR VPWR _2999_ sky130_fd_sc_hd__nand2_1
X_9108_ net526 VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__inv_2
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9039_ net520 VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__inv_2
XFILLER_103_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6740_ _2316_ _2366_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__xnor2_2
XFILLER_63_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6671_ _2226_ _2263_ _2280_ _2294_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_21_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9390_ clknet_leaf_13_clk adder_inst.exp_larger\[4\] _0300_ VGND VGND VPWR VPWR adder_inst.exp_larger_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_8410_ _3982_ VGND VGND VPWR VPWR _3983_ sky130_fd_sc_hd__inv_2
X_5622_ _1235_ _1236_ _1249_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_98_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8341_ net146 _3773_ _3837_ net130 VGND VGND VPWR VPWR _3914_ sky130_fd_sc_hd__o211a_1
X_5553_ _1179_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__xnor2_1
X_8272_ net146 _3763_ net130 VGND VGND VPWR VPWR _3845_ sky130_fd_sc_hd__a21o_1
X_5484_ _1085_ _1108_ _1112_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__or3_1
X_7223_ _2850_ _2852_ VGND VGND VPWR VPWR _2853_ sky130_fd_sc_hd__nor2_1
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout515 net524 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__buf_4
Xfanout504 net505 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_4
X_7154_ _2682_ _2783_ VGND VGND VPWR VPWR _2784_ sky130_fd_sc_hd__nor2_1
Xfanout548 net549 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__clkbuf_4
Xfanout537 net549 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__buf_4
XFILLER_113_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout526 net536 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_2
X_6105_ _1637_ _1733_ _1734_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__nand3_2
XFILLER_98_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7085_ net389 net396 net282 net288 VGND VGND VPWR VPWR _2715_ sky130_fd_sc_hd__and4_1
X_6036_ _1659_ _1664_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_57_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_107_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7987_ adder_inst.sum_raw_r\[14\] net196 net176 adder_inst.sum_raw_r\[13\] net190
+ VGND VGND VPWR VPWR _3578_ sky130_fd_sc_hd__o221a_1
X_6938_ _2313_ _2567_ _2311_ VGND VGND VPWR VPWR _2568_ sky130_fd_sc_hd__a21o_2
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6869_ net326 net482 VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__nand2_1
X_8608_ net193 _4168_ _4171_ VGND VGND VPWR VPWR _4172_ sky130_fd_sc_hd__o21ai_1
XFILLER_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8539_ _4083_ _4085_ _4079_ VGND VGND VPWR VPWR _4112_ sky130_fd_sc_hd__a21o_1
XFILLER_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7910_ net115 _3508_ _3511_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__and3_1
X_8890_ net511 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__inv_2
X_7841_ net498 _3408_ VGND VGND VPWR VPWR _3447_ sky130_fd_sc_hd__nor2_1
XFILLER_36_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7772_ _3291_ _3313_ _3348_ _3350_ _3325_ VGND VGND VPWR VPWR _3381_ sky130_fd_sc_hd__o221a_1
X_4984_ _0607_ _0612_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__nand3_1
X_6723_ net291 net475 net480 net284 VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_34_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9442_ clknet_leaf_11_clk multiplier_inst.exp_final\[7\] _0352_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[7\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6654_ _2281_ _2282_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_62_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5605_ _1216_ _1222_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__a21o_1
X_9373_ clknet_leaf_15_clk _0046_ _0283_ VGND VGND VPWR VPWR add_res\[19\] sky130_fd_sc_hd__dfrtp_1
X_6585_ _2144_ _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__and2b_1
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8324_ _3896_ VGND VGND VPWR VPWR _3897_ sky130_fd_sc_hd__inv_2
X_5536_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__nor2_1
X_8255_ _3824_ _3827_ VGND VGND VPWR VPWR _3828_ sky130_fd_sc_hd__and2b_1
X_5467_ _1065_ _1087_ _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__or3_4
X_7206_ _0915_ _2804_ _2819_ _2834_ VGND VGND VPWR VPWR _2836_ sky130_fd_sc_hd__o211ai_2
XFILLER_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8186_ _3677_ _3745_ _3758_ net121 VGND VGND VPWR VPWR _3760_ sky130_fd_sc_hd__a31o_1
Xfanout301 net302 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout312 net313 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5398_ net151 _1019_ _1027_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_6_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout323 net327 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_1
XFILLER_101_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7137_ _2750_ _2751_ _2766_ VGND VGND VPWR VPWR _2767_ sky130_fd_sc_hd__nor3_1
Xfanout334 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__clkbuf_2
Xfanout345 net346 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__buf_2
Xfanout356 net361 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__buf_2
XFILLER_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout367 adder_inst.man_a_r\[20\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout378 net380 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_21_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7068_ _2694_ _2695_ VGND VGND VPWR VPWR _2698_ sky130_fd_sc_hd__xnor2_1
Xfanout389 net390 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkbuf_4
X_6019_ _1171_ _1648_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__nor2_1
XFILLER_46_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6370_ _1985_ _1987_ _1986_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_11_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5321_ _0945_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__nand2_1
XFILLER_114_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8040_ net498 net196 _3428_ _3623_ net492 VGND VGND VPWR VPWR _3624_ sky130_fd_sc_hd__a221o_1
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5252_ _0782_ _0784_ _0783_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__o21ai_1
XFILLER_87_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5183_ _0576_ _0577_ _0590_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a21oi_1
XFILLER_96_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8942_ net519 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__inv_2
XFILLER_113_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8873_ net644 mul_res\[25\] net506 VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__mux2_1
XFILLER_36_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7824_ net502 net500 VGND VGND VPWR VPWR _3430_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_19_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7755_ adder_inst.is_zero_b_r net700 VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__and2_1
X_4967_ _0595_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and2b_1
XFILLER_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7686_ _3302_ _3311_ VGND VGND VPWR VPWR _3312_ sky130_fd_sc_hd__xnor2_1
X_6706_ _2333_ _2334_ _2328_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__a21bo_1
X_4898_ net242 net411 VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__nand2_1
X_6637_ net446 net330 VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__nand2_1
X_9425_ clknet_leaf_19_clk multiplier_inst.man_final\[13\] _0335_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[13\] sky130_fd_sc_hd__dfrtp_1
X_6568_ net434 net337 net343 net426 VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__a22oi_2
X_9356_ clknet_leaf_20_clk _0058_ _0266_ VGND VGND VPWR VPWR add_res\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_115_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8307_ _3876_ _3877_ VGND VGND VPWR VPWR _3880_ sky130_fd_sc_hd__xor2_2
X_5519_ _1147_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__nor2_1
XFILLER_3_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9287_ clknet_leaf_14_clk adder_inst.sum_raw\[24\] _0197_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[24\]
+ sky130_fd_sc_hd__dfrtp_1
X_6499_ _2051_ _2127_ _2128_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__nand3_1
XFILLER_3_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8238_ net149 _3809_ _3810_ VGND VGND VPWR VPWR _3811_ sky130_fd_sc_hd__and3_1
Xfanout131 _3703_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlymetal6s2s_1
X_8169_ net137 _3742_ _3740_ net144 VGND VGND VPWR VPWR _3743_ sky130_fd_sc_hd__o211a_1
Xfanout142 net143 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_2
Xfanout153 _3698_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_2
Xfanout164 net166 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout175 _4357_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_4
Xfanout197 _4343_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_4
Xfanout186 _4269_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_22_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_11_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5870_ _1495_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__xnor2_1
XFILLER_73_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4821_ _0442_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2_1
XFILLER_21_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_4752_ _4522_ _4521_ VGND VGND VPWR VPWR _4523_ sky130_fd_sc_hd__and2b_1
X_7540_ _2574_ _2795_ _2799_ _3022_ VGND VGND VPWR VPWR _3170_ sky130_fd_sc_hd__a31oi_4
X_7471_ _3100_ VGND VGND VPWR VPWR _3101_ sky130_fd_sc_hd__inv_2
X_4683_ _4451_ _4452_ VGND VGND VPWR VPWR _4454_ sky130_fd_sc_hd__xor2_1
X_6422_ _2049_ _2050_ _2048_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__o21bai_1
X_9210_ clknet_leaf_0_clk net4 _0120_ VGND VGND VPWR VPWR adder_inst.i_a\[12\] sky130_fd_sc_hd__dfrtp_1
X_9141_ net528 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__inv_2
X_6353_ _1895_ _1981_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__nand3_1
X_9072_ net545 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__inv_2
X_6284_ net295 net444 _1912_ _1910_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__a31o_1
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5304_ _0828_ _0927_ _0926_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21o_1
X_8023_ _4342_ _3608_ _3607_ net489 VGND VGND VPWR VPWR _3609_ sky130_fd_sc_hd__a211o_1
X_5235_ _0855_ _0862_ _0863_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_110_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5166_ _0495_ _0497_ _0496_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o21ai_1
X_5097_ _0669_ _0671_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nand2_1
X_8925_ net508 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__inv_2
XFILLER_71_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8856_ add_res\[8\] net676 net504 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__mux2_1
X_8787_ _4293_ _2537_ _2542_ VGND VGND VPWR VPWR _4294_ sky130_fd_sc_hd__nor3b_1
X_7807_ net491 net490 VGND VGND VPWR VPWR _3413_ sky130_fd_sc_hd__nor2_2
XFILLER_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5999_ net393 net328 _1285_ _1287_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__a22o_1
X_7738_ adder_inst.i_b\[1\] adder_inst.i_b\[0\] adder_inst.i_b\[3\] adder_inst.i_b\[2\]
+ VGND VGND VPWR VPWR _3357_ sky130_fd_sc_hd__or4_1
X_9408_ clknet_leaf_11_clk net701 _0318_ VGND VGND VPWR VPWR multiplier_inst.is_zero_r
+ sky130_fd_sc_hd__dfrtp_1
X_7669_ adder_inst.exp_b_r\[5\] adder_inst.exp_a_r\[5\] VGND VGND VPWR VPWR _3295_
+ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_104_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9339_ clknet_leaf_3_clk net575 _0249_ VGND VGND VPWR VPWR adder_inst.man_b_r\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold9 adder_inst.exp_b\[6\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5020_ net215 net221 net417 net421 VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__and4_1
XFILLER_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_2_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8710_ _4074_ _4254_ _4260_ VGND VGND VPWR VPWR _4261_ sky130_fd_sc_hd__a21o_1
XFILLER_93_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6971_ _1535_ _1537_ VGND VGND VPWR VPWR _2601_ sky130_fd_sc_hd__nand2_1
XFILLER_80_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5922_ _1549_ _1550_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__or3_1
XFILLER_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8641_ _3974_ _3984_ _3985_ VGND VGND VPWR VPWR _4200_ sky130_fd_sc_hd__a21o_1
X_5853_ _1480_ _1481_ _1476_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__a21o_1
X_8572_ _3889_ _3891_ VGND VGND VPWR VPWR _4140_ sky130_fd_sc_hd__nand2_1
XFILLER_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4804_ _0432_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__xnor2_1
X_5784_ _1281_ _1411_ _1412_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__nor4_1
X_4735_ _4504_ _4505_ VGND VGND VPWR VPWR _4506_ sky130_fd_sc_hd__nand2_1
X_7523_ net109 VGND VGND VPWR VPWR _3153_ sky130_fd_sc_hd__inv_2
X_7454_ _3082_ _3083_ VGND VGND VPWR VPWR _3084_ sky130_fd_sc_hd__or2_2
X_4666_ net218 net389 net396 net212 VGND VGND VPWR VPWR _4437_ sky130_fd_sc_hd__a22oi_1
X_6405_ _1941_ _2028_ _2026_ _2009_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__a211o_1
X_7385_ _3013_ _3014_ VGND VGND VPWR VPWR _3015_ sky130_fd_sc_hd__and2b_1
X_4597_ _4359_ _4360_ _4367_ VGND VGND VPWR VPWR _4368_ sky130_fd_sc_hd__o21a_1
X_9124_ net540 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__inv_2
X_6336_ _1957_ _1960_ _1964_ _1965_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__o211a_1
X_9055_ net533 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__inv_2
XFILLER_1_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6267_ _1812_ _1814_ _1813_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__o21ai_1
X_8006_ _4338_ _3432_ _3524_ adder_inst.sum_raw_r\[12\] VGND VGND VPWR VPWR _3594_
+ sky130_fd_sc_hd__o2bb2a_1
XFILLER_69_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5218_ _0841_ _0846_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__xnor2_1
X_6198_ _1732_ _1826_ _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__nand3_1
XFILLER_69_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5149_ _0460_ _0462_ _0461_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__o21ai_1
XFILLER_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8908_ net522 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__inv_2
XFILLER_72_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8839_ _3244_ _3257_ _3260_ _3253_ VGND VGND VPWR VPWR _4328_ sky130_fd_sc_hd__a31o_1
XFILLER_52_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7170_ _2795_ _2799_ VGND VGND VPWR VPWR _2800_ sky130_fd_sc_hd__nand2_1
X_6121_ _1735_ _1749_ _1750_ _1654_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a211oi_1
XFILLER_105_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6052_ net271 net447 net453 net265 VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__a22oi_1
X_5003_ _0630_ _0631_ _0629_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a21bo_1
XFILLER_66_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6954_ _1531_ _1542_ _1530_ VGND VGND VPWR VPWR _2584_ sky130_fd_sc_hd__a21boi_2
XFILLER_81_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5905_ net382 net387 net299 net304 VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__nand4_1
X_6885_ _2478_ _2485_ _2487_ _2508_ VGND VGND VPWR VPWR _2515_ sky130_fd_sc_hd__a22oi_1
X_8624_ _3996_ _4006_ _3995_ VGND VGND VPWR VPWR _4185_ sky130_fd_sc_hd__a21o_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5836_ _1450_ _1464_ _1465_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__nand3_2
X_8555_ _3855_ _4125_ VGND VGND VPWR VPWR adder_inst.sum_raw\[2\] sky130_fd_sc_hd__xor2_1
X_5767_ _1394_ _1395_ _1390_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a21o_1
X_8486_ net125 net122 _3886_ VGND VGND VPWR VPWR _4059_ sky130_fd_sc_hd__and3_1
X_7506_ _3059_ _3086_ _3089_ _3096_ _3097_ VGND VGND VPWR VPWR _3136_ sky130_fd_sc_hd__a32oi_4
X_4718_ _4487_ _4488_ VGND VGND VPWR VPWR _4489_ sky130_fd_sc_hd__nand2_1
X_5698_ _1325_ _1326_ _1321_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__a21o_1
X_7437_ _3065_ _3066_ VGND VGND VPWR VPWR _3067_ sky130_fd_sc_hd__and2_1
X_4649_ _4414_ _4418_ _4419_ VGND VGND VPWR VPWR _4420_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_73_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7368_ _2996_ _2997_ VGND VGND VPWR VPWR _2998_ sky130_fd_sc_hd__nand2_1
X_6319_ _1946_ _1948_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__and2b_1
X_9107_ net525 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__inv_2
X_7299_ _2914_ _2915_ _2928_ VGND VGND VPWR VPWR _2929_ sky130_fd_sc_hd__nor3_1
X_9038_ net538 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__inv_2
XFILLER_76_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6670_ _2298_ _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5621_ _1235_ _1236_ _1249_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__nand3_1
XFILLER_31_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8340_ net148 _3841_ _3912_ net127 VGND VGND VPWR VPWR _3913_ sky130_fd_sc_hd__a211o_1
X_5552_ _1180_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__and2b_1
X_8271_ _3766_ _3770_ net147 VGND VGND VPWR VPWR _3844_ sky130_fd_sc_hd__mux2_1
XFILLER_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5483_ _1108_ _1112_ _1085_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__o21a_1
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7222_ _2850_ _2851_ net223 net442 VGND VGND VPWR VPWR _2852_ sky130_fd_sc_hd__and4bb_1
Xfanout505 net507 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__clkbuf_4
X_7153_ _2775_ _2782_ VGND VGND VPWR VPWR _2783_ sky130_fd_sc_hd__xnor2_1
Xfanout538 net540 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__buf_4
XFILLER_113_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout516 net523 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__buf_4
Xfanout527 net530 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_4
X_7084_ net403 net278 VGND VGND VPWR VPWR _2714_ sky130_fd_sc_hd__nand2_1
X_6104_ _1630_ _1631_ _1636_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__a21o_1
Xfanout549 net67 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__clkbuf_4
X_6035_ _1664_ _1659_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__and2b_1
XFILLER_66_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_107_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7986_ adder_inst.sum_raw_r\[11\] net499 _3575_ _3576_ _3473_ VGND VGND VPWR VPWR
+ _3577_ sky130_fd_sc_hd__a221o_1
XFILLER_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6937_ _2369_ _2565_ _2368_ VGND VGND VPWR VPWR _2567_ sky130_fd_sc_hd__a21o_1
XFILLER_25_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_37_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6868_ net324 net474 net482 net317 VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__a22oi_1
XFILLER_22_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8607_ net180 _4169_ _4170_ VGND VGND VPWR VPWR _4171_ sky130_fd_sc_hd__or3_1
X_5819_ _1396_ _1403_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__nand2_1
XFILLER_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6799_ _2427_ _2428_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__xnor2_1
X_8538_ _4088_ _4110_ VGND VGND VPWR VPWR _4111_ sky130_fd_sc_hd__nand2b_1
XFILLER_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8469_ _4039_ _4040_ VGND VGND VPWR VPWR _4042_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_9_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput90 net90 VGND VGND VPWR VPWR o_res[2] sky130_fd_sc_hd__buf_2
XFILLER_110_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7840_ net502 _4341_ VGND VGND VPWR VPWR _3446_ sky130_fd_sc_hd__nand2_1
XFILLER_36_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7771_ _3289_ _3294_ _3379_ multiplier_inst.exp_final\[0\] VGND VGND VPWR VPWR _3380_
+ sky130_fd_sc_hd__and4b_1
X_4983_ _0610_ _0611_ _0608_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a21o_1
XFILLER_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6722_ _2337_ _2351_ _2293_ _2320_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_34_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9441_ clknet_leaf_10_clk multiplier_inst.exp_final\[6\] _0351_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6653_ _2281_ _2282_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_62_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5604_ _1232_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__or2_1
X_6584_ net295 net462 _2142_ _2143_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a22o_1
X_9372_ clknet_leaf_18_clk _0045_ _0282_ VGND VGND VPWR VPWR add_res\[18\] sky130_fd_sc_hd__dfrtp_1
X_8323_ _3880_ _3895_ VGND VGND VPWR VPWR _3896_ sky130_fd_sc_hd__nand2_1
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5535_ net409 net297 net305 net404 VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__a22oi_1
XFILLER_105_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8254_ _3825_ _3826_ VGND VGND VPWR VPWR _3827_ sky130_fd_sc_hd__nor2_1
X_5466_ _1091_ _1092_ _1094_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nand3_1
XFILLER_105_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7205_ _2819_ _2834_ _0915_ _2804_ VGND VGND VPWR VPWR _2835_ sky130_fd_sc_hd__a211o_1
XFILLER_99_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8185_ _3745_ _3758_ VGND VGND VPWR VPWR _3759_ sky130_fd_sc_hd__nand2_1
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__buf_2
Xfanout313 adder_inst.man_b_r\[5\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__buf_2
X_5397_ _1025_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_6_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout324 net325 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__buf_2
Xfanout335 net336 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__buf_2
XFILLER_98_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout357 net361 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkbuf_2
X_7136_ _2759_ _2764_ VGND VGND VPWR VPWR _2766_ sky130_fd_sc_hd__xnor2_1
Xfanout346 net347 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout379 net380 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__buf_2
X_7067_ _2694_ _2695_ VGND VGND VPWR VPWR _2697_ sky130_fd_sc_hd__nand2_1
Xfanout368 net373 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__buf_2
X_6018_ net419 net293 _1169_ _1170_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_67_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7969_ adder_inst.sum_raw_r\[8\] _4341_ net177 adder_inst.sum_raw_r\[7\] net198 VGND
+ VGND VPWR VPWR _3562_ sky130_fd_sc_hd__o221a_1
XFILLER_54_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 adder_inst.man_b_r\[0\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_11_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5320_ _0948_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__xnor2_1
X_5251_ net357 net310 _0879_ _0877_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a31o_1
X_5182_ _0791_ _0811_ _0759_ _0777_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a211oi_2
XFILLER_68_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8941_ net519 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__inv_2
XFILLER_56_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8872_ net709 mul_res\[24\] net506 VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__mux2_1
X_7823_ adder_inst.sum_raw_r\[0\] adder_inst.sum_raw_r\[1\] _3394_ _3428_ VGND VGND
+ VPWR VPWR _3429_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_19_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7754_ adder_inst.man_a\[23\] _3371_ VGND VGND VPWR VPWR adder_inst.is_zero_a sky130_fd_sc_hd__and2b_1
XFILLER_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6705_ _2328_ _2333_ _2334_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__nand3_1
X_4966_ _0558_ _0593_ _0594_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__or3b_1
X_7685_ _3309_ _3310_ _3307_ VGND VGND VPWR VPWR _3311_ sky130_fd_sc_hd__a21oi_1
X_4897_ net250 net255 net400 net407 VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__and4_1
XFILLER_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6636_ net433 net439 net335 net342 VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__and4_1
X_9424_ clknet_leaf_19_clk multiplier_inst.man_final\[12\] _0334_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[12\] sky130_fd_sc_hd__dfrtp_1
X_6567_ net440 net330 VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__nand2_1
X_9355_ clknet_leaf_20_clk _0047_ _0265_ VGND VGND VPWR VPWR add_res\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_115_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8306_ _3876_ _3877_ VGND VGND VPWR VPWR _3879_ sky130_fd_sc_hd__nor2_1
X_5518_ _0600_ _0772_ _0770_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a21oi_1
X_9286_ clknet_leaf_14_clk adder_inst.sum_raw\[23\] _0196_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[23\]
+ sky130_fd_sc_hd__dfrtp_2
X_6498_ _2048_ _2050_ _2049_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__o21ai_1
X_8237_ net138 _3771_ _3807_ net146 VGND VGND VPWR VPWR _3810_ sky130_fd_sc_hd__a211o_1
XFILLER_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5449_ _1070_ _1073_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a21o_1
XFILLER_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout121 _3732_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_2
X_8168_ _3741_ VGND VGND VPWR VPWR _3742_ sky130_fd_sc_hd__inv_2
XFILLER_59_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_2
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout154 _3694_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_2
Xfanout143 _3709_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__buf_2
XFILLER_86_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7119_ _2643_ _2651_ _2650_ VGND VGND VPWR VPWR _2749_ sky130_fd_sc_hd__a21bo_1
X_8099_ _3277_ _3653_ _3663_ _3278_ _3341_ VGND VGND VPWR VPWR _3673_ sky130_fd_sc_hd__a2111o_1
Xfanout198 _4340_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__buf_2
Xfanout176 _3463_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
Xfanout187 _4269_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_553 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4820_ _0440_ _0441_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nand2_1
XFILLER_21_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4751_ _4491_ _4493_ _4490_ VGND VGND VPWR VPWR _4522_ sky130_fd_sc_hd__o21ba_1
X_7470_ _3098_ _3099_ VGND VGND VPWR VPWR _3100_ sky130_fd_sc_hd__xor2_1
X_4682_ _4452_ _4451_ VGND VGND VPWR VPWR _4453_ sky130_fd_sc_hd__and2b_1
X_6421_ _2048_ _2049_ _2050_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__or3_1
X_9140_ net527 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__inv_2
XFILLER_108_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6352_ _1892_ _1894_ _1893_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__o21ai_1
X_9071_ net538 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__inv_2
X_6283_ _1910_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__and2b_1
X_5303_ _0929_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__nand2b_1
X_8022_ adder_inst.sum_raw_r\[14\] _3523_ _3605_ net197 VGND VGND VPWR VPWR _3608_
+ sky130_fd_sc_hd__a22o_1
X_5234_ _0855_ _0862_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_110_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5165_ _0507_ _0793_ _0792_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_110_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5096_ _0724_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__or2_1
X_8924_ net512 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__inv_2
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8855_ net712 mul_res\[7\] net504 VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__mux2_1
X_7806_ _3397_ _3411_ net492 VGND VGND VPWR VPWR _3412_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_65_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8786_ _2516_ _4292_ _2535_ VGND VGND VPWR VPWR _4293_ sky130_fd_sc_hd__a21oi_1
X_5998_ _1625_ _1626_ _1624_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__o21bai_1
X_7737_ adder_inst.i_b\[5\] adder_inst.i_b\[4\] adder_inst.i_b\[7\] adder_inst.i_b\[6\]
+ VGND VGND VPWR VPWR _3356_ sky130_fd_sc_hd__or4_1
X_4949_ net231 net237 net417 net421 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__and4_1
X_7668_ _3289_ _3294_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[2\] sky130_fd_sc_hd__and2b_1
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9407_ clknet_leaf_6_clk adder_inst.is_zero_b _0317_ VGND VGND VPWR VPWR adder_inst.is_zero_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_6619_ _2193_ _2247_ _2248_ _2189_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__or4bb_4
XFILLER_106_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7599_ _0458_ _1158_ _3035_ VGND VGND VPWR VPWR _3229_ sky130_fd_sc_hd__and3_1
XFILLER_106_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9338_ clknet_leaf_3_clk net568 _0248_ VGND VGND VPWR VPWR adder_inst.man_b_r\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_9269_ clknet_leaf_16_clk adder_inst.sum_raw\[6\] _0179_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[6\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_76_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap118 _3142_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6970_ _2585_ _2598_ VGND VGND VPWR VPWR _2600_ sky130_fd_sc_hd__xor2_2
XFILLER_26_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5921_ net406 net282 net288 net398 VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__a22oi_2
XFILLER_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8640_ _3987_ _4199_ VGND VGND VPWR VPWR adder_inst.sum_raw\[13\] sky130_fd_sc_hd__xnor2_1
X_5852_ _1476_ _1480_ _1481_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__nand3_1
X_8571_ _4133_ _4134_ _3895_ VGND VGND VPWR VPWR _4139_ sky130_fd_sc_hd__a21o_1
X_4803_ net209 net408 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nand2_1
X_5783_ _1253_ _1280_ _1279_ _1269_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__a211oi_1
XFILLER_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7522_ _4370_ net136 _3151_ VGND VGND VPWR VPWR _3152_ sky130_fd_sc_hd__nand3_1
X_4734_ _4489_ _4503_ VGND VGND VPWR VPWR _4505_ sky130_fd_sc_hd__nand2_1
X_7453_ net219 net358 net364 net210 VGND VGND VPWR VPWR _3083_ sky130_fd_sc_hd__a22oi_2
X_4665_ net211 net218 net390 net396 VGND VGND VPWR VPWR _4436_ sky130_fd_sc_hd__and4_1
X_6404_ _2032_ _2033_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__nor2_1
X_7384_ _3006_ _3009_ _3012_ VGND VGND VPWR VPWR _3014_ sky130_fd_sc_hd__nand3_1
X_4596_ net352 net208 net345 net211 VGND VGND VPWR VPWR _4367_ sky130_fd_sc_hd__a22o_1
XFILLER_115_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9123_ net540 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__inv_2
X_6335_ _1963_ _1881_ _1962_ _1944_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a211o_1
XFILLER_103_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9054_ net533 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__inv_2
X_8005_ adder_inst.sum_raw_r\[14\] net198 _3405_ adder_inst.sum_raw_r\[13\] net197
+ VGND VGND VPWR VPWR _3593_ sky130_fd_sc_hd__o221a_1
X_6266_ _1893_ _1894_ _1892_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__o21bai_1
XFILLER_103_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5217_ _0841_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__nand2_1
X_6197_ _1725_ _1726_ _1731_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__a21o_1
X_5148_ net351 net344 net311 net316 VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__and4_1
X_5079_ _0708_ _0707_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2b_1
XFILLER_72_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8907_ net522 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
XFILLER_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8838_ net104 _4327_ VGND VGND VPWR VPWR multiplier_inst.man_final\[17\] sky130_fd_sc_hd__nor2_1
XFILLER_12_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8769_ _3164_ _1975_ VGND VGND VPWR VPWR _4276_ sky130_fd_sc_hd__and2b_1
XFILLER_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6120_ _1640_ _1642_ _1653_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a21oi_1
X_6051_ net265 net271 net447 net453 VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__and4_1
X_5002_ _0629_ _0630_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nand3b_1
XFILLER_38_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6953_ _1546_ _1568_ _1545_ VGND VGND VPWR VPWR _2583_ sky130_fd_sc_hd__a21boi_1
XFILLER_19_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6884_ _2512_ _2513_ _2480_ VGND VGND VPWR VPWR _2514_ sky130_fd_sc_hd__a21bo_1
X_5904_ net395 net294 VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand2_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8623_ _3997_ _4184_ VGND VGND VPWR VPWR adder_inst.sum_raw\[11\] sky130_fd_sc_hd__xnor2_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5835_ _1457_ _1458_ _1463_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__a21o_1
XFILLER_22_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8554_ net194 _4120_ _4121_ _4122_ _4124_ VGND VGND VPWR VPWR _4125_ sky130_fd_sc_hd__a32o_1
X_5766_ _1390_ _1394_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nand3_1
XFILLER_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8485_ _4050_ _4054_ _4056_ VGND VGND VPWR VPWR _4058_ sky130_fd_sc_hd__and3_1
X_4717_ _4450_ _4486_ VGND VGND VPWR VPWR _4488_ sky130_fd_sc_hd__or2_1
X_7505_ _3098_ _3099_ _3134_ VGND VGND VPWR VPWR _3135_ sky130_fd_sc_hd__nor3_1
X_5697_ _1321_ _1325_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__nand3_1
XFILLER_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7436_ _3042_ _3064_ VGND VGND VPWR VPWR _3066_ sky130_fd_sc_hd__or2_1
X_4648_ _4396_ _4413_ _4412_ VGND VGND VPWR VPWR _4419_ sky130_fd_sc_hd__a21o_1
X_4579_ _4349_ VGND VGND VPWR VPWR _4350_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_73_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9106_ net526 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__inv_2
XFILLER_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7367_ _2967_ _2974_ VGND VGND VPWR VPWR _2997_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_73_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6318_ net276 net470 net475 net269 VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__a22o_1
XFILLER_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7298_ _2920_ _2926_ VGND VGND VPWR VPWR _2928_ sky130_fd_sc_hd__xor2_1
X_9037_ net537 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__inv_2
X_6249_ _1873_ _1877_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__xnor2_1
XFILLER_84_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold90 _0007_ VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5620_ _1235_ _1236_ _1249_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__and3_1
X_5551_ net287 net414 net419 net281 VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__a22o_1
XFILLER_31_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8270_ net128 _3841_ _3838_ net126 VGND VGND VPWR VPWR _3843_ sky130_fd_sc_hd__a211o_1
X_5482_ _1109_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__and2_1
X_7221_ net236 net432 net437 net229 VGND VGND VPWR VPWR _2851_ sky130_fd_sc_hd__a22oi_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout506 net507 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__buf_4
XFILLER_113_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7152_ _2776_ _2780_ VGND VGND VPWR VPWR _2782_ sky130_fd_sc_hd__xnor2_1
Xfanout539 net540 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__buf_2
XFILLER_112_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout517 net523 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout528 net530 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__buf_4
XFILLER_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7083_ _2601_ _2609_ _2608_ VGND VGND VPWR VPWR _2713_ sky130_fd_sc_hd__a21o_1
X_6103_ _1726_ _1731_ _1725_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__a21bo_1
XFILLER_100_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6034_ _1660_ _1663_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__and2b_1
XFILLER_100_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7985_ adder_inst.sum_raw_r\[10\] _4341_ net188 adder_inst.sum_raw_r\[8\] net198
+ VGND VGND VPWR VPWR _3576_ sky130_fd_sc_hd__o221a_1
XFILLER_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6936_ _2369_ _2565_ VGND VGND VPWR VPWR _2566_ sky130_fd_sc_hd__nand2_1
XFILLER_54_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6867_ _2496_ _2492_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__nand2b_1
X_6798_ net312 net473 VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__nand2_1
X_8606_ _3931_ _3932_ VGND VGND VPWR VPWR _4170_ sky130_fd_sc_hd__and2b_1
X_5818_ _1445_ _1446_ _1372_ _1385_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__o211ai_2
XFILLER_22_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8537_ _4064_ _4072_ _4075_ _4109_ _4071_ VGND VGND VPWR VPWR _4110_ sky130_fd_sc_hd__o221ai_4
X_5749_ _1376_ _1377_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nand3b_1
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8468_ _4040_ VGND VGND VPWR VPWR _4041_ sky130_fd_sc_hd__inv_2
X_8399_ _3971_ VGND VGND VPWR VPWR _3972_ sky130_fd_sc_hd__inv_2
X_7419_ _3046_ _3047_ VGND VGND VPWR VPWR _3049_ sky130_fd_sc_hd__xor2_1
XFILLER_104_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput91 net91 VGND VGND VPWR VPWR o_res[30] sky130_fd_sc_hd__buf_2
Xoutput80 net80 VGND VGND VPWR VPWR o_res[20] sky130_fd_sc_hd__buf_2
XFILLER_110_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7770_ _3155_ _3288_ _3338_ VGND VGND VPWR VPWR _3379_ sky130_fd_sc_hd__and3_1
X_4982_ _0608_ _0610_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nand3_1
X_6721_ _2337_ _2348_ _2349_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_34_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9440_ clknet_leaf_11_clk multiplier_inst.exp_final\[5\] _0350_ VGND VGND VPWR VPWR
+ multiplier_inst.exp_final_r\[5\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_102_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6652_ _2219_ _2221_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_62_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9371_ clknet_leaf_18_clk _0044_ _0281_ VGND VGND VPWR VPWR add_res\[17\] sky130_fd_sc_hd__dfrtp_1
X_5603_ _1230_ _1231_ _1223_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__a21oi_1
X_8322_ _3889_ _3891_ VGND VGND VPWR VPWR _3895_ sky130_fd_sc_hd__xnor2_1
X_6583_ net312 net450 _2204_ _2203_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__a31o_1
XFILLER_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5534_ net404 net409 net297 net305 VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__and4_1
X_8253_ net122 _3791_ _3820_ _3821_ net160 VGND VGND VPWR VPWR _3826_ sky130_fd_sc_hd__o221a_1
X_5465_ _1091_ _1092_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__and3_1
X_8184_ net148 _3756_ _3757_ VGND VGND VPWR VPWR _3758_ sky130_fd_sc_hd__or3_1
X_7204_ _2819_ _2820_ _2832_ _2833_ VGND VGND VPWR VPWR _2834_ sky130_fd_sc_hd__nand4_2
XFILLER_99_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout303 adder_inst.man_b_r\[7\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__clkbuf_2
X_5396_ net151 _1019_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__xnor2_1
Xfanout314 net320 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__buf_2
X_7135_ _2759_ _2764_ VGND VGND VPWR VPWR _2765_ sky130_fd_sc_hd__and2_1
Xfanout325 net326 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__buf_2
Xfanout336 net337 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_4
Xfanout347 net348 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout358 net359 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__buf_2
X_7066_ _2694_ _2695_ VGND VGND VPWR VPWR _2696_ sky130_fd_sc_hd__nor2_1
Xfanout369 net373 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkbuf_2
X_6017_ _1632_ _1634_ _1633_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_68_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7968_ adder_inst.sum_raw_r\[6\] net188 VGND VGND VPWR VPWR _3561_ sky130_fd_sc_hd__or2_1
XFILLER_15_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6919_ _2412_ _2481_ _2482_ VGND VGND VPWR VPWR _2549_ sky130_fd_sc_hd__nand3_1
X_7899_ net200 adder_inst.sum_raw_r\[3\] adder_inst.sum_raw_r\[2\] _3383_ VGND VGND
+ VPWR VPWR _3503_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_81_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer2 adder_inst.man_a_r\[15\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_11_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5250_ _0877_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__and2b_1
XFILLER_5_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5181_ _0807_ _0808_ _0809_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand3_1
XFILLER_68_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8940_ net515 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__inv_2
XFILLER_68_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_39_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8871_ net648 mul_res\[23\] net507 VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__mux2_1
X_7822_ net493 net488 VGND VGND VPWR VPWR _3428_ sky130_fd_sc_hd__nor2_1
XFILLER_36_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7753_ _3367_ _3370_ VGND VGND VPWR VPWR _3371_ sky130_fd_sc_hd__nor2_2
X_4965_ _0558_ _0593_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_19_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6704_ _2269_ _2322_ _2327_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__a21o_1
X_7684_ _3275_ _3283_ _3274_ VGND VGND VPWR VPWR _3310_ sky130_fd_sc_hd__a21o_1
X_9423_ clknet_leaf_17_clk multiplier_inst.man_final\[11\] _0333_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[11\] sky130_fd_sc_hd__dfrtp_1
X_4896_ _0513_ _0524_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nand3_1
XFILLER_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6635_ _2196_ _2198_ _2197_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__o21ai_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6566_ net426 net434 net337 net343 VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__and4_1
X_9354_ clknet_leaf_20_clk _0036_ _0264_ VGND VGND VPWR VPWR add_res\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_115_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9285_ clknet_leaf_11_clk adder_inst.sum_raw\[22\] _0195_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_8305_ _3876_ _3877_ VGND VGND VPWR VPWR _3878_ sky130_fd_sc_hd__nand2_1
X_5517_ _1140_ _1142_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_115_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8236_ net141 _3733_ _3808_ net143 VGND VGND VPWR VPWR _3809_ sky130_fd_sc_hd__a211o_1
X_6497_ _2124_ _2125_ _2123_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__o21bai_1
X_5448_ _1038_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__xor2_1
XFILLER_99_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout122 net123 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_2
X_8167_ net274 net413 net159 VGND VGND VPWR VPWR _3741_ sky130_fd_sc_hd__mux2_1
X_5379_ _1007_ _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__xnor2_1
Xfanout111 net112 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_2
X_8098_ _3277_ _3657_ _3278_ VGND VGND VPWR VPWR _3672_ sky130_fd_sc_hd__a21oi_1
Xfanout144 net147 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_2
XFILLER_59_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7118_ _2745_ _2746_ _2739_ VGND VGND VPWR VPWR _2748_ sky130_fd_sc_hd__a21o_1
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_2
XFILLER_101_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout199 _4340_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout188 _3430_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_2
Xfanout177 _3446_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__buf_2
X_7049_ _2678_ _2582_ VGND VGND VPWR VPWR _2679_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4750_ _4519_ _4520_ VGND VGND VPWR VPWR _4521_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_44_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4681_ _4399_ _4405_ _4407_ VGND VGND VPWR VPWR _4452_ sky130_fd_sc_hd__a21oi_1
X_6420_ net422 net337 net343 net416 VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__a22oi_2
X_6351_ _1978_ _1979_ _1977_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__o21bai_1
X_5302_ _0929_ _0930_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__or3_1
X_9070_ net544 VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__inv_2
X_6282_ net306 net433 net439 net297 VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__a22o_1
X_8021_ net502 _4342_ net494 _3606_ net500 VGND VGND VPWR VPWR _3607_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5233_ _0764_ _0776_ _0812_ _0854_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a211oi_1
XFILLER_68_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5164_ _0507_ _0792_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_110_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5095_ net351 net279 net285 net344 VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a22oi_1
X_8923_ net509 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
XFILLER_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8854_ net689 mul_res\[6\] net504 VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__mux2_1
XFILLER_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7805_ net197 _3410_ VGND VGND VPWR VPWR _3411_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8785_ _2543_ _4291_ _2532_ _2533_ VGND VGND VPWR VPWR _4292_ sky130_fd_sc_hd__and4b_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5997_ _1624_ _1625_ _1626_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__or3_1
X_7736_ net194 VGND VGND VPWR VPWR multiplier_inst.sign_res sky130_fd_sc_hd__inv_2
X_4948_ _0545_ _0546_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__xnor2_1
X_7667_ net103 _3272_ _3293_ VGND VGND VPWR VPWR _3294_ sky130_fd_sc_hd__a21o_1
X_4879_ _0492_ _0493_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__and3_1
X_9406_ clknet_leaf_10_clk net555 _0316_ VGND VGND VPWR VPWR adder_inst.sign_a_r sky130_fd_sc_hd__dfrtp_1
X_6618_ _2114_ _2188_ _2187_ _2184_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__o211ai_1
X_7598_ _1081_ _3224_ _1035_ VGND VGND VPWR VPWR _3228_ sky130_fd_sc_hd__a21oi_1
X_9337_ clknet_leaf_0_clk net583 _0247_ VGND VGND VPWR VPWR adder_inst.man_b_r\[15\]
+ sky130_fd_sc_hd__dfrtp_1
X_6549_ _2092_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__or2_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9268_ clknet_leaf_16_clk adder_inst.sum_raw\[5\] _0178_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[5\]
+ sky130_fd_sc_hd__dfrtp_4
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8219_ net125 _3790_ net122 VGND VGND VPWR VPWR _3792_ sky130_fd_sc_hd__a21o_1
X_9199_ clknet_leaf_22_clk net12 _0109_ VGND VGND VPWR VPWR adder_inst.i_a\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_58_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_27_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_36_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap119 _1622_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5920_ net399 net406 net282 net288 VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__and4_1
XFILLER_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5851_ _1478_ _1479_ _1477_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8570_ _3895_ _4138_ VGND VGND VPWR VPWR adder_inst.sum_raw\[4\] sky130_fd_sc_hd__xor2_1
XFILLER_61_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4802_ _0430_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__nor2_1
X_5782_ _1409_ _1410_ _1352_ _1355_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__o211a_1
XFILLER_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4733_ _4489_ _4503_ VGND VGND VPWR VPWR _4504_ sky130_fd_sc_hd__or2_1
X_7521_ _3148_ _3149_ _4393_ VGND VGND VPWR VPWR _3151_ sky130_fd_sc_hd__a21o_4
XPHY_EDGE_ROW_54_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7452_ net210 net217 net358 net364 VGND VGND VPWR VPWR _3082_ sky130_fd_sc_hd__and4_1
X_6403_ _2022_ _2024_ _2031_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__and3_1
X_4664_ _4428_ _4433_ VGND VGND VPWR VPWR _4435_ sky130_fd_sc_hd__xor2_1
X_7383_ _3009_ _3012_ _3006_ VGND VGND VPWR VPWR _3013_ sky130_fd_sc_hd__a21oi_1
X_4595_ net207 net359 _4364_ _4362_ VGND VGND VPWR VPWR _4366_ sky130_fd_sc_hd__a31o_1
X_9122_ net540 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__inv_2
X_6334_ _1944_ _1962_ _1963_ _1881_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__o211ai_4
X_9053_ net533 VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__inv_2
X_6265_ _1892_ _1893_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__or3_1
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8004_ net116 _3592_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__and2_1
X_5216_ _0844_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__xnor2_1
X_6196_ _1819_ _1824_ _1818_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a21bo_1
XFILLER_84_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5147_ _0509_ _0756_ _0758_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_63_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5078_ _0643_ _0645_ _0642_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__o21ba_1
XFILLER_57_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8906_ net517 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__inv_2
XFILLER_84_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8837_ _3259_ _4326_ VGND VGND VPWR VPWR _4327_ sky130_fd_sc_hd__xnor2_1
XFILLER_52_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8768_ _1810_ _3165_ VGND VGND VPWR VPWR _4275_ sky130_fd_sc_hd__xor2_1
X_7719_ adder_inst.exp_a_r\[7\] adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR _3342_
+ sky130_fd_sc_hd__nand2b_4
X_8699_ _4067_ _4251_ VGND VGND VPWR VPWR adder_inst.sum_raw\[20\] sky130_fd_sc_hd__xnor2_1
XFILLER_109_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6050_ _1265_ _1266_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__xnor2_1
XFILLER_112_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5001_ net256 net385 net391 net249 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__a22o_1
XFILLER_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6952_ _1572_ _1608_ _1571_ VGND VGND VPWR VPWR _2582_ sky130_fd_sc_hd__a21bo_1
X_6883_ _2482_ _2483_ _2484_ _2509_ VGND VGND VPWR VPWR _2513_ sky130_fd_sc_hd__a22o_1
X_5903_ _1425_ _1427_ _1426_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__o21bai_1
XFILLER_53_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8622_ net180 _4183_ _4180_ VGND VGND VPWR VPWR _4184_ sky130_fd_sc_hd__a21o_1
X_5834_ _1457_ _1458_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__nand3_1
XFILLER_34_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8553_ _4115_ _4123_ net182 VGND VGND VPWR VPWR _4124_ sky130_fd_sc_hd__o21a_1
X_5765_ _1392_ _1393_ _1391_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__a21o_1
X_8484_ _4054_ _4056_ VGND VGND VPWR VPWR _4057_ sky130_fd_sc_hd__and2_1
X_4716_ _4450_ _4486_ VGND VGND VPWR VPWR _4487_ sky130_fd_sc_hd__nand2_1
X_7504_ _4387_ _3133_ VGND VGND VPWR VPWR _3134_ sky130_fd_sc_hd__nand2_1
X_5696_ _1323_ _1324_ _1322_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__o21ai_1
XFILLER_107_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7435_ _3042_ _3064_ VGND VGND VPWR VPWR _3065_ sky130_fd_sc_hd__nand2_1
X_4647_ _4415_ _4417_ VGND VGND VPWR VPWR _4418_ sky130_fd_sc_hd__nand2_1
X_7366_ _2988_ _2995_ _2987_ VGND VGND VPWR VPWR _2996_ sky130_fd_sc_hd__a21o_1
XFILLER_116_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4578_ adder_inst.exp_b_r\[1\] adder_inst.exp_a_r\[1\] VGND VGND VPWR VPWR _4349_
+ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_73_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6317_ net259 net480 VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__nand2_1
X_9105_ net526 VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__inv_2
XFILLER_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7297_ _2921_ _2926_ VGND VGND VPWR VPWR _2927_ sky130_fd_sc_hd__nor2_1
X_9036_ net543 VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__inv_2
XFILLER_39_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6248_ _1873_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__nand2_1
X_6179_ _1715_ _1807_ _1806_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__a21bo_1
XFILLER_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold80 add_res\[17\] VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold91 add_res\[4\] VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5550_ net281 net287 net414 net419 VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__and4_1
X_5481_ _1108_ _1110_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__nor2_1
X_7220_ net229 net236 net431 net437 VGND VGND VPWR VPWR _2850_ sky130_fd_sc_hd__and4_1
XFILLER_113_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7151_ _2776_ _2780_ VGND VGND VPWR VPWR _2781_ sky130_fd_sc_hd__nand2b_1
Xfanout507 opcode_stage1 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__buf_2
Xfanout518 net521 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_4
XFILLER_98_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout529 net530 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__buf_2
X_7082_ _2685_ _2710_ VGND VGND VPWR VPWR _2712_ sky130_fd_sc_hd__xnor2_1
X_6102_ _1725_ _1726_ _1731_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__nand3_1
XFILLER_100_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6033_ _1660_ _1661_ _1662_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__or3_1
XFILLER_100_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7984_ adder_inst.sum_raw_r\[9\] net177 VGND VGND VPWR VPWR _3575_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_1_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6935_ _2370_ _2553_ _2558_ _2564_ VGND VGND VPWR VPWR _2565_ sky130_fd_sc_hd__o31ai_4
XTAP_TAPCELL_ROW_1_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6866_ _2493_ _2495_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__nor2_1
XFILLER_50_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6797_ _2425_ _2426_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__nor2_1
X_8605_ _4159_ _4160_ _3936_ VGND VGND VPWR VPWR _4169_ sky130_fd_sc_hd__a21boi_1
X_5817_ _1372_ _1385_ _1445_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__a211o_1
XFILLER_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8536_ _4032_ _4039_ _4045_ _4108_ _4031_ VGND VGND VPWR VPWR _4109_ sky130_fd_sc_hd__a221oi_4
XFILLER_22_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5748_ net399 net298 net304 net394 VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__a22o_1
XFILLER_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8467_ _4036_ _4037_ VGND VGND VPWR VPWR _4040_ sky130_fd_sc_hd__and2_1
X_5679_ net398 net311 VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__nand2_1
X_8398_ net163 _3969_ _3970_ VGND VGND VPWR VPWR _3971_ sky130_fd_sc_hd__o21ai_2
X_7418_ net358 net224 _3046_ VGND VGND VPWR VPWR _3048_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_9_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7349_ _2975_ _2976_ VGND VGND VPWR VPWR _2979_ sky130_fd_sc_hd__xnor2_1
XFILLER_106_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9019_ net512 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__inv_2
XFILLER_49_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput70 net70 VGND VGND VPWR VPWR o_res[11] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR o_res[31] sky130_fd_sc_hd__buf_2
Xoutput81 net81 VGND VGND VPWR VPWR o_res[21] sky130_fd_sc_hd__buf_2
XFILLER_63_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4981_ net361 net285 net292 net355 VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a22o_1
XFILLER_17_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6720_ _2337_ _2348_ _2349_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__and3_1
XFILLER_16_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6651_ _2273_ _2275_ _2272_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__o21ba_1
X_6582_ _2136_ _2210_ _2211_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__nand3_2
X_9370_ clknet_leaf_18_clk _0043_ _0280_ VGND VGND VPWR VPWR add_res\[16\] sky130_fd_sc_hd__dfrtp_1
X_5602_ _1223_ _1230_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__and3_1
X_8321_ _3893_ VGND VGND VPWR VPWR _3894_ sky130_fd_sc_hd__inv_2
X_5533_ net414 net293 VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nand2_1
X_8252_ net464 net165 VGND VGND VPWR VPWR _3825_ sky130_fd_sc_hd__nor2_1
X_5464_ _1040_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__nor2_1
X_8183_ net137 _3750_ _3748_ net142 VGND VGND VPWR VPWR _3757_ sky130_fd_sc_hd__o211a_1
X_5395_ _1022_ _1023_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__xnor2_1
X_7203_ _2830_ _2831_ _2827_ VGND VGND VPWR VPWR _2833_ sky130_fd_sc_hd__a21o_1
XFILLER_99_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7134_ _2762_ _2763_ VGND VGND VPWR VPWR _2764_ sky130_fd_sc_hd__xnor2_1
Xfanout304 net305 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__buf_2
XFILLER_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout337 adder_inst.man_b_r\[1\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout326 net327 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__buf_2
XFILLER_100_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout348 net349 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout315 net316 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__buf_2
XFILLER_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout359 net360 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_2
X_7065_ _2591_ _2597_ _2590_ VGND VGND VPWR VPWR _2695_ sky130_fd_sc_hd__a21oi_1
XFILLER_101_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6016_ _1643_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__nor2_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7967_ net116 _3560_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_68_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6918_ _2481_ _2514_ _2546_ _2511_ VGND VGND VPWR VPWR _2548_ sky130_fd_sc_hd__a31o_1
X_7898_ adder_inst.sum_raw_r\[1\] net488 _3462_ adder_inst.sum_raw_r\[0\] _3394_ VGND
+ VGND VPWR VPWR _3502_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_81_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6849_ _2478_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__inv_2
XFILLER_23_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9499_ clknet_leaf_13_clk net627 _0409_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
X_8519_ _4025_ _4091_ VGND VGND VPWR VPWR _4092_ sky130_fd_sc_hd__and2_1
XFILLER_108_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer3 net551 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_42_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5180_ _0807_ _0808_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__and3_1
XFILLER_110_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8870_ net626 mul_res\[22\] net507 VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__mux2_1
X_7821_ adder_inst.sum_raw_r\[3\] adder_inst.sum_raw_r\[5\] adder_inst.sum_raw_r\[4\]
+ adder_inst.sum_raw_r\[7\] VGND VGND VPWR VPWR _3427_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_19_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_16_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
X_7752_ _3364_ _3365_ _3368_ _3369_ VGND VGND VPWR VPWR _3370_ sky130_fd_sc_hd__or4_1
X_4964_ _0549_ _0554_ _0548_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_19_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6703_ _2331_ _2332_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__xnor2_1
XFILLER_32_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7683_ _3307_ _3308_ VGND VGND VPWR VPWR _3309_ sky130_fd_sc_hd__nor2_1
X_4895_ _0510_ _0512_ _0511_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__o21ai_1
X_9422_ clknet_leaf_19_clk multiplier_inst.man_final\[10\] _0332_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[10\] sky130_fd_sc_hd__dfrtp_1
X_6634_ _2202_ _2208_ _2207_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__a21o_1
X_9353_ clknet_leaf_6_clk adder_inst.is_nan_b _0263_ VGND VGND VPWR VPWR adder_inst.is_nan_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_6565_ _2182_ _2194_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_115_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_9284_ clknet_leaf_16_clk adder_inst.sum_raw\[21\] _0194_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_8304_ _4334_ _3874_ net165 VGND VGND VPWR VPWR _3877_ sky130_fd_sc_hd__mux2_2
X_6496_ _2123_ _2124_ _2125_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__or3_1
X_5516_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__nand2b_1
X_8235_ _4358_ net156 net154 net153 _3772_ VGND VGND VPWR VPWR _3808_ sky130_fd_sc_hd__o41a_1
X_5447_ _1067_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__nor2_1
XFILLER_99_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8166_ net175 _3680_ net155 _3699_ _3739_ VGND VGND VPWR VPWR _3740_ sky130_fd_sc_hd__a41o_1
XFILLER_87_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5378_ net209 net412 VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__nand2_1
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_4
XFILLER_113_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8097_ _3669_ _3670_ VGND VGND VPWR VPWR _3671_ sky130_fd_sc_hd__nand2_1
Xfanout156 _3679_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_2
Xfanout145 net147 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_2
Xfanout123 _3731_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_2
XFILLER_87_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7117_ _2739_ _2745_ _2746_ VGND VGND VPWR VPWR _2747_ sky130_fd_sc_hd__nand3_1
Xfanout167 _3666_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_2
Xfanout178 net179 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_2
X_7048_ _2640_ _2677_ VGND VGND VPWR VPWR _2678_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8999_ net522 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__inv_2
XFILLER_82_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4680_ _4444_ _4449_ VGND VGND VPWR VPWR _4451_ sky130_fd_sc_hd__xnor2_1
X_6350_ _1977_ _1978_ _1979_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__or3_1
XFILLER_6_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5301_ net254 net415 net420 net248 VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__a22oi_1
X_6281_ net295 net444 VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_5_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_8020_ adder_inst.sum_raw_r\[15\] _3470_ net491 VGND VGND VPWR VPWR _3606_ sky130_fd_sc_hd__a21o_1
X_5232_ _0859_ _0860_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__xor2_1
X_5163_ _0500_ _0501_ _0506_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__a21o_1
XFILLER_110_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5094_ net354 net347 net279 net285 VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__and4_1
X_8922_ net509 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__inv_2
XFILLER_37_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8853_ add_res\[5\] net672 net504 VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__mux2_1
XFILLER_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7804_ net497 _3396_ _3398_ _3403_ _3409_ VGND VGND VPWR VPWR _3410_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_65_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8784_ _2487_ _2508_ VGND VGND VPWR VPWR _4291_ sky130_fd_sc_hd__xnor2_1
XFILLER_52_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5996_ net393 net332 net338 net388 VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__a22oi_2
X_7735_ adder_inst.sign_b_r adder_inst.sign_a_r VGND VGND VPWR VPWR _3355_ sky130_fd_sc_hd__xnor2_2
X_4947_ _0533_ _0560_ _0575_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a21o_1
XFILLER_33_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7666_ _3282_ _3292_ VGND VGND VPWR VPWR _3293_ sky130_fd_sc_hd__xnor2_1
X_4878_ _0500_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nand2_1
X_9405_ clknet_leaf_9_clk adder_inst.is_zero_a _0315_ VGND VGND VPWR VPWR adder_inst.is_zero_a_r
+ sky130_fd_sc_hd__dfrtp_1
X_6617_ _2243_ _2246_ _2195_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__o21ai_2
XFILLER_20_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9336_ clknet_leaf_3_clk net580 _0246_ VGND VGND VPWR VPWR adder_inst.man_b_r\[14\]
+ sky130_fd_sc_hd__dfrtp_4
X_7597_ _1035_ _1081_ _3224_ VGND VGND VPWR VPWR _3227_ sky130_fd_sc_hd__and3_1
X_6548_ _2169_ _2171_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__nor2_1
X_9267_ clknet_leaf_16_clk adder_inst.sum_raw\[4\] _0177_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[4\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_76_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6479_ _2107_ _2108_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__nor2_1
X_8218_ net124 _3790_ VGND VGND VPWR VPWR _3791_ sky130_fd_sc_hd__nand2_1
X_9198_ clknet_leaf_22_clk net1 _0108_ VGND VGND VPWR VPWR adder_inst.i_a\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_99_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8149_ net476 net168 _3722_ VGND VGND VPWR VPWR _3723_ sky130_fd_sc_hd__o21ai_1
XFILLER_87_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5850_ _1477_ _1478_ _1479_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4801_ net221 net396 net402 net216 VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a22oi_1
X_5781_ _1352_ _1355_ _1409_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__a211oi_2
XFILLER_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4732_ _4497_ _4502_ VGND VGND VPWR VPWR _4503_ sky130_fd_sc_hd__xnor2_1
X_7520_ _3148_ _3149_ VGND VGND VPWR VPWR _3150_ sky130_fd_sc_hd__nand2_1
XFILLER_9_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7451_ _3062_ _3077_ _3080_ VGND VGND VPWR VPWR _3081_ sky130_fd_sc_hd__o21ai_1
X_4663_ _4428_ _4433_ VGND VGND VPWR VPWR _4434_ sky130_fd_sc_hd__and2_1
X_6402_ _2022_ _2024_ _2031_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__a21oi_2
X_7382_ _3010_ _3011_ VGND VGND VPWR VPWR _3012_ sky130_fd_sc_hd__nand2_1
X_4594_ _4362_ _4364_ VGND VGND VPWR VPWR _4365_ sky130_fd_sc_hd__and2b_1
X_9121_ net540 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__inv_2
X_6333_ _1864_ _1865_ _1879_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__o21ai_2
XFILLER_115_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9052_ net533 VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__inv_2
X_6264_ net412 adder_inst.man_b_r\[1\] net340 net407 VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8003_ net485 net501 net178 net503 _3591_ VGND VGND VPWR VPWR _3592_ sky130_fd_sc_hd__a221o_1
X_5215_ net207 net446 VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
X_6195_ _1818_ _1819_ _1824_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__nand3_1
XFILLER_96_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5146_ _0593_ _0762_ _0763_ _0760_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o22ai_1
XFILLER_29_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5077_ _0705_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__xnor2_1
X_8905_ net515 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__inv_2
XFILLER_72_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8836_ _3270_ _4325_ _4326_ VGND VGND VPWR VPWR multiplier_inst.man_final\[16\] sky130_fd_sc_hd__and3_1
XFILLER_64_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5979_ _1571_ _1572_ _1608_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nand3_1
X_8767_ _3153_ _3167_ VGND VGND VPWR VPWR _4274_ sky130_fd_sc_hd__nor2_1
X_7718_ adder_inst.exp_a_r\[7\] adder_inst.exp_b_r\[7\] VGND VGND VPWR VPWR _3341_
+ sky130_fd_sc_hd__and2b_1
XFILLER_40_558 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8698_ net194 _4250_ _4246_ _4245_ VGND VGND VPWR VPWR _4251_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_60_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7649_ adder_inst.exp_b_r\[2\] adder_inst.exp_a_r\[2\] VGND VGND VPWR VPWR _3277_
+ sky130_fd_sc_hd__nand2b_1
X_9319_ clknet_leaf_7_clk net602 _0229_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_107_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5000_ net249 net256 net386 net391 VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_0_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6951_ _2577_ _2580_ VGND VGND VPWR VPWR _2581_ sky130_fd_sc_hd__nand2_1
XFILLER_19_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6882_ _2482_ _2483_ _2484_ _2509_ VGND VGND VPWR VPWR _2512_ sky130_fd_sc_hd__nand4_1
X_5902_ _1437_ _1439_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__nand2_1
X_8621_ _4182_ _4181_ net105 VGND VGND VPWR VPWR _4183_ sky130_fd_sc_hd__mux2_1
X_5833_ _1459_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__xnor2_1
X_8552_ _3783_ _4091_ _4024_ VGND VGND VPWR VPWR _4123_ sky130_fd_sc_hd__a21o_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5764_ _1391_ _1392_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__nand3_1
X_7503_ _4385_ _4386_ VGND VGND VPWR VPWR _3133_ sky130_fd_sc_hd__or2_1
X_8483_ _4052_ _4053_ VGND VGND VPWR VPWR _4056_ sky130_fd_sc_hd__nand2b_1
X_4715_ _4484_ _4485_ VGND VGND VPWR VPWR _4486_ sky130_fd_sc_hd__nor2_1
X_5695_ _1322_ _1323_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__or3_1
X_7434_ _3062_ _3063_ VGND VGND VPWR VPWR _3064_ sky130_fd_sc_hd__and2_1
X_4646_ net377 net243 _4415_ _4416_ VGND VGND VPWR VPWR _4417_ sky130_fd_sc_hd__nand4_1
X_4577_ adder_inst.exp_a_r\[1\] adder_inst.exp_b_r\[1\] VGND VGND VPWR VPWR _4348_
+ sky130_fd_sc_hd__nand2b_1
X_7365_ _2989_ _2993_ VGND VGND VPWR VPWR _2995_ sky130_fd_sc_hd__xnor2_1
XFILLER_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6316_ net269 net273 net470 net475 VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__and4_1
X_9104_ net525 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__inv_2
XFILLER_116_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7296_ _2924_ _2925_ VGND VGND VPWR VPWR _2926_ sky130_fd_sc_hd__xnor2_1
X_9035_ net537 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__inv_2
X_6247_ _1874_ _1875_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__xnor2_1
X_6178_ _1806_ _1807_ _1715_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__nand3b_1
XFILLER_69_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5129_ _0509_ _0756_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nor3_2
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8819_ _3204_ _3210_ _3220_ VGND VGND VPWR VPWR _4317_ sky130_fd_sc_hd__or3_4
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold70 adder_inst.i_a\[19\] VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 _0008_ VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 _0026_ VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_82_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5480_ _1076_ _1086_ _1097_ _1107_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__o211a_1
XFILLER_61_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_1 _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7150_ _2777_ _2778_ VGND VGND VPWR VPWR _2780_ sky130_fd_sc_hd__xnor2_1
Xfanout519 net521 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__buf_4
XFILLER_112_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout508 net510 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__buf_4
X_7081_ _2685_ _2710_ VGND VGND VPWR VPWR _2711_ sky130_fd_sc_hd__and2b_1
X_6101_ _1727_ _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__xnor2_1
XFILLER_100_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6032_ net287 net430 net438 net283 VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__a22oi_1
XFILLER_39_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7983_ net115 _3574_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__and2_1
XFILLER_54_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6934_ _2556_ _2563_ _2561_ VGND VGND VPWR VPWR _2564_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_1_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6865_ _2493_ _2494_ net330 net474 VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__and4bb_1
X_8604_ _4167_ _4166_ net105 VGND VGND VPWR VPWR _4168_ sky130_fd_sc_hd__mux2_1
XFILLER_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6796_ net324 net461 net468 net317 VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__a22oi_1
X_5816_ _1432_ _1433_ _1444_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__o21ba_1
X_8535_ _4058_ _4106_ _4107_ VGND VGND VPWR VPWR _4108_ sky130_fd_sc_hd__a21o_1
X_5747_ net394 net399 net298 net304 VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__nand4_1
X_8466_ _4036_ _4037_ VGND VGND VPWR VPWR _4039_ sky130_fd_sc_hd__nor2_2
X_7417_ net358 net224 VGND VGND VPWR VPWR _3047_ sky130_fd_sc_hd__nand2_1
X_5678_ _1305_ _1306_ _1301_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__a21o_1
X_8397_ net274 net170 VGND VGND VPWR VPWR _3970_ sky130_fd_sc_hd__or2_1
X_4629_ net364 net241 VGND VGND VPWR VPWR _4400_ sky130_fd_sc_hd__nand2_1
XFILLER_116_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7348_ _2971_ _2973_ VGND VGND VPWR VPWR _2978_ sky130_fd_sc_hd__nand2_1
XFILLER_103_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7279_ _2900_ _2908_ _2899_ VGND VGND VPWR VPWR _2909_ sky130_fd_sc_hd__a21oi_1
X_9018_ net508 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__inv_2
XFILLER_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput82 net82 VGND VGND VPWR VPWR o_res[22] sky130_fd_sc_hd__buf_2
XFILLER_95_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput71 net71 VGND VGND VPWR VPWR o_res[12] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR o_res[3] sky130_fd_sc_hd__buf_2
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4980_ net355 net361 net285 net292 VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__nand4_1
XFILLER_23_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6650_ _2209_ _2264_ _2279_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__nand3_2
X_6581_ _2129_ _2130_ _2135_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__a21o_1
X_5601_ _1228_ _1229_ _1224_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__a21o_1
X_8320_ _3889_ _3891_ VGND VGND VPWR VPWR _3893_ sky130_fd_sc_hd__nand2b_1
X_5532_ _1159_ _1161_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__nor2_1
X_8251_ _3822_ _3823_ VGND VGND VPWR VPWR _3824_ sky130_fd_sc_hd__or2_1
X_5463_ _0728_ _0735_ _1039_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__and3_1
X_8182_ net137 _3755_ _3753_ net144 VGND VGND VPWR VPWR _3756_ sky130_fd_sc_hd__o211a_1
X_5394_ _1022_ _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__or2_1
X_7202_ _2827_ _2830_ _2831_ VGND VGND VPWR VPWR _2832_ sky130_fd_sc_hd__nand3_2
X_7133_ net206 net467 VGND VGND VPWR VPWR _2763_ sky130_fd_sc_hd__nand2_1
Xfanout305 net307 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__buf_2
Xfanout327 adder_inst.man_b_r\[3\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__buf_2
XFILLER_98_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout316 net320 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__clkbuf_2
Xfanout338 net340 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout349 adder_inst.man_a_r\[23\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkbuf_4
X_7064_ _2692_ _2693_ VGND VGND VPWR VPWR _2694_ sky130_fd_sc_hd__or2_1
XFILLER_86_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6015_ _1643_ _1644_ net293 net424 VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__and4bb_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7966_ net485 adder_inst.sum_raw_r\[13\] adder_inst.sum_raw_r\[12\] net178 _3559_
+ VGND VGND VPWR VPWR _3560_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_68_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6917_ _2481_ _2514_ _2546_ VGND VGND VPWR VPWR _2547_ sky130_fd_sc_hd__nand3_1
X_7897_ net115 _3500_ _3501_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_81_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6848_ net158 _2477_ _2444_ _2448_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__o211ai_4
XFILLER_23_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8518_ _4022_ _4023_ _4020_ _4021_ VGND VGND VPWR VPWR _4091_ sky130_fd_sc_hd__a211o_1
X_6779_ _2402_ _2407_ _2408_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__nand3_2
XFILLER_10_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9498_ clknet_leaf_15_clk net625 _0408_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
X_8449_ net121 _3937_ _4017_ _4018_ net169 VGND VGND VPWR VPWR _4022_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_79_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7820_ adder_inst.sum_raw_r\[6\] adder_inst.sum_raw_r\[9\] adder_inst.sum_raw_r\[8\]
+ adder_inst.sum_raw_r\[11\] VGND VGND VPWR VPWR _3426_ sky130_fd_sc_hd__or4_1
X_7751_ adder_inst.i_a\[17\] adder_inst.i_a\[18\] adder_inst.i_a\[21\] adder_inst.i_a\[22\]
+ VGND VGND VPWR VPWR _3369_ sky130_fd_sc_hd__or4_1
X_4963_ _0576_ _0592_ _0558_ _0559_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_19_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7682_ adder_inst.exp_b_r\[3\] adder_inst.exp_a_r\[3\] _3306_ VGND VGND VPWR VPWR
+ _3308_ sky130_fd_sc_hd__a21oi_1
X_6702_ net312 net461 VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__nand2_1
X_6633_ _2212_ _2225_ _2224_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__a21oi_1
X_4894_ net259 net395 _0504_ _0503_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a31o_1
X_9421_ clknet_leaf_21_clk multiplier_inst.man_final\[9\] _0331_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9352_ clknet_leaf_10_clk net205 _0262_ VGND VGND VPWR VPWR add_vld sky130_fd_sc_hd__dfrtp_1
X_6564_ _2176_ _2177_ _2181_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__a21o_1
XFILLER_20_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9283_ clknet_leaf_16_clk adder_inst.sum_raw\[20\] _0193_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_8303_ net170 _3874_ _3875_ VGND VGND VPWR VPWR _3876_ sky130_fd_sc_hd__a21oi_2
X_6495_ net428 net337 net343 net422 VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__a22oi_2
X_5515_ _1131_ _1137_ _1139_ _1143_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_115_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8234_ _4358_ net156 net154 net153 _3769_ VGND VGND VPWR VPWR _3807_ sky130_fd_sc_hd__o41a_1
X_5446_ _1067_ _1074_ _1075_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__nor3_1
X_8165_ _3738_ VGND VGND VPWR VPWR _3739_ sky130_fd_sc_hd__inv_2
X_5377_ _1005_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__nor2_1
Xfanout113 net114 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_4
X_8096_ _3667_ _3668_ _3305_ VGND VGND VPWR VPWR _3670_ sky130_fd_sc_hd__a21o_1
Xfanout124 net125 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_2
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_2
X_7116_ _2743_ _2744_ _2740_ VGND VGND VPWR VPWR _2746_ sky130_fd_sc_hd__a21o_1
Xfanout168 _3665_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
Xfanout179 _3382_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_2
XFILLER_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7047_ _2641_ _2676_ VGND VGND VPWR VPWR _2677_ sky130_fd_sc_hd__xor2_1
XFILLER_101_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8998_ net543 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__inv_2
XFILLER_70_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7949_ adder_inst.sum_raw_r\[9\] net195 net176 adder_inst.sum_raw_r\[8\] net189 VGND
+ VGND VPWR VPWR _3545_ sky130_fd_sc_hd__o221a_1
XFILLER_42_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5300_ net244 net425 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand2_1
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6280_ net297 net306 net433 net439 VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__and4_1
XFILLER_5_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5231_ _0860_ _0859_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__and2b_1
X_5162_ _0781_ _0786_ _0780_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_110_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5093_ _0719_ _0720_ _0640_ _0657_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__o211ai_1
XFILLER_96_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8921_ net509 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
XFILLER_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8852_ net640 mul_res\[4\] net504 VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__mux2_1
X_8783_ _2538_ _4289_ VGND VGND VPWR VPWR _4290_ sky130_fd_sc_hd__or2_1
X_7803_ net201 _3408_ _3404_ VGND VGND VPWR VPWR _3409_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_65_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7734_ _3353_ _3354_ VGND VGND VPWR VPWR adder_inst.man_a\[23\] sky130_fd_sc_hd__or2_1
XFILLER_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5995_ net398 net328 VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__nand2_1
X_4946_ _0533_ _0560_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand3_2
X_7665_ _4354_ _3154_ _4352_ VGND VGND VPWR VPWR _3292_ sky130_fd_sc_hd__o21ai_1
X_4877_ _0500_ _0501_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__nand3_1
X_9404_ clknet_leaf_10_clk adder_inst.sign_sum _0314_ VGND VGND VPWR VPWR adder_inst.sign_sum_r
+ sky130_fd_sc_hd__dfrtp_1
X_6616_ _2244_ _2245_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__and2_1
X_7596_ _1081_ _3224_ _1035_ VGND VGND VPWR VPWR _3226_ sky130_fd_sc_hd__a21bo_1
X_9335_ clknet_leaf_3_clk net589 _0245_ VGND VGND VPWR VPWR adder_inst.man_b_r\[13\]
+ sky130_fd_sc_hd__dfrtp_4
X_6547_ _2101_ _2175_ _2174_ _2156_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__o211ai_1
X_9266_ clknet_leaf_16_clk adder_inst.sum_raw\[3\] _0176_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[3\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_76_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6478_ _2097_ _2099_ _2106_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__and3_1
X_9197_ clknet_leaf_12_clk net65 _0107_ VGND VGND VPWR VPWR adder_inst.i_vld sky130_fd_sc_hd__dfrtp_1
X_8217_ net129 _3788_ _3789_ _3785_ VGND VGND VPWR VPWR _3790_ sky130_fd_sc_hd__a31o_1
X_5429_ _1046_ _1047_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__or3_1
X_8148_ net336 net161 VGND VGND VPWR VPWR _3722_ sky130_fd_sc_hd__or2_1
XFILLER_87_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8079_ _4348_ _4355_ _4349_ VGND VGND VPWR VPWR _3653_ sky130_fd_sc_hd__a21oi_2
XFILLER_87_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4800_ net216 net221 net396 net402 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__and4_1
XFILLER_34_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5780_ _1387_ _1388_ _1407_ _1408_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_21_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4731_ _4500_ _4501_ VGND VGND VPWR VPWR _4502_ sky130_fd_sc_hd__xnor2_1
XFILLER_9_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7450_ _3078_ _3079_ VGND VGND VPWR VPWR _3080_ sky130_fd_sc_hd__or2_1
X_4662_ net226 net390 _4431_ _4429_ VGND VGND VPWR VPWR _4433_ sky130_fd_sc_hd__a31o_1
X_6401_ _1954_ _2030_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__nand2_1
X_9120_ net532 VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__inv_2
X_7381_ _3007_ _3008_ VGND VGND VPWR VPWR _3011_ sky130_fd_sc_hd__xor2_2
X_4593_ net353 net211 net218 net346 VGND VGND VPWR VPWR _4364_ sky130_fd_sc_hd__a22o_1
X_6332_ _1943_ _1945_ _1961_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__and3_2
X_9051_ net533 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__inv_2
X_6263_ net416 net329 VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__nand2_1
X_8002_ adder_inst.sum_raw_r\[14\] _3504_ _3589_ _3590_ VGND VGND VPWR VPWR _3591_
+ sky130_fd_sc_hd__o211a_1
X_5214_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__nor2_1
X_6194_ _1820_ _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__xnor2_1
XFILLER_84_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5145_ _0765_ _0768_ _0767_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5076_ net227 net408 VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__nand2_1
XFILLER_56_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8904_ net515 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__inv_2
XFILLER_25_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8835_ _3244_ _3257_ VGND VGND VPWR VPWR _4326_ sky130_fd_sc_hd__nand2_1
X_8766_ multiplier_inst.is_nan_r net205 net706 VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__and3b_1
X_5978_ _1573_ _1607_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__xnor2_1
X_7717_ _3329_ _3332_ _3330_ VGND VGND VPWR VPWR _3340_ sky130_fd_sc_hd__o21ba_1
X_8697_ _4033_ _4042_ _4051_ _4224_ _4249_ VGND VGND VPWR VPWR _4250_ sky130_fd_sc_hd__a41o_1
X_4929_ _0556_ _0557_ _0491_ _0509_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a211oi_4
X_7648_ _3274_ _3275_ VGND VGND VPWR VPWR _3276_ sky130_fd_sc_hd__nand2b_1
XFILLER_60_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7579_ _1151_ _3208_ VGND VGND VPWR VPWR _3209_ sky130_fd_sc_hd__xnor2_1
X_9318_ clknet_leaf_7_clk net613 _0228_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_9249_ clknet_leaf_3_clk net43 _0159_ VGND VGND VPWR VPWR adder_inst.i_b\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_87_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6950_ _2578_ _2579_ VGND VGND VPWR VPWR _2580_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_109_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5901_ _1528_ _1529_ _1514_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__a21o_1
X_6881_ _2482_ _2483_ _2484_ _2509_ VGND VGND VPWR VPWR _2511_ sky130_fd_sc_hd__and4_1
XFILLER_34_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8620_ _4004_ _4102_ _4006_ VGND VGND VPWR VPWR _4182_ sky130_fd_sc_hd__o21a_1
X_5832_ _1460_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__and2b_1
X_8551_ _4095_ net107 VGND VGND VPWR VPWR _4122_ sky130_fd_sc_hd__or2_1
XFILLER_61_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5763_ net409 net288 net414 net282 VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_101_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4714_ _4480_ _4483_ VGND VGND VPWR VPWR _4485_ sky130_fd_sc_hd__nor2_1
X_7502_ _4390_ _3131_ VGND VGND VPWR VPWR _3132_ sky130_fd_sc_hd__nor2_1
XFILLER_108_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8482_ _4052_ _4053_ VGND VGND VPWR VPWR _4055_ sky130_fd_sc_hd__and2b_1
X_5694_ net368 net333 net339 net362 VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a22oi_2
X_7433_ _3043_ _3061_ VGND VGND VPWR VPWR _3063_ sky130_fd_sc_hd__nand2_1
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4645_ net371 net249 net256 net365 VGND VGND VPWR VPWR _4416_ sky130_fd_sc_hd__a22o_1
XFILLER_116_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4576_ net538 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__inv_2
X_7364_ _2989_ _2993_ VGND VGND VPWR VPWR _2994_ sky130_fd_sc_hd__nand2b_1
X_9103_ net525 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__inv_2
X_6315_ _1862_ _1942_ _1941_ _1924_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__o211ai_1
X_9034_ net546 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__inv_2
XFILLER_89_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7295_ net206 net460 VGND VGND VPWR VPWR _2925_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_110_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6246_ _1874_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__nand2b_1
XFILLER_69_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6177_ _1713_ _1714_ _1708_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__a21bo_1
XFILLER_111_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5128_ _0606_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__or2_1
XFILLER_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5059_ _0630_ _0632_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__nand2_1
XFILLER_72_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8818_ _4315_ _4316_ VGND VGND VPWR VPWR multiplier_inst.man_final\[8\] sky130_fd_sc_hd__and2b_1
XFILLER_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8749_ net717 _4269_ net184 VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__and3_1
XFILLER_40_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold71 multiplier_inst.exp_final_r\[6\] VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 adder_inst.exp_b\[3\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 add_res\[15\] VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold93 add_res\[0\] VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_2 _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6100_ _1728_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__nor2_1
Xfanout509 net510 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__buf_4
X_7080_ _2698_ _2709_ VGND VGND VPWR VPWR _2710_ sky130_fd_sc_hd__xnor2_1
XFILLER_86_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6031_ net277 net443 VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__nand2_1
XFILLER_39_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7982_ net484 adder_inst.sum_raw_r\[15\] adder_inst.sum_raw_r\[14\] net178 _3573_
+ VGND VGND VPWR VPWR _3574_ sky130_fd_sc_hd__a221o_1
XFILLER_54_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6933_ _2370_ _2411_ _2555_ VGND VGND VPWR VPWR _2563_ sky130_fd_sc_hd__nor3_1
XFILLER_81_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6864_ net342 net462 net469 net336 VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__a22oi_1
XFILLER_35_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8603_ _3934_ _4100_ _3933_ VGND VGND VPWR VPWR _4167_ sky130_fd_sc_hd__o21ba_1
X_5815_ _1432_ _1433_ _1444_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__nor3b_2
XFILLER_34_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6795_ net317 net324 net461 net468 VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__and4_1
X_8534_ _4049_ _4054_ _4048_ VGND VGND VPWR VPWR _4107_ sky130_fd_sc_hd__o21ai_1
X_5746_ net404 net293 VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__nand2_1
X_8465_ _4036_ _4037_ VGND VGND VPWR VPWR _4038_ sky130_fd_sc_hd__nand2b_1
X_5677_ _1301_ _1305_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__nand3_1
X_4628_ net262 _4398_ VGND VGND VPWR VPWR _4399_ sky130_fd_sc_hd__and2_1
X_7416_ _3044_ _3045_ VGND VGND VPWR VPWR _3046_ sky130_fd_sc_hd__nor2_1
X_8396_ net125 _3886_ _3968_ net122 VGND VGND VPWR VPWR _3969_ sky130_fd_sc_hd__o211a_1
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7347_ _2975_ _2976_ VGND VGND VPWR VPWR _2977_ sky130_fd_sc_hd__nand2_1
XFILLER_103_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7278_ _2906_ _2907_ VGND VGND VPWR VPWR _2908_ sky130_fd_sc_hd__nor2_1
XFILLER_77_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9017_ net508 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
X_6229_ _1764_ _1857_ _1856_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__o21a_1
XFILLER_106_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput83 net83 VGND VGND VPWR VPWR o_res[23] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR o_res[4] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR o_res[13] sky130_fd_sc_hd__buf_2
XFILLER_110_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6580_ _2207_ _2208_ _2202_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__a21bo_1
X_5600_ _1224_ _1228_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__nand3_1
X_5531_ _1159_ _1160_ net404 net311 VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__and4bb_1
X_8250_ _3806_ _3819_ net168 _3792_ VGND VGND VPWR VPWR _3823_ sky130_fd_sc_hd__o211a_1
XFILLER_105_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5462_ _1089_ _1090_ _0701_ _0717_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__o211ai_2
X_7201_ _0910_ _2829_ _2828_ VGND VGND VPWR VPWR _2831_ sky130_fd_sc_hd__a21o_1
X_8181_ net434 net159 _3754_ VGND VGND VPWR VPWR _3755_ sky130_fd_sc_hd__a21oi_1
X_5393_ _0431_ _0433_ _0430_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__o21ba_1
X_7132_ _2760_ _2761_ VGND VGND VPWR VPWR _2762_ sky130_fd_sc_hd__nor2_1
XFILLER_113_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout317 net318 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__buf_2
XFILLER_86_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout339 net340 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_2
X_7063_ _2690_ _2691_ _2686_ VGND VGND VPWR VPWR _2693_ sky130_fd_sc_hd__a21oi_1
Xfanout328 net329 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__buf_2
XFILLER_100_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6014_ net423 net297 net305 net414 VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__a22oi_1
XFILLER_39_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7965_ adder_inst.sum_raw_r\[9\] _3504_ _3557_ _3558_ VGND VGND VPWR VPWR _3559_
+ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_68_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6916_ _2484_ _2535_ _2537_ _2545_ VGND VGND VPWR VPWR _2546_ sky130_fd_sc_hd__a22o_1
X_7896_ net200 adder_inst.sum_raw_r\[2\] _3383_ adder_inst.sum_raw_r\[1\] VGND VGND
+ VPWR VPWR _3501_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_81_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6847_ _2468_ _2475_ _2476_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__and3_1
XFILLER_23_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6778_ _2360_ _2372_ _2401_ _2406_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_61_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8517_ _4058_ _4089_ VGND VGND VPWR VPWR _4090_ sky130_fd_sc_hd__nand2_1
XFILLER_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5729_ net356 net362 net333 net339 VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__nand4_1
X_9497_ clknet_leaf_15_clk net657 _0407_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
X_8448_ net336 net168 VGND VGND VPWR VPWR _4021_ sky130_fd_sc_hd__nor2_1
X_8379_ net396 net164 VGND VGND VPWR VPWR _3952_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_79_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7750_ adder_inst.i_a\[8\] adder_inst.i_a\[11\] adder_inst.i_a\[13\] adder_inst.i_a\[14\]
+ VGND VGND VPWR VPWR _3368_ sky130_fd_sc_hd__or4_1
X_4962_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_19_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7681_ adder_inst.exp_b_r\[3\] adder_inst.exp_a_r\[3\] _3306_ VGND VGND VPWR VPWR
+ _3307_ sky130_fd_sc_hd__and3_1
X_6701_ _2329_ _2330_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__nor2_1
X_4893_ _0520_ _0521_ _0514_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
X_6632_ _2229_ _2239_ _2238_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__a21oi_1
X_9420_ clknet_leaf_21_clk multiplier_inst.man_final\[8\] _0330_ VGND VGND VPWR VPWR
+ multiplier_inst.man_final_r\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9351_ clknet_leaf_10_clk net557 _0261_ VGND VGND VPWR VPWR adder_inst.sign_b_r sky130_fd_sc_hd__dfrtp_1
X_6563_ _2180_ _2186_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__xnor2_1
X_9282_ clknet_leaf_16_clk adder_inst.sum_raw\[19\] _0192_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_8302_ net313 net168 VGND VGND VPWR VPWR _3875_ sky130_fd_sc_hd__nor2_1
X_6494_ net434 net331 VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__nand2_1
X_5514_ _1139_ _1143_ _1131_ _1137_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__a211oi_1
XFILLER_8_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8233_ _3678_ _3799_ _3805_ VGND VGND VPWR VPWR _3806_ sky130_fd_sc_hd__and3_1
X_5445_ _1018_ _1066_ _1065_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__o21ba_1
XFILLER_105_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8164_ net268 net408 net159 VGND VGND VPWR VPWR _3738_ sky130_fd_sc_hd__mux2_1
Xfanout103 net104 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_2
X_5376_ net222 net403 net408 net215 VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__a22oi_1
X_7115_ _2740_ _2743_ _2744_ VGND VGND VPWR VPWR _2745_ sky130_fd_sc_hd__nand3_1
X_8095_ _3305_ _3667_ _3668_ VGND VGND VPWR VPWR _3669_ sky130_fd_sc_hd__nand3_1
Xfanout147 _3708_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_2
Xfanout125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_87_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout114 _3152_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_4
Xfanout136 _4391_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_2
Xfanout169 _3665_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7046_ _2642_ _2674_ VGND VGND VPWR VPWR _2676_ sky130_fd_sc_hd__xnor2_1
XFILLER_74_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8997_ net537 VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
XFILLER_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7948_ adder_inst.sum_raw_r\[6\] net496 _3542_ _3543_ _3473_ VGND VGND VPWR VPWR
+ _3544_ sky130_fd_sc_hd__a221o_1
XFILLER_82_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7879_ adder_inst.exp_larger_r\[0\] _3415_ _3407_ VGND VGND VPWR VPWR _3485_ sky130_fd_sc_hd__o21ai_1
XFILLER_50_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5230_ _0586_ _0588_ _0585_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__o21ba_1
XFILLER_5_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5161_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__or2_1
X_5092_ _0640_ _0657_ _0719_ _0720_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a211o_1
XFILLER_96_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8920_ net509 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
XFILLER_68_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8851_ net633 mul_res\[3\] net505 VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__mux2_1
X_8782_ net341 net474 net482 net335 _2540_ VGND VGND VPWR VPWR _4289_ sky130_fd_sc_hd__a221o_1
X_7802_ _4346_ _3407_ VGND VGND VPWR VPWR _3408_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5994_ net388 net393 net332 net338 VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__and4_1
X_7733_ adder_inst.exp_a\[1\] adder_inst.exp_a\[0\] adder_inst.exp_a\[3\] adder_inst.exp_a\[2\]
+ VGND VGND VPWR VPWR _3354_ sky130_fd_sc_hd__or4_1
X_4945_ _0572_ _0573_ _0567_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a21bo_1
X_7664_ _3288_ _3289_ _3291_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[3\] sky130_fd_sc_hd__o21a_1
X_4876_ _0502_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__xnor2_1
XFILLER_20_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9403_ clknet_leaf_6_clk adder_inst.is_inf_b _0313_ VGND VGND VPWR VPWR adder_inst.is_inf_b_r
+ sky130_fd_sc_hd__dfrtp_1
X_6615_ _2241_ _2242_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__xor2_1
X_7595_ _3223_ _1035_ _1081_ VGND VGND VPWR VPWR _3225_ sky130_fd_sc_hd__or3b_1
XFILLER_20_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9334_ clknet_leaf_0_clk net591 _0244_ VGND VGND VPWR VPWR adder_inst.man_b_r\[12\]
+ sky130_fd_sc_hd__dfrtp_1
X_6546_ _2156_ _2174_ _2175_ _2101_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__a211o_1
X_9265_ clknet_leaf_14_clk adder_inst.sum_raw\[2\] _0175_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[2\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_TAPCELL_ROW_76_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6477_ _2097_ _2099_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__a21oi_2
X_9196_ clknet_leaf_12_clk net686 _0106_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
X_8216_ net139 _3764_ _3786_ net146 VGND VGND VPWR VPWR _3789_ sky130_fd_sc_hd__a211o_1
X_5428_ _1051_ _1056_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__xnor2_1
XFILLER_99_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8147_ _3719_ _3720_ net139 VGND VGND VPWR VPWR _3721_ sky130_fd_sc_hd__mux2_1
XFILLER_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5359_ net372 net261 _0732_ _0731_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a31o_1
X_8078_ adder_inst.is_nan_r net205 net705 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__and3b_1
XFILLER_87_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7029_ net234 net442 net448 net228 VGND VGND VPWR VPWR _2659_ sky130_fd_sc_hd__a22oi_1
XFILLER_114_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4730_ net207 net389 VGND VGND VPWR VPWR _4501_ sky130_fd_sc_hd__nand2_1
X_4661_ _4429_ _4431_ VGND VGND VPWR VPWR _4432_ sky130_fd_sc_hd__and2b_1
X_6400_ _1951_ _1953_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__or2_1
X_7380_ _2779_ _2781_ VGND VGND VPWR VPWR _3010_ sky130_fd_sc_hd__nand2_2
X_4592_ net208 net358 VGND VGND VPWR VPWR _4363_ sky130_fd_sc_hd__nand2_1
X_6331_ _1954_ _1959_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__xor2_1
X_6262_ net407 net412 adder_inst.man_b_r\[1\] net340 VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__and4_1
X_9050_ net528 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_23_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8001_ adder_inst.sum_raw_r\[16\] net195 net176 adder_inst.sum_raw_r\[15\] net189
+ VGND VGND VPWR VPWR _3590_ sky130_fd_sc_hd__o221a_1
X_5213_ net221 net435 adder_inst.man_a_r\[7\] net212 VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__a22oi_1
X_6193_ _1821_ _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__nor2_1
X_5144_ _0600_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__xnor2_1
XFILLER_69_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5075_ _0703_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__nor2_1
XFILLER_56_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8903_ net515 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__inv_2
XFILLER_84_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8834_ _3244_ _3257_ VGND VGND VPWR VPWR _4325_ sky130_fd_sc_hd__or2_1
XFILLER_25_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8765_ net680 _4272_ _0104_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a21o_1
XFILLER_52_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5977_ _1605_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__nor2_1
X_7716_ net103 _3339_ _3338_ _3324_ VGND VGND VPWR VPWR multiplier_inst.exp_final\[6\]
+ sky130_fd_sc_hd__o2bb2a_1
XFILLER_100_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8696_ _4033_ _4248_ _4247_ VGND VGND VPWR VPWR _4249_ sky130_fd_sc_hd__a21o_1
X_4928_ _0491_ _0509_ _0556_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__o211a_1
X_7647_ adder_inst.exp_b_r\[2\] adder_inst.exp_a_r\[2\] _3273_ VGND VGND VPWR VPWR
+ _3275_ sky130_fd_sc_hd__a21o_1
XFILLER_100_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4859_ _0482_ _0483_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand3_1
X_7578_ _0977_ _3207_ VGND VGND VPWR VPWR _3208_ sky130_fd_sc_hd__and2_1
X_9317_ clknet_leaf_6_clk net604 _0227_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_6529_ net280 net475 _2084_ _2085_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__o2bb2a_1
X_9248_ clknet_leaf_4_clk net42 _0158_ VGND VGND VPWR VPWR adder_inst.i_b\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9179_ net534 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__inv_2
XFILLER_0_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5900_ _1514_ _1528_ _1529_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__nand3_1
XFILLER_47_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6880_ _2478_ _2485_ _2487_ _2508_ VGND VGND VPWR VPWR _2510_ sky130_fd_sc_hd__nand4_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5831_ net271 net420 net429 net264 VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__a22o_1
X_8550_ _4020_ _4021_ _4022_ _4023_ VGND VGND VPWR VPWR _4121_ sky130_fd_sc_hd__or4bb_1
XFILLER_61_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5762_ net282 net409 net288 net414 VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__nand4_1
X_4713_ _4480_ _4483_ VGND VGND VPWR VPWR _4484_ sky130_fd_sc_hd__and2_1
X_7501_ _4388_ _4389_ _4383_ VGND VGND VPWR VPWR _3131_ sky130_fd_sc_hd__o21a_1
X_8481_ _4053_ _4052_ VGND VGND VPWR VPWR _4054_ sky130_fd_sc_hd__nand2b_1
X_5693_ net362 net368 net333 net339 VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__and4_1
X_7432_ _3043_ _3061_ VGND VGND VPWR VPWR _3062_ sky130_fd_sc_hd__or2_1
X_4644_ net365 net371 net249 net256 VGND VGND VPWR VPWR _4415_ sky130_fd_sc_hd__nand4_1
X_4575_ net201 VGND VGND VPWR VPWR _4347_ sky130_fd_sc_hd__inv_2
X_7363_ _2990_ _2991_ VGND VGND VPWR VPWR _2993_ sky130_fd_sc_hd__xnor2_1
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9102_ net525 VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__inv_2
X_7294_ _2922_ _2923_ VGND VGND VPWR VPWR _2924_ sky130_fd_sc_hd__nand2b_1
X_6314_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__inv_2
XFILLER_115_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9033_ net546 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__inv_2
XFILLER_103_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6245_ _1271_ _1794_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__xor2_1
XFILLER_103_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6176_ _1800_ _1803_ _1805_ _1711_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__o211ai_2
XFILLER_69_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5127_ _0601_ _0605_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__nor2_1
X_5058_ _0685_ _0686_ _0684_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8817_ _3204_ _3220_ VGND VGND VPWR VPWR _4316_ sky130_fd_sc_hd__nand2_1
XFILLER_53_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8748_ net719 net186 net184 VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_23_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8679_ _4051_ _4224_ VGND VGND VPWR VPWR _4234_ sky130_fd_sc_hd__nand2_1
XFILLER_112_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold50 adder_inst.i_a\[13\] VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 adder_inst.exp_a\[7\] VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 _0006_ VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold72 multiplier_inst.man_final_r\[7\] VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold94 _0000_ VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_3 _3371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6030_ net283 net287 net430 net438 VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__and4_1
XFILLER_112_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7981_ _3414_ _3571_ _3572_ VGND VGND VPWR VPWR _3573_ sky130_fd_sc_hd__o21a_1
X_6932_ _2561_ VGND VGND VPWR VPWR _2562_ sky130_fd_sc_hd__inv_2
XFILLER_54_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6863_ net335 net342 net462 net469 VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__and4_1
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8602_ _3935_ _4163_ _3933_ VGND VGND VPWR VPWR _4166_ sky130_fd_sc_hd__a21o_1
X_5814_ _1434_ _1443_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__xor2_1
XFILLER_22_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6794_ _2379_ _2418_ _2423_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__nand3_1
X_8533_ _3967_ _3989_ _4103_ _4105_ VGND VGND VPWR VPWR _4106_ sky130_fd_sc_hd__a31o_1
X_5745_ _1329_ _1331_ _1330_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__o21bai_1
XFILLER_41_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8464_ net380 _4034_ net166 VGND VGND VPWR VPWR _4037_ sky130_fd_sc_hd__mux2_1
X_5676_ _1303_ _1304_ _1302_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a21o_1
XFILLER_108_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4627_ net354 net347 net267 VGND VGND VPWR VPWR _4398_ sky130_fd_sc_hd__and3_1
X_7415_ net345 net235 _4374_ VGND VGND VPWR VPWR _3045_ sky130_fd_sc_hd__and3_1
X_8395_ net149 _3774_ _3884_ _3728_ VGND VGND VPWR VPWR _3968_ sky130_fd_sc_hd__a211o_1
XFILLER_104_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7346_ _2938_ _2945_ VGND VGND VPWR VPWR _2976_ sky130_fd_sc_hd__xor2_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7277_ _2904_ _2905_ _2901_ VGND VGND VPWR VPWR _2907_ sky130_fd_sc_hd__a21oi_1
XFILLER_103_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9016_ net512 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__inv_2
X_6228_ _1764_ _1856_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__nor3_1
X_6159_ net246 net254 net472 net479 VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__and4_1
XFILLER_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput84 net84 VGND VGND VPWR VPWR o_res[24] sky130_fd_sc_hd__buf_2
XFILLER_110_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput73 net73 VGND VGND VPWR VPWR o_res[14] sky130_fd_sc_hd__buf_2
XFILLER_68_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput95 net95 VGND VGND VPWR VPWR o_res[5] sky130_fd_sc_hd__buf_2
XFILLER_48_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5530_ net398 net314 net321 net393 VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__a22oi_1
X_5461_ _0701_ _0717_ _1089_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a211o_1
X_7200_ _0910_ _2828_ _2829_ VGND VGND VPWR VPWR _2830_ sky130_fd_sc_hd__nand3_2
XFILLER_99_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8180_ net296 _3342_ _3664_ VGND VGND VPWR VPWR _3754_ sky130_fd_sc_hd__and3_1
X_5392_ _1020_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7131_ net217 net454 net460 net210 VGND VGND VPWR VPWR _2761_ sky130_fd_sc_hd__a22oi_1
XFILLER_98_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout318 net319 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__buf_2
Xfanout329 adder_inst.man_b_r\[2\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__buf_2
Xfanout307 adder_inst.man_b_r\[6\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_2
X_7062_ _2686_ _2690_ _2691_ VGND VGND VPWR VPWR _2692_ sky130_fd_sc_hd__and3_1
X_6013_ net414 net419 net297 net305 VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__and4_1
XFILLER_100_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7964_ adder_inst.sum_raw_r\[11\] net195 net176 adder_inst.sum_raw_r\[10\] net189
+ VGND VGND VPWR VPWR _3558_ sky130_fd_sc_hd__o221a_1
Xclkbuf_leaf_19_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_6_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6915_ _2488_ _2516_ _2534_ _2544_ VGND VGND VPWR VPWR _2545_ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_68_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7895_ adder_inst.sum_raw_r\[0\] net488 _3394_ VGND VGND VPWR VPWR _3500_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_81_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6846_ _2440_ _2449_ _2473_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6777_ _2401_ _2406_ _2360_ _2372_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_61_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8516_ _4044_ _4075_ _4088_ VGND VGND VPWR VPWR _4089_ sky130_fd_sc_hd__nor3_1
X_5728_ net368 net328 VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__and2_1
X_9496_ clknet_leaf_15_clk net623 _0406_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
X_8447_ _3732_ _3937_ _4017_ _4018_ net162 VGND VGND VPWR VPWR _4020_ sky130_fd_sc_hd__a221oi_2
X_5659_ _1286_ _1287_ _1285_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__a21bo_1
X_8378_ net171 _3950_ _3949_ VGND VGND VPWR VPWR _3951_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_79_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7329_ _2914_ _2915_ _2928_ VGND VGND VPWR VPWR _2959_ sky130_fd_sc_hd__o21a_1
XFILLER_100_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_79_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4961_ _0576_ _0577_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_19_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7680_ _3303_ _3304_ VGND VGND VPWR VPWR _3306_ sky130_fd_sc_hd__or2_1
X_6700_ net324 net450 net456 net317 VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__a22oi_1
X_4892_ _0514_ _0520_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nand3_1
X_6631_ _2244_ _2245_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__xnor2_2
XFILLER_20_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9350_ clknet_leaf_11_clk _0068_ _0260_ VGND VGND VPWR VPWR add_ovf sky130_fd_sc_hd__dfrtp_1
X_8301_ net122 _3861_ _3869_ _3873_ VGND VGND VPWR VPWR _3874_ sky130_fd_sc_hd__a31oi_2
X_6562_ _2117_ _2189_ _2190_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__nor3_1
XFILLER_20_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9281_ clknet_leaf_16_clk adder_inst.sum_raw\[18\] _0191_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_6493_ net422 net426 net337 net343 VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__and4_1
X_5513_ _1140_ _1142_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_8_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_8232_ _3803_ _3804_ net128 VGND VGND VPWR VPWR _3805_ sky130_fd_sc_hd__a21o_1
X_5444_ _1071_ _1072_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__xor2_1
X_8163_ _3736_ VGND VGND VPWR VPWR _3737_ sky130_fd_sc_hd__inv_2
X_5375_ net216 net222 net403 net408 VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__and4_1
Xfanout104 _3269_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_2
X_7114_ net241 net431 _2741_ _2742_ VGND VGND VPWR VPWR _2744_ sky130_fd_sc_hd__a22o_1
X_8094_ _3342_ _3664_ _3660_ VGND VGND VPWR VPWR _3668_ sky130_fd_sc_hd__a21o_1
Xfanout126 _3729_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_2
Xfanout137 _3711_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_2
XFILLER_87_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout115 net117 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_2
Xfanout148 _3704_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
Xfanout159 net167 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7045_ _2674_ _2642_ VGND VGND VPWR VPWR _2675_ sky130_fd_sc_hd__nand2b_1
XFILLER_101_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8996_ net517 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__inv_2
XFILLER_103_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7947_ adder_inst.sum_raw_r\[5\] _4341_ net188 adder_inst.sum_raw_r\[3\] net198 VGND
+ VGND VPWR VPWR _3543_ sky130_fd_sc_hd__o221a_1
X_7878_ _3386_ _3415_ _3446_ VGND VGND VPWR VPWR _3484_ sky130_fd_sc_hd__a21oi_1
X_6829_ net324 net468 net473 net317 VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__a22oi_1
XFILLER_50_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_9479_ clknet_leaf_20_clk net660 _0389_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
XFILLER_109_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5160_ _0464_ _0470_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__xnor2_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5091_ _0640_ _0657_ _0719_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a211oi_1
XFILLER_96_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8850_ net659 mul_res\[2\] net505 VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__mux2_1
X_8781_ _2481_ _2514_ _2546_ VGND VGND VPWR VPWR _4288_ sky130_fd_sc_hd__a21o_1
X_7801_ net202 _3406_ VGND VGND VPWR VPWR _3407_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5993_ _1620_ _1621_ _1284_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__o21a_1
X_7732_ adder_inst.exp_a\[5\] adder_inst.exp_a\[4\] adder_inst.exp_a\[7\] adder_inst.exp_a\[6\]
+ VGND VGND VPWR VPWR _3353_ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_96_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4944_ _0567_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand3_1
X_9402_ clknet_leaf_6_clk net569 _0312_ VGND VGND VPWR VPWR adder_inst.exp_b_r\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_7663_ net104 _3290_ VGND VGND VPWR VPWR _3291_ sky130_fd_sc_hd__nand2_1
X_4875_ _0503_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and2b_1
XFILLER_20_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6614_ _2233_ _2235_ _2236_ _2232_ _2231_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__a32o_1
X_7594_ _1153_ _3222_ _1082_ VGND VGND VPWR VPWR _3224_ sky130_fd_sc_hd__a21o_1
X_9333_ clknet_leaf_3_clk net576 _0243_ VGND VGND VPWR VPWR adder_inst.man_b_r\[11\]
+ sky130_fd_sc_hd__dfrtp_4
X_6545_ _2080_ _2081_ _2099_ _2100_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__a2bb2oi_1
X_9264_ clknet_leaf_14_clk adder_inst.sum_raw\[1\] _0174_ VGND VGND VPWR VPWR adder_inst.sum_raw_r\[1\]
+ sky130_fd_sc_hd__dfrtp_4
X_8215_ net138 _3768_ _3787_ net143 VGND VGND VPWR VPWR _3788_ sky130_fd_sc_hd__a211o_1
X_6476_ _1951_ _2105_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__or2_1
X_9195_ clknet_leaf_10_clk net553 _0105_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_76_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5427_ _1051_ _1056_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__nand2_1
X_8146_ net330 adder_inst.man_a_r\[2\] net161 VGND VGND VPWR VPWR _3720_ sky130_fd_sc_hd__mux2_1
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5358_ _4553_ _4559_ _4558_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21o_1
XFILLER_114_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8077_ _3628_ _3652_ net204 VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__o21a_1
XFILLER_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7028_ net228 net234 net442 net448 VGND VGND VPWR VPWR _2658_ sky130_fd_sc_hd__and4_1
X_5289_ _0899_ _0912_ _0918_ _0849_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a211o_1
XFILLER_74_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8979_ net508 VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_87_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout490 adder_inst.sum_raw_r\[22\] VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__buf_2
XFILLER_48_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4660_ net237 net378 net384 net231 VGND VGND VPWR VPWR _4431_ sky130_fd_sc_hd__a22o_1
X_4591_ net353 net346 net211 net218 VGND VGND VPWR VPWR _4362_ sky130_fd_sc_hd__and4_1
X_6330_ _1954_ _1959_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__nor2_1
X_6261_ _1806_ _1887_ _1888_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__and3_1
X_8000_ adder_inst.sum_raw_r\[13\] net496 _3587_ _3588_ _3473_ VGND VGND VPWR VPWR
+ _3589_ sky130_fd_sc_hd__a221o_1
XFILLER_69_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5212_ net215 net221 net435 net440 VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__and4_1
X_6192_ net416 net314 net321 net411 VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__a22oi_1
X_5143_ _0770_ _0771_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or2_1
XFILLER_69_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5074_ net238 net397 net402 net232 VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_71_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8902_ net518 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__inv_2
XFILLER_84_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8833_ _3232_ _4324_ _3244_ VGND VGND VPWR VPWR multiplier_inst.man_final\[15\] sky130_fd_sc_hd__a21oi_1
XFILLER_52_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8764_ net620 _4272_ _0104_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__a21o_1
X_5976_ _1603_ _1604_ _1466_ _1468_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__o211a_1
X_7715_ _3322_ _3338_ VGND VGND VPWR VPWR _3339_ sky130_fd_sc_hd__and2_1
X_8695_ _4043_ _4235_ _4038_ VGND VGND VPWR VPWR _4248_ sky130_fd_sc_hd__o21ai_1
X_4927_ _0535_ _0537_ _0555_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7646_ adder_inst.exp_b_r\[2\] adder_inst.exp_a_r\[2\] _3273_ VGND VGND VPWR VPWR
+ _3274_ sky130_fd_sc_hd__and3_1
X_4858_ _0484_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__xnor2_1
X_9316_ clknet_leaf_7_clk net605 _0226_ VGND VGND VPWR VPWR adder_inst.exp_a_r\[3\]
+ sky130_fd_sc_hd__dfrtp_2
X_7577_ _3029_ _3030_ _3031_ _3033_ VGND VGND VPWR VPWR _3207_ sky130_fd_sc_hd__a211o_1
X_4789_ _4553_ _4558_ _4559_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand3_1
XFILLER_114_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6528_ _2155_ _2157_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__nor2_1
X_9247_ clknet_leaf_3_clk net41 _0157_ VGND VGND VPWR VPWR adder_inst.i_b\[17\] sky130_fd_sc_hd__dfrtp_1
X_6459_ net273 net475 net480 net269 VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__a22o_1
X_9178_ net534 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__inv_2
XFILLER_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8129_ _3700_ _3702_ VGND VGND VPWR VPWR _3703_ sky130_fd_sc_hd__nor2_1
XFILLER_87_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5830_ net264 net271 net420 net425 VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__and4_1
XFILLER_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5761_ net278 net419 VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__and2_1
X_8480_ net391 net171 _3776_ _3979_ VGND VGND VPWR VPWR _4053_ sky130_fd_sc_hd__a22o_1
X_4712_ _4481_ _4482_ VGND VGND VPWR VPWR _4483_ sky130_fd_sc_hd__nor2_1
X_7500_ _3126_ _3129_ VGND VGND VPWR VPWR _3130_ sky130_fd_sc_hd__and2_1
X_7431_ _3059_ _3060_ VGND VGND VPWR VPWR _3061_ sky130_fd_sc_hd__or2_1
X_5692_ net374 net328 VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__nand2_1
X_4643_ _4396_ _4412_ _4413_ VGND VGND VPWR VPWR _4414_ sky130_fd_sc_hd__nand3_1
X_4574_ adder_inst.exp_larger_r\[3\] VGND VGND VPWR VPWR _4346_ sky130_fd_sc_hd__inv_2
X_7362_ _2758_ _2765_ _2990_ VGND VGND VPWR VPWR _2992_ sky130_fd_sc_hd__o21ai_1
X_7293_ net217 net448 net454 net210 VGND VGND VPWR VPWR _2923_ sky130_fd_sc_hd__a22o_1
X_6313_ _1924_ _1941_ _1942_ _1862_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__a211o_1
X_9101_ net525 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__inv_2
X_9032_ net537 VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__inv_2
XFILLER_103_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6244_ _1858_ _1860_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__nor2_1
XFILLER_97_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6175_ _1706_ _1707_ _1710_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__a21o_1
XFILLER_111_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5126_ _0492_ _0493_ _0508_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a21oi_1
XFILLER_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5057_ _0684_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__or2_1
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8816_ _3204_ _3220_ VGND VGND VPWR VPWR _4315_ sky130_fd_sc_hd__nor2_1
XFILLER_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8747_ net716 net186 net185 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__and3_1
X_5959_ net228 net234 net448 net454 VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_23_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8678_ _4108_ net106 _4232_ net181 VGND VGND VPWR VPWR _4233_ sky130_fd_sc_hd__o211a_1
XFILLER_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7629_ net110 _3255_ _3258_ VGND VGND VPWR VPWR _3259_ sky130_fd_sc_hd__o21ai_2
XFILLER_105_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold40 adder_inst.i_b\[13\] VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_42_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold62 adder_inst.i_b\[2\] VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 adder_inst.exp_b\[1\] VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 add_res\[19\] VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold95 add_res\[25\] VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 add_res\[3\] VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 adder_inst.man_a_r\[7\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7980_ adder_inst.sum_raw_r\[13\] net195 net176 adder_inst.sum_raw_r\[12\] net189
+ VGND VGND VPWR VPWR _3572_ sky130_fd_sc_hd__o221a_1
X_6931_ _2411_ _2555_ _2370_ VGND VGND VPWR VPWR _2561_ sky130_fd_sc_hd__o21ai_1
XFILLER_66_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6862_ _2453_ _2455_ VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__xnor2_1
XFILLER_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8601_ _3936_ _4165_ VGND VGND VPWR VPWR adder_inst.sum_raw\[8\] sky130_fd_sc_hd__xnor2_1
X_5813_ _1441_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__and2b_1
XFILLER_22_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6793_ _2420_ _2421_ _2419_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__o21bai_1
X_8532_ _3955_ _3964_ _3967_ _4094_ _3954_ VGND VGND VPWR VPWR _4105_ sky130_fd_sc_hd__a221o_1
XFILLER_50_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5744_ _1342_ _1344_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nand2_1
X_8463_ net165 _4034_ _4035_ VGND VGND VPWR VPWR _4036_ sky130_fd_sc_hd__o21ai_1
X_5675_ _1302_ _1303_ _1304_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nand3_1
X_8394_ _3956_ _3966_ VGND VGND VPWR VPWR _3967_ sky130_fd_sc_hd__nor2_1
X_7414_ net345 net235 _4374_ VGND VGND VPWR VPWR _3044_ sky130_fd_sc_hd__a21oi_1
X_4626_ _4394_ _4396_ VGND VGND VPWR VPWR _4397_ sky130_fd_sc_hd__nand2_1
X_7345_ _2967_ _2974_ _2966_ VGND VGND VPWR VPWR _2975_ sky130_fd_sc_hd__a21o_1
XFILLER_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7276_ _2901_ _2904_ _2905_ VGND VGND VPWR VPWR _2906_ sky130_fd_sc_hd__and3_1
X_9015_ net510 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__inv_2
X_6227_ _1760_ _1761_ _1763_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__a21oi_1
X_6158_ _1785_ _1787_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__and2_1
XFILLER_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5109_ _0737_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_56_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6089_ net394 net400 net334 net338 VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__and4_1
XFILLER_72_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput85 net85 VGND VGND VPWR VPWR o_res[25] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR o_res[15] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput96 net96 VGND VGND VPWR VPWR o_res[6] sky130_fd_sc_hd__buf_2
XFILLER_48_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_106_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5460_ _1059_ _1088_ _0737_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21oi_1
XFILLER_8_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5391_ _0429_ _0434_ _0428_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__a21oi_1
XFILLER_99_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7130_ net210 net217 net454 net460 VGND VGND VPWR VPWR _2760_ sky130_fd_sc_hd__and4_1
XFILLER_113_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout308 net309 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_2
Xfanout319 net320 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__clkbuf_2
X_7061_ _2688_ _2689_ _2687_ VGND VGND VPWR VPWR _2691_ sky130_fd_sc_hd__o21ai_1
XFILLER_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6012_ _1299_ _1639_ _1638_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21o_1
XFILLER_39_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
.ends
